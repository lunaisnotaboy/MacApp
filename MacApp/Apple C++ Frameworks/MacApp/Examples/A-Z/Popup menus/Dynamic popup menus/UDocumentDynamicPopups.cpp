//----------------------------------------------------------------------------------------
// UDocumentDynamicPopups.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/19/01	DoNeedDiskSpace is now const.  Cosmetic.
		01/02/01	Update copyright.
		07/13/00	Stripped out MA_DEFINE_CLASS of TDocumentDynamicPopups.
		12/08/99	Take out MA_DEFINE_CLASS of TDocumentDynamicPopups.
*/

#ifndef __UDocumentDynamicPopups__
#include "UDocumentDynamicPopups.h"
#endif

// MacApp

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UPOPUP__
#include "UPopup.h"
#endif

//----------------------------------------------------------------------------------------
// Constants:

const ResNumber kDynamicPopupsWindowID = kDefaultWindowID;

//========================================================================================
// CLASS TDocumentDynamicPopups
//========================================================================================

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups constructor
//----------------------------------------------------------------------------------------

TDocumentDynamicPopups::TDocumentDynamicPopups(TFile* itsFile,
										  OSType itsCreator) :
TFileBasedDocument(itsFile,itsCreator)
{
} // TDocumentDynamicPopups::TDocumentDynamicPopups

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups destructor
//----------------------------------------------------------------------------------------

TDocumentDynamicPopups::~TDocumentDynamicPopups()
{
}

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::FreeData:
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::FreeData()
{
	TFileBasedDocument::FreeData();
} // TDocumentDynamicPopups::FreeData

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::DoInitialState:
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::DoInitialState()
{
	TFileBasedDocument::DoInitialState();
} // TDocumentDynamicPopups::DoInitialState

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::DoMakeViews:
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::DoMakeViews(bool /*forPrinting*/)
{
	TWindow* aWindow = gViewServer->NewTemplateWindow(kDynamicPopupsWindowID, this);
	::ThrowIfNULL_AC(aWindow);

	TView* aView = aWindow->FindSubView('MENU');
	TPopup* aPopup = dynamic_cast<TPopup*>(aView);
	::ThrowIfNULL_AC(aPopup);

	aPopup->CreateMenu();
	aPopup->AddItem("Hello there");
	aPopup->AddItem("All righty then");
	aPopup->AddItem("Toggle Menu Bar");	// 3rd item will actually do stuff
	aPopup->AddSeparator();

	// This is the dynamic part: we add the document's name to the end
	// so it's unique per instance of the popup
	aPopup->AddItem(aWindow->GetTitle());

	aPopup->SetCurrentItem(5, kRedraw);
} // TDocumentDynamicPopups::DoMakeViews

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::DoNeedDiskSpace:
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::DoEvent(EventNumber eventNumber,
							TEventHandler* source,
							TEvent* event)
{
	if (eventNumber == mPopupHit)
	{
		TPopup* aPopup = dynamic_cast<TPopup*> (source);
		if (aPopup)
		{
			switch (aPopup->GetCurrentItem())
			{
				case 3:
					if (TMenuBarManager::fgMenuBarManager->IsMenuBarShown())
						TMenuBarManager::fgMenuBarManager->HideMenuBar();
					else
						TMenuBarManager::fgMenuBarManager->ShowMenuBar();
					break;

				default: ;
			}
		}
	}
	else
		TFileBasedDocument::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::DoNeedDiskSpace:
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::DoNeedDiskSpace(TFile* itsFile,
										long& dataForkBytes,
										long& rsrcForkBytes) const
{
	TFileBasedDocument::DoNeedDiskSpace(itsFile, dataForkBytes, rsrcForkBytes);
} // TDocumentDynamicPopups::DoNeedDiskSpace

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::DoMenuCommand: This method is overridden to handle menu items which
// are enabled when this document is in the target chain. In this example, this is true
// when the document is open and its window is the active window. The inherited method
// should always be called so that MacApp can allow successor objects in the target chain
// (i.e. the application) to handle THEIR menu items.
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::DoMenuCommand(CommandNumber aCommandNumber)
{
	switch (aCommandNumber)
	{
		/*	Typically, you will have dispatch your own menu commands here:
		case cCommandHandledByDocument:
			{
				TCommandDynamicPopups* aCommand = new TCommandDynamicPopups;
				aCommand->ICommandDynamicPopups(aCommandNumber, this);
				this->PostCommand(aCommand);
			}
			break;
		*/
		default:
			TFileBasedDocument::DoMenuCommand(aCommandNumber);
			break;
	}
} // TDocumentDynamicPopups::DoMenuCommand

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::DoRead:
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::DoRead(TFile* aFile,
						   	   bool forPrinting)
{
	TFileBasedDocument::DoRead(aFile,forPrinting);
} // TDocumentDynamicPopups::DoRead

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::DoSetupMenus: This method is overridden to enable menu items which
// should be enabled when this object is in the target chain. MacApp initially disables
// all menu items, then lets the objects in the target chain enable those items they
// handle.
//
// A document object is in the target chain when its window is the active window.
//
// The inherited method is called so that TDocument can enable document-level menu items
// like "Save ". This also ensures that objects further up the target chain (the
// application) can set up THEIR menus.
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::DoSetupMenus()
{
	TFileBasedDocument::DoSetupMenus();

	/*	Typically, you will have enable your own menu commands here:
	Enable(cCommandHandledByDocument,true);
	*/
} // TDocumentDynamicPopups::DoSetupMenus

//----------------------------------------------------------------------------------------
// TDocumentDynamicPopups::DoWrite:
//----------------------------------------------------------------------------------------

void TDocumentDynamicPopups::DoWrite(TFile* aFile,
									bool makingCopy)
{
	TFileBasedDocument::DoWrite(aFile,makingCopy);
} // TDocumentDynamicPopups::DoWrite

//----------------------------------------------------------------------------------------
// End of UDocumentDynamicPopups.cp

