//----------------------------------------------------------------------------------------
// UKnobControl.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/08/99	Include UNumberText.h to get TNumberText.  Prevent redraw
					in SetNumber.
		08/17/99	Change obsoleted macros to ACS versions. 
		03/24/99	Update copyright notice.
*/

#ifndef __UKnobControl__
#include "UKnobControl.h"
#endif

// MacApp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UNUMBERTEXT__
#include "UNumberText.h"
#endif

//========================================================================================
// GLOBAL Functions
//========================================================================================

void InitUKnobControl()
{
	if (qTemplateViews)
	{
		REGISTER_CLASS_AC(TKnobControl);
		REGISTER_CLASS_AC(TKnobCluster);
	}
}  


//========================================================================================
// CLASS TKnobControl
//========================================================================================
#undef Inherited
#define Inherited TSpriteControl

MA_DEFINE_CLASS(TKnobControl);

//----------------------------------------------------------------------------------------
// TKnobControl destructor
//----------------------------------------------------------------------------------------

TKnobControl::~TKnobControl()
{
}

//----------------------------------------------------------------------------------------
// TKnobControl::MouseIndex:
//----------------------------------------------------------------------------------------

short TKnobControl::MouseIndex(const CViewPoint& nextPoint) // override
{
	CRect_AC extent(GetExtent().AsRect());
	CPoint_AC point(nextPoint.AsPoint());
	short angle;
	PtToAngle(&extent, point, &angle);
	angle += 180;
	if (angle > 360)
		angle -= 360;

	enum
	{
		kFirstAngle = 40,
		kLastAngle = 320,
		kArcLength = kLastAngle - kFirstAngle
	};

	if (angle < kFirstAngle)
		angle = kFirstAngle;
	else if (angle > kLastAngle)
		angle = kLastAngle;

	short index = ((long) (angle - kFirstAngle) * (fImageCount - 1)) / kArcLength + 1;

	return index;
}


//========================================================================================
// CLASS TKnobCluster
//========================================================================================
#undef Inherited
#define Inherited TCluster

MA_DEFINE_CLASS(TKnobCluster);

//----------------------------------------------------------------------------------------
// TKnobCluster destructor
//----------------------------------------------------------------------------------------

TKnobCluster::~TKnobCluster()
{
}

//----------------------------------------------------------------------------------------
// TKnobCluster::DoEvent: 
//----------------------------------------------------------------------------------------

void TKnobCluster::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event) // override
{
	switch (eventNumber)
	{
		case mControlHit:
			{
				SetNumber(GetKnob(), kRedraw);
				HandleEvent(fEventNumber, this, NULL);
			}
			break;

		case mEditTextHit:
		case cTyping:
			{
				SetKnob(GetNumber(), kRedraw);
				//SetNumber(GetKnob(), kRedraw);
				HandleEvent(fEventNumber, this, NULL);
			}
			break;

		default:
			Inherited::DoEvent(eventNumber, source, event);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TKnobCluster::GetKnob: 
//----------------------------------------------------------------------------------------

long TKnobCluster::GetKnob() const
{
	TKnobControl* knob = dynamic_cast_AC(TKnobControl*, FindSubView('knob'));
	ThrowIfNonObject_AC(knob);
	return (knob->GetValue());
}

//----------------------------------------------------------------------------------------
// TKnobCluster::SetKnob: 
//----------------------------------------------------------------------------------------

void TKnobCluster::SetKnob(long newValue, bool	redraw)
{
	TKnobControl* knob = dynamic_cast_AC(TKnobControl*, FindSubView('knob'));
	ThrowIfNonObject_AC(knob);
	knob->SetValue(newValue, redraw);
}

//----------------------------------------------------------------------------------------
// TKnobCluster::GetNumber: 
//----------------------------------------------------------------------------------------

long TKnobCluster::GetNumber() const
{
	TNumberText* numberText = dynamic_cast_AC(TNumberText*, FindSubView('Numb'));
	ThrowIfNonObject_AC(numberText);
	return (numberText->GetValue());
}

//----------------------------------------------------------------------------------------
// TKnobCluster::SetNumber: 
//----------------------------------------------------------------------------------------

void TKnobCluster::SetNumber(long newValue, bool	redraw)
{
	TNumberText* numberText = dynamic_cast_AC(TNumberText*, FindSubView('Numb'));
	ThrowIfNonObject_AC(numberText);
	if (newValue != numberText->GetValue())
		numberText->SetValue(newValue, redraw);
}


//----------------------------------------------------------------------------------------
// End of UKnobControl.cpp
