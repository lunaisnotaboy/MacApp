//----------------------------------------------------------------------------------------
// UDemoSprite.cp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		07/13/00	Stripped out MA_DEFINE_CLASS of TDemoSpriteApplication.
		12/08/99	Took out MA_DEFINE_CLASS of TDemoSpriteApplication.
		03/24/99	Update copyright notice.
*/

// SimpleSizer

#ifndef __UDemoSprite__
#include "UDemoSprite.h"
#endif

// MacApp

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

//----------------------------------------------------------------------------------------
// Constants:

const CommandNumber cFirstWindow = 2001;
const CommandNumber cLastWindow = 2001;

const CommandNumber cFirstDialog = -1;
const CommandNumber cLastDialog = -1;

//========================================================================================
// CLASS TDemoSprite
//========================================================================================

//----------------------------------------------------------------------------------------
// TDemoSpriteApplication::DoMenuCommand
//----------------------------------------------------------------------------------------
void TDemoSpriteApplication::DoMenuCommand(CommandNumber aCommandNumber)
{
	bool	done = false;
	
	// Convert cFinderNew into the main window.
	if (aCommandNumber == cFinderNew)
		aCommandNumber = (cFirstWindow != -1) ? cFirstWindow : cFirstDialog;

	// Try to make a new window based on the command number.
	if (aCommandNumber >= cFirstWindow && aCommandNumber <= cLastWindow)
		done = MakeAWindow(aCommandNumber);
	else if (aCommandNumber >= cFirstDialog && aCommandNumber <= cLastDialog)
		done = PoseAWindow(aCommandNumber);
	
	if (!done)
		TApplication::DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// TDemoSpriteApplication::DoSetupMenus
//----------------------------------------------------------------------------------------
void TDemoSpriteApplication::DoSetupMenus()
{
	TApplication::DoSetupMenus();				// Always call the inherited method first
	if (cFirstWindow != -1)
		for (CommandNumber theCommandNum = cFirstWindow; theCommandNum <= cLastWindow; theCommandNum++)
			::Enable(theCommandNum, true);
	if (cFirstDialog != -1)
		for (CommandNumber theCommandNum = cFirstDialog; theCommandNum <= cLastDialog; theCommandNum++)
			::Enable(theCommandNum, true);
}

//----------------------------------------------------------------------------------------
// TDemoSpriteApplication::MakeAWindow
//----------------------------------------------------------------------------------------
bool TDemoSpriteApplication::MakeAWindow(CommandNumber aWindowNumber)
{
	bool	windowMade = false;
	// Try to make a new window based on the command number.
	if (aWindowNumber >= cFirstWindow && aWindowNumber <= cLastWindow)
	{
		TWindow* aWindow = gViewServer->NewTemplateWindow(aWindowNumber, NULL);
		::ThrowIfNULL_AC(aWindow);
		/*
		TSSView* aSSView = (TSSView*) (aWindow->FindSubView('SKEL'));

		TStdPrintHandler* aHandler = TH_new TStdPrintHandler(this,		// its document 
								   aSSView,	// its view 
								   kFixedSize,		// horzontal page size is fixed 
								   kFixedSize);		// vertical page size is fixed
		*/
		aWindow->Open();
		windowMade = true;
	}

	return windowMade;
}

//----------------------------------------------------------------------------------------
// TDemoSpriteApplication::PoseAWindow
//----------------------------------------------------------------------------------------
bool TDemoSpriteApplication::PoseAWindow(CommandNumber aWindowNumber)
{
	bool	windowMade = false;
	if (aWindowNumber >= cFirstDialog && aWindowNumber <= cLastDialog)
	{
		TWindow* aWindow = gViewServer->NewTemplateWindow(aWindowNumber, NULL);
		::ThrowIfNULL_AC(aWindow);
		
		aWindow->PoseModally();
		windowMade = true;
	}
	return windowMade;
}

//----------------------------------------------------------------------------------------
// End of UDemoSprite.cp


