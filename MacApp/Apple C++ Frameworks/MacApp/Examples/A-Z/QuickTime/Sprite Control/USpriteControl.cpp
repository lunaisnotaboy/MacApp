//----------------------------------------------------------------------------------------
// USpriteControl.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/23/99	TSpriteControl::LoadSprites():
							  Carbon: In LockPixels, no longer need to cast.
							  For LockPixels, use GetGWorldPixMap instead of direct access.
		08/17/99	Change obsoleted macros to ACS versions. 
		03/24/99	Update copyright notice.
*/

#ifndef __USPRITECONTROL__
#include "USpriteControl.h"
#endif

// MacApp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

// Mac OS names are our preference, so remap conflicting ones
#if qMSWindows
#	ifndef __QTMLMAPNAMES__
#		include "QTMLMapNames.h"
#	endif
#endif

//========================================================================================
// GLOBAL Functions
//========================================================================================

void InitUSpriteControl()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TSpriteControl, 'sprt');
	}
}  


//========================================================================================
// CLASS TSpriteControl
//========================================================================================
#undef Inherited
#define Inherited TControl

MA_DEFINE_CLASS(TSpriteControl);

//----------------------------------------------------------------------------------------
// TSpriteControl constructor
//----------------------------------------------------------------------------------------

TSpriteControl::TSpriteControl() :
	TControl(),
	fRsrcID(kNoResource),
	fDataHandle(nil),
	fImageDescription(nil),
	fSpritePlane(nil),
	fSpriteWorld(nil),
	fImageCount(0),
	fImageIndex(0)
{
	fEventNumber = mControlHit;
}


//----------------------------------------------------------------------------------------
// TSpriteControl constructor
//----------------------------------------------------------------------------------------

TSpriteControl::TSpriteControl(const CViewPoint& itsLocation,
							   const CViewPoint& itsSize,
							   SizeDeterminer itsHSizeDet,
							   SizeDeterminer itsVSizeDet,
							   ResNumber itsRsrcID) :
	TControl(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
	fRsrcID(kNoResource),
	fDataHandle(nil),
	fImageDescription(nil),
	fSpritePlane(nil),
	fSpriteWorld(nil),
	fImageCount(0),
	fImageIndex(0)
{
	fEventNumber = mControlHit;

	SetRsrcID(itsRsrcID, kDontRedraw);
}


//----------------------------------------------------------------------------------------
// TSpriteControl copy constructor
//----------------------------------------------------------------------------------------

TSpriteControl::TSpriteControl(const TSpriteControl& inControl) :
	fRsrcID(kNoResource),
	fDataHandle(nil),
	fImageDescription(nil),
	fSpritePlane(nil),
	fSpriteWorld(nil),
	fImageCount(0),
	fImageIndex(0)
{
	if (inControl.fDataHandle)
		SetRsrcID(inControl.fRsrcID, kDontRedraw);
}


//----------------------------------------------------------------------------------------
// TSpriteControl destructor
//----------------------------------------------------------------------------------------

TSpriteControl::~TSpriteControl()
{
	ReleaseData();
}

//----------------------------------------------------------------------------------------
// TSpriteControl::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TSpriteControl::GetStandardSignature() const // override
{
	return 'sprt';
}

//----------------------------------------------------------------------------------------
// TSpriteControl::ReadFields: 
//----------------------------------------------------------------------------------------

void TSpriteControl::ReadFields(CStream_AC* aStream) // override
{
	Inherited::ReadFields(aStream);

	ResNumber itsRsrcID = aStream->ReadInteger();
	SetRsrcID(itsRsrcID, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TSpriteControl::WriteFields: 
//----------------------------------------------------------------------------------------

void TSpriteControl::WriteFields(CStream_AC* aStream) const // override
{
	Inherited::WriteFields(aStream);

	aStream->WriteInteger(fRsrcID);
}

//----------------------------------------------------------------------------------------
// TSpriteControl::BeInPort:
//----------------------------------------------------------------------------------------

void TSpriteControl::BeInPort(GrafPtr itsPort) // override
{
	UnloadSprites();

	Inherited::BeInPort(itsPort); // override

	LoadSprites();
}

//----------------------------------------------------------------------------------------
// TSpriteControl::ReleaseData: 
//----------------------------------------------------------------------------------------

void TSpriteControl::ReleaseData()
{
	UnloadSprites();
	fRsrcID = kNoResource;
	if (fImageDescription)
	{
		DisposeHandle((Handle)fImageDescription);
		fImageDescription = nil;
	}
	if (fDataHandle)
	{
		QTUnlockContainer(fDataHandle);
		HPurge(fDataHandle);
		fDataHandle = nil;
	}
}

//----------------------------------------------------------------------------------------
// TSpriteControl::UnloadSprites: 
//----------------------------------------------------------------------------------------

void TSpriteControl::UnloadSprites()
{
	fSprite = nil;
	if (fSpriteWorld)
	{
		DisposeSpriteWorld(fSpriteWorld);
		fSpriteWorld = nil;
	}
	if (fSpritePlane)
	{
		DisposeGWorld(fSpritePlane);
		fSpritePlane = nil;
	}
}

//----------------------------------------------------------------------------------------
// TSpriteControl::SetRsrcID: 
//----------------------------------------------------------------------------------------

void TSpriteControl::SetRsrcID(ResNumber itsRsrcID, bool redraw)
{
	ReleaseData();

	fRsrcID = itsRsrcID;

	if (fRsrcID != kNoResource)
	{
		fDataHandle = GetResource('sprt', fRsrcID);
		::ThrowIfNULLResource_AC(fDataHandle);

		LoadSprites();
	}

	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TSpriteControl::LoadSprites: 
//----------------------------------------------------------------------------------------

void TSpriteControl::LoadSprites()
{
#if qCarbon
	CGrafPtr destination = GetGrafPort();
#else
	CGrafPort* destination = reinterpret_cast<CGrafPort*>(GetGrafPort());
#endif
	if (destination && fDataHandle)
	{
		MoveHHi(fDataHandle);
		QTLockContainer(fDataHandle);

		QTAtom defaultsAtom = QTFindChildByIndex( fDataHandle, 0, kSpriteSharedDataAtomType, 1, nil );
		if (!defaultsAtom)
			ThrowIfOSErr_AC(cannotFindAtomErr);
			
		QTAtom imagesContainerAtom = QTFindChildByIndex( fDataHandle, defaultsAtom, kSpriteImagesContainerAtomType, 1, nil );
		if (!imagesContainerAtom)
			ThrowIfOSErr_AC(cannotFindAtomErr);

		fImageCount = QTCountChildrenOfType( fDataHandle, imagesContainerAtom, kSpriteImageAtomType );

		QTAtom imageAtom = QTFindChildByIndex( fDataHandle, imagesContainerAtom, kSpriteImageAtomType, 1, nil );
		if (!imageAtom)
			ThrowIfOSErr_AC(cannotFindAtomErr);

		QTAtom imageDataAtom = QTFindChildByIndex( fDataHandle, imageAtom, kSpriteImageDataAtomType, 1, nil );
		if (!imageDataAtom)
			ThrowIfOSErr_AC(cannotFindAtomErr);

		fImageDescription = (ImageDescriptionHandle) NewPermHandle( sizeof(ImageDescription) );
		ThrowIfNULL_AC( fImageDescription );
		ThrowIfOSErr_AC( QTCopyAtomDataToHandle( fDataHandle, imageDataAtom, (Handle) fImageDescription ) );
		SetHandleSize((Handle) fImageDescription, (*fImageDescription)->idSize);

		ImageDescriptionPtr imageDesc = nil;
		ThrowIfOSErr_AC( QTGetAtomDataPtr( fDataHandle, imageDataAtom, nil, (Ptr *) &imageDesc ) );
		Ptr imageData = (Ptr) imageDesc + imageDesc->idSize;
		
		CRect_AC bounds(0, 0, (*fImageDescription)->width, (*fImageDescription)->height);
		NewGWorld(&fSpritePlane, 16, &bounds, nil, nil, useTempMem);
		if (!fSpritePlane)
			NewGWorld(&fSpritePlane, 16, &bounds, nil, nil, 0);

		ThrowIfNULL_AC(fSpritePlane);
		LockPixels(GetGWorldPixMap(fSpritePlane));
		
		CRGBColor_AC backgroundColor(CRGBColor_AC::kRGBWhite);
		if (fDrawingEnvironment)
			backgroundColor = fDrawingEnvironment->fBackgroundColor;

		ThrowIfOSErr_AC(NewSpriteWorld(&fSpriteWorld, destination, fSpritePlane, &backgroundColor, nil));

		MatrixRecord matrix;
		CRect_AC frame(0, 0, fSize.h, fSize.v);
		if (frame != bounds)
		{
			RectMatrix(&matrix, &bounds, &frame);
			ThrowIfOSErr_AC(SetSpriteWorldMatrix(fSpriteWorld, &matrix));
		}

		SetIdentityMatrix(&matrix);
		ThrowIfOSErr_AC(NewSprite(&fSprite, fSpriteWorld, fImageDescription, imageData, &matrix, true, 1));

		fImageIndex = 1;
	}
}

//----------------------------------------------------------------------------------------
// TSpriteControl::SetValue: 
//----------------------------------------------------------------------------------------

void TSpriteControl::SetValue(short newVal, bool redraw)
{
	if (fSprite && fDataHandle && (fImageIndex != newVal))
	{
		if (newVal <= 0)
			newVal = 1;
		else if (newVal > fImageCount)
			newVal = fImageCount;

		QTAtom defaultsAtom = QTFindChildByIndex( fDataHandle, 0, kSpriteSharedDataAtomType, 1, nil );
		if (!defaultsAtom)
			ThrowIfOSErr_AC(cannotFindAtomErr);
			
		QTAtom imagesContainerAtom = QTFindChildByIndex( fDataHandle, defaultsAtom, kSpriteImagesContainerAtomType, 1, nil );
		if (!imagesContainerAtom)
			ThrowIfOSErr_AC(cannotFindAtomErr);

		QTAtom imageAtom = QTFindChildByIndex( fDataHandle, imagesContainerAtom, kSpriteImageAtomType, newVal, nil );
		if (!imageAtom)
			ThrowIfOSErr_AC(cannotFindAtomErr);

		QTAtom imageDataAtom = QTFindChildByIndex( fDataHandle, imageAtom, kSpriteImageDataAtomType, 1, nil );
		if (!imageDataAtom)
			ThrowIfOSErr_AC(cannotFindAtomErr);

		ImageDescriptionPtr imageDesc = nil;
		ThrowIfOSErr_AC( QTGetAtomDataPtr( fDataHandle, imageDataAtom, nil, (Ptr *) &imageDesc ) );
		Ptr imageData = (Ptr) imageDesc + imageDesc->idSize;
		ThrowIfOSErr_AC(SetSpriteProperty(fSprite, kSpritePropertyImageDataPtr, imageData));

		fImageIndex = newVal;

		if (redraw)
			ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TSpriteControl::SetFrame:
//----------------------------------------------------------------------------------------

void TSpriteControl::SetFrame(const CViewRect& newFrame, bool invalidate) // override
{
	CViewRect oldFrame(GetFrame());

	if (newFrame != oldFrame)
	{
		Inherited::SetFrame(newFrame, invalidate);

		if (fImageDescription && fSpriteWorld)
		{
			CRect_AC bounds(0, 0, (*fImageDescription)->width, (*fImageDescription)->height);
			CRect_AC frame(0, 0, fSize.h, fSize.v);
			if (frame != bounds)
			{
				MatrixRecord matrix;
				RectMatrix(&matrix, &bounds, &frame);
				ThrowIfOSErr_AC(SetSpriteWorldMatrix(fSpriteWorld, &matrix));
			}
		}
	}
}

//----------------------------------------------------------------------------------------
// TSpriteControl::Draw: 
//----------------------------------------------------------------------------------------

void TSpriteControl::Draw(const CViewRect& area) // override
{
	if (fSpriteWorld)
	{
		OSErr ignore;
		CRect_AC areaQD(ViewToQD(area));
		ignore = InvalidateSpriteWorld(fSpriteWorld, areaQD);
		ignore = SpriteWorldIdle(fSpriteWorld, 0, nil);
	}
	Inherited::Draw(area);
}

//----------------------------------------------------------------------------------------
// TSpriteControl::TrackMouse:
//----------------------------------------------------------------------------------------

void TSpriteControl::TrackMouse(TrackPhase aTrackPhase,
								CViewPoint& anchorPoint,
								CViewPoint& previousPoint,
								CViewPoint& nextPoint,
								bool mouseDidMove)
{
#pragma unused (anchorPoint, previousPoint, mouseDidMove)

	switch (aTrackPhase)
	{
		case trackBegin:
			break;
		case trackContinue:
			{
				short index = MouseIndex(nextPoint);
				SetValue(index, kDontRedraw);
				OSErr ignore = SpriteWorldIdle(fSpriteWorld, 0, nil);
				HandleEvent(fEventNumber, this, NULL);
			}
			break;
		case trackEnd:
			if (ContainsMouse(nextPoint))
				HandleEvent(fEventNumber, this, NULL);
			break;
	}
}


//----------------------------------------------------------------------------------------
// TSpriteControl::MouseIndex:
//----------------------------------------------------------------------------------------

short TSpriteControl::MouseIndex(const CViewPoint& nextPoint)
{
	ViewCoordinate h = nextPoint.h;
	if (h < 0)
		h = 0;
	else if (h > fSize.h)
		h = fSize.h;

	short index = (h * (fImageCount - 1)) / fSize.h + 1;

	return index;
}


//----------------------------------------------------------------------------------------
// End of USpriteControl.cpp