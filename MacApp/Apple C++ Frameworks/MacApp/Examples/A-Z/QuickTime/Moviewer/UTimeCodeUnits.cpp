//----------------------------------------------------------------------------------------
// UTimeCodeUnits.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/03/01	Universal interfaces 3.4b3 define AECoercionHandlerUPP as a
							AECoerceDescUPP rather than a UniversalProcPtr. This is good,
							but it means we no longer need to define a AECoerceDescUPP 
							flavor of AERemoveCoercionHandler. 
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		07/24/00	CW Pro 6: namespacing. 
		03/17/00	Need the type safe versions of AERemoveCoercionHandler for 
							Carbon as well as 68K. 
		03/15/00	Change GetKeyData to GetUnitData. The object specifier doesn't
							have to be exactly the type we want if we can coerce it. 
		02/22/00	Include AEPackObject and stdio for non-debug builds. 
							Add some glue for the casting required by AERemoveCoercionHandler. 
							Go through AECoercePtr instead of calling WildToTimeCode, so
							conversions like seconds to frames will work. 
		02/18/00	Initial version. 
*/

#ifndef __UTimeCodeUnits__
#include "UTimeCodeUnits.h"
#endif

// Moviewer

#ifndef __UAEUtils__
#include "UAEUtils.h"
#endif

// MacApp

#ifndef __USCRIPTING__
#include "UScripting.h"
#endif

// ACS

#ifndef __Bail_AC__
#include "Bail_AC.h"
#endif

#ifndef __CFixedPoint_AC__
#include "CFixedPoint_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __TemplateUPP_AC__
#include "TemplateUPP_AC.h"
#endif

// Toolbox

#ifndef __AEDATAMODEL__
#include <AEDataModel.h>
#endif

#ifndef __AEPACKOBJECT__
#include <AEPackObject.h>
#endif

#ifndef __AEREGISTRY__
#include <AERegistry.h>
#endif

#ifndef __ASREGISTRY__
#include <ASRegistry.h>
#endif

#ifndef __FIXMATH__
#include <FixMath.h>
#endif

#ifndef __FP__
#include <fp.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// ANSI

#ifndef _STDIO_H
#include <stdio.h>
#endif

using std::floor;

//----------------------------------------------------------------------------------------
// GLOBAL Variables
//----------------------------------------------------------------------------------------

//TemplateTempUPP_AC<OSLAccessorUPP, OSLAccessorProcPtr> pUnitAccessorUPP;
CTempAECoerceDescUPP pWildToUnitUPP;
CTempAECoercePtrUPP pUnitToWildUPP;
CTempAECoercePtrUPP pBaseToUnitUPP;
CTempAECoercePtrUPP pUnitToBaseUPP;

long gFramesPerSecond = 25;

enum { kInSystem = true };

//========================================================================================
// Global Functions
//========================================================================================

void InitUTimeCodeUnits()
{
	static TTimeCodeUnit pTimeCodeUnit(typeTimeCode);
	static TFramesUnit pFramesUnit(typeFrames);
	static TSecondsUnit pSecondsUnit(typeSeconds);
}

//----------------------------------------------------------------------------------------
// ThrowError
//----------------------------------------------------------------------------------------

inline void ThrowError(OSErr error)
// Just throws an exception. No debug strings. 
{
	throw CException_AC(error);
}

//----------------------------------------------------------------------------------------
// ThrowIfOSErr
//----------------------------------------------------------------------------------------

static void ThrowIfOSErr(OSErr error)
// If there is an error, just throws an exception. No debug strings. 
{
	if (error != noErr)
		ThrowError(error);
}

//----------------------------------------------------------------------------------------
// AERemoveCoercionHandler
//----------------------------------------------------------------------------------------

#if TARGET_CARBON || !TARGET_RT_MAC_CFM

#if UNIVERSAL_INTERFACES_VERSION < 0x0337

inline OSErr AERemoveCoercionHandler(DescType fromType, DescType toType,
									 AECoerceDescUPP handler, Boolean isSysHandler)
{
	return AERemoveCoercionHandler(fromType, toType, (AECoercionHandlerUPP)handler, isSysHandler);
}

#endif // UNIVERSAL_INTERFACES_VERSION < 0x0337

inline OSErr AERemoveCoercionHandler(DescType fromType, DescType toType,
									 AECoercePtrUPP handler, Boolean isSysHandler)
{
	return AERemoveCoercionHandler(fromType, toType, (AECoercionHandlerUPP)handler, isSysHandler);
}

#endif // !TARGET_RT_MAC_CFM

//----------------------------------------------------------------------------------------
// GetUnitData
//----------------------------------------------------------------------------------------

static CAEDesc_AC GetUnitData(const CAEDesc_AC& fromObjectSpec)
// Get unit data that has been packaged as an object specifier. 
{
	CTempDesc_AC record(fromObjectSpec.Coerce(typeAERecord));

	DescType typeCode;
	Size actualSize;
	
	DescType desiredClass = 0;
	ThrowIfOSErr(record.GetKeyPtr(keyAEDesiredClass, typeWildCard, &typeCode, &desiredClass, sizeof(desiredClass), &actualSize));

	CTempDesc selectionData;
	ThrowIfOSErr(AEGetKeyDesc(record, keyAEKeyData, typeWildCard, &selectionData));
	
	// Coerce the selection data to the desired unit type
	if (selectionData.descriptorType != desiredClass)
		selectionData.reset(selectionData.CoerceDesc(desiredClass));

	return selectionData.release();
}

//========================================================================================
// TTimeCodeUnit
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

TTimeCodeUnit::TTimeCodeUnit(DescType unitID)
	:	fUnitID(unitID)
{
	Install();
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

TTimeCodeUnit::~TTimeCodeUnit()
{
	Remove();
}

//----------------------------------------------------------------------------------------
// Install
//----------------------------------------------------------------------------------------

void TTimeCodeUnit::Install()
{
	if (!pWildToUnitUPP)
		pWildToUnitUPP = WildToUnitProc;

	if (!pUnitToWildUPP)
		pUnitToWildUPP = UnitToWildProc;

	InstallCoerceDescHandler(typeWildCard, fUnitID, pWildToUnitUPP, (long)this, kInSystem);
	InstallCoercePtrHandler(fUnitID, typeWildCard, pUnitToWildUPP, (long)this, kInSystem);

//	if (!pUnitAccessorUPP)
//		pUnitAccessorUPP = UnitAccessorProc;
//
//	ThrowIfOSErr(AEInstallObjectAccessor(typeWildCard, fUnitID, pUnitAccessorUPP, (long)this, kInSystem));
}

//----------------------------------------------------------------------------------------
// Remove
//----------------------------------------------------------------------------------------

void TTimeCodeUnit::Remove()
{
	OSErr err = noErr;
	err = AERemoveCoercionHandler(typeWildCard, fUnitID, pWildToUnitUPP, kInSystem);
	err = AERemoveCoercionHandler(fUnitID, typeWildCard, pUnitToWildUPP, kInSystem);
//	err = AERemoveObjectAccessor(typeWildCard, fUnitID, pUnitAccessorUPP, kInSystem);
}

//----------------------------------------------------------------------------------------
// WildToTimeCode
//----------------------------------------------------------------------------------------

TimeCodeTime TTimeCodeUnit::WildToTimeCode(const CAEDesc_AC& fromDesc) const
{
	TimeCodeTime timeCode = {0, 0, 0, 0};

	switch (fromDesc.descriptorType)
	{
		case typeTimeCode:
			{
				timeCode = CAETimeCodeTime(fromDesc);
			}
			break;

		case typeChar:
			{
				char line[64];
#if qCarbon
				Size len = Min_AC(AEGetDescDataSize(fromDesc), sizeof(line) - 1);
				AEGetDescData(fromDesc, line, sizeof(line));
				line[len] = 0;
#else
				Size len = Min_AC(GetHandleSize(fromDesc.dataHandle), sizeof(line) - 1);
				BlockMove_AC(*fromDesc.dataHandle, line, len);
				line[len] = 0;
#endif
				sscanf(line, "%02d:%02d:%02d:%02d", timeCode.hours, timeCode.minutes, 
					   timeCode.seconds, timeCode.frames);
			}
			break;

		case typeAEList:
			{
				if (fromDesc.CountListItems() != 4)
					ThrowError(errAECoercionFail);
				
				DescType typeCode;
				Size actualSize;
				short temp;

				fromDesc.GetNthPtr(1, typeShortInteger, &typeCode, &temp, sizeof(temp), &actualSize);
				timeCode.hours = temp;

				fromDesc.GetNthPtr(2, typeShortInteger, &typeCode, &temp, sizeof(temp), &actualSize);
				timeCode.minutes = temp;

				fromDesc.GetNthPtr(3, typeShortInteger, &typeCode, &temp, sizeof(temp), &actualSize);
				timeCode.seconds = temp;

				fromDesc.GetNthPtr(4, typeShortInteger, &typeCode, &temp, sizeof(temp), &actualSize);
				timeCode.frames = temp;
			}
			break;

		case typeAERecord:
			{
				DescType typeCode;
				Size actualSize;
				short temp;

				fromDesc.GetKeyPtr(typeHours, typeShortInteger, &typeCode, &temp, sizeof(temp), &actualSize);
				timeCode.hours = temp;

				fromDesc.GetKeyPtr(typeMinutes, typeShortInteger, &typeCode, &temp, sizeof(temp), &actualSize);
				timeCode.minutes = temp;

				fromDesc.GetKeyPtr(typeSeconds, typeShortInteger, &typeCode, &temp, sizeof(temp), &actualSize);
				timeCode.seconds = temp;

				fromDesc.GetKeyPtr(typeFrames, typeShortInteger, &typeCode, &temp, sizeof(temp), &actualSize);
				timeCode.frames = temp;
			}
			break;

		case typeObjectSpecifier:
			{
				CTempDesc_AC selectionData = GetUnitData(fromDesc);
				timeCode = WildToTimeCode(selectionData);
			}
			break;

		default:
			ThrowError(errAECoercionFail);
			break;
	};

	return timeCode;
}

//----------------------------------------------------------------------------------------
// TimeCodeToWild
//----------------------------------------------------------------------------------------

CAEDesc_AC TTimeCodeUnit::TimeCodeToWild(const TimeCodeTime& timeCode, DescType toType) const
{
	CAEDesc_AC result;

	switch (toType)
	{
		case typeTimeCode:
			result.Set(typeTimeCode, &timeCode, sizeof(timeCode));
			break;
		
		case typeAEList:
			result = TimeCodeToList(timeCode);
			break;
		
		case typeAERecord:
			// We don't want this to happen. 
			ThrowError(errAECoercionFail);
			//result = TimeCodeToRecord(timeCode);
			break;
		
		case typeChar:
			result = TimeCodeToString(timeCode);
			break;
		
		case typeObjectSpecifier:
			result = TimeCodeToSpec(timeCode);
			break;

		default:
			ThrowError(errAECoercionFail);
			break;
	};

	return result;
}

//----------------------------------------------------------------------------------------
// TimeCodeToList
//----------------------------------------------------------------------------------------

CAEDesc_AC TTimeCodeUnit::TimeCodeToList(const TimeCodeTime& timeCode) const
{
	CTempDesc_AC result;

	result.CreateList();
	
	short temp = timeCode.hours;
	result.PutListPtr(0, typeShortInteger, &temp, sizeof(temp));
	
	temp = timeCode.minutes;
	result.PutListPtr(0, typeShortInteger, &temp, sizeof(temp));
	
	temp = timeCode.seconds;
	result.PutListPtr(0, typeShortInteger, &temp, sizeof(temp));
	
	temp = timeCode.frames;
	result.PutListPtr(0, typeShortInteger, &temp, sizeof(temp));

	return result.release();
}

//----------------------------------------------------------------------------------------
// TimeCodeToRecord
//----------------------------------------------------------------------------------------

CAEDesc_AC TTimeCodeUnit::TimeCodeToRecord(const TimeCodeTime& timeCode) const
{
	CTempDesc_AC result;

	result.CreateRecord();
	
	short temp = timeCode.hours;
	result.PutKeyPtr(typeHours, typeShortInteger, &temp, sizeof(temp));
	
	temp = timeCode.minutes;
	result.PutKeyPtr(typeMinutes, typeShortInteger, &temp, sizeof(temp));
	
	temp = timeCode.seconds;
	result.PutKeyPtr(typeSeconds, typeShortInteger, &temp, sizeof(temp));
	
	temp = timeCode.frames;
	result.PutKeyPtr(typeFrames, typeShortInteger, &temp, sizeof(temp));

	return result.release();
}

//----------------------------------------------------------------------------------------
// TimeCodeToString
//----------------------------------------------------------------------------------------

CAEDesc_AC TTimeCodeUnit::TimeCodeToString(const TimeCodeTime& timeCode) const
{
	CTempDesc_AC result;

	char line[64];
	int len = sprintf(line, "%02d:%02d:%02d:%02d", timeCode.hours, 
					  timeCode.minutes, timeCode.seconds, timeCode.frames);
	result.Set(typeChar, line, len);

	return result.release();
}

//----------------------------------------------------------------------------------------
// TimeCodeToSpec
//----------------------------------------------------------------------------------------

CAEDesc_AC TTimeCodeUnit::TimeCodeToSpec(const TimeCodeTime& timeCode) const
{
	CTempDesc_AC result;

	CTempDesc_AC unitTypeData(TimeCodeToList(timeCode));

	CAEDesc_AC containerDesc;
	ThrowIfOSErr(CreateObjSpecifier(typeTimeCode, &containerDesc, formName,
									&unitTypeData, false, &result));

	return result.release();
}

//----------------------------------------------------------------------------------------
// WildToUnit
//----------------------------------------------------------------------------------------

CAEDesc_AC TTimeCodeUnit::WildToUnit(const CAEDesc_AC& fromDesc, DescType toType) const
{
	CTempDesc_AC result;
	
	if (toType != typeTimeCode)
		ThrowError(errAECoercionFail);

	TimeCodeTime timeCode = WildToTimeCode(fromDesc);
	result.Set(typeTimeCode, &timeCode, sizeof(timeCode));

	return result.release();
}

//----------------------------------------------------------------------------------------
// UnitToWild
//----------------------------------------------------------------------------------------

CAEDesc_AC TTimeCodeUnit::UnitToWild(DescType typeCode, const void* dataPtr, Size dataSize, 
									 DescType toType) const
{
	if ((typeCode != typeTimeCode) || (dataSize != sizeof(TimeCodeTime)))
		ThrowError(errAECoercionFail);

	return TimeCodeToWild(*static_cast<const TimeCodeTime*>(dataPtr), toType);
}

//----------------------------------------------------------------------------------------
// UnitAccessor
//----------------------------------------------------------------------------------------

CAEDesc_AC TTimeCodeUnit::UnitAccessor(DescType desiredClass, const AEDesc *container,
									   DescType containerClass, DescType form, 
									   const AEDesc *selectionData) const
{
#pragma unused (container, containerClass, form)

	if (desiredClass != typeTimeCode)
		ThrowError(errAECoercionFail);

	TimeCodeTime timeCode = WildToTimeCode(selectionData);

	return CAEDesc_AC(typeTimeCode, &timeCode, sizeof(timeCode));
}

//----------------------------------------------------------------------------------------
// WildToUnitProc
//----------------------------------------------------------------------------------------

pascal OSErr TTimeCodeUnit::WildToUnitProc(const AEDesc *fromDesc, DescType toType, 
										   long handlerRefcon, AEDesc *result)
{
	OSErr err = noErr;
	try
	{
		TTimeCodeUnit* unit = reinterpret_cast<TTimeCodeUnit*>(handlerRefcon);
		*result = unit->WildToUnit(fromDesc, toType);
	}
	catch (CException_AC& fi)
	{
		err = fi.GetError();
	}
	catch (...)
	{
		err = errAECoercionFail;
	}
	return err;
}

//----------------------------------------------------------------------------------------
// UnitToWildProc
//----------------------------------------------------------------------------------------

pascal OSErr TTimeCodeUnit::UnitToWildProc(DescType typeCode, const void* dataPtr, 
										   Size dataSize, DescType toType, long handlerRefcon, 
										   AEDesc *result)
{
	OSErr err = noErr;
	try
	{
		TTimeCodeUnit* unit = reinterpret_cast<TTimeCodeUnit*>(handlerRefcon);
		*result = unit->UnitToWild(typeCode, dataPtr, dataSize, toType);
	}
	catch (CException_AC& fi)
	{
		err = fi.GetError();
	}
	catch (...)
	{
		err = errAECoercionFail;
	}
	return err;
}

//----------------------------------------------------------------------------------------
// UnitToWildProc
//----------------------------------------------------------------------------------------

pascal OSErr TTimeCodeUnit::UnitAccessorProc(DescType desiredClass, const AEDesc *container,
											 DescType containerClass, DescType form, 
											 const AEDesc *selectionData, AEDesc *value, 
											 long accessorRefcon)
{
	OSErr err = noErr;
	try
	{
		TTimeCodeUnit* unit = reinterpret_cast<TTimeCodeUnit*>(accessorRefcon);
		*value = unit->UnitAccessor(desiredClass, container, containerClass, form, selectionData);
	}
	catch (CException_AC& fi)
	{
		err = fi.GetError();
	}
	catch (...)
	{
		err = errAECoercionFail;
	}
	return err;
}


//========================================================================================
// TTimeCodeSubUnit
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

TTimeCodeSubUnit::TTimeCodeSubUnit(DescType unitID)
	:	TTimeCodeUnit(unitID)
{
	Install();
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

TTimeCodeSubUnit::~TTimeCodeSubUnit()
{
	Remove();
}

//----------------------------------------------------------------------------------------
// Install
//----------------------------------------------------------------------------------------

void TTimeCodeSubUnit::Install()
{
	TTimeCodeUnit::Install();

	if (!pBaseToUnitUPP)
		pBaseToUnitUPP = BaseToUnitProc;

	if (!pUnitToBaseUPP)
		pUnitToBaseUPP = UnitToBaseProc;

	InstallCoercePtrHandler(typeTimeCode, fUnitID, pBaseToUnitUPP, (long)this, kInSystem);
	InstallCoercePtrHandler(fUnitID, typeTimeCode, pUnitToBaseUPP, (long)this, kInSystem);
}

//----------------------------------------------------------------------------------------
// Remove
//----------------------------------------------------------------------------------------

void TTimeCodeSubUnit::Remove()
{
	TTimeCodeUnit::Remove();

	OSErr err = noErr;
	err = AERemoveCoercionHandler(typeTimeCode, fUnitID, pBaseToUnitUPP, kInSystem);
	err = AERemoveCoercionHandler(fUnitID, typeTimeCode, pUnitToBaseUPP, kInSystem);
}

//----------------------------------------------------------------------------------------
// BaseToUnitProc
//----------------------------------------------------------------------------------------

pascal OSErr TTimeCodeSubUnit::BaseToUnitProc(DescType typeCode, const void* dataPtr, 
											  Size dataSize, DescType toType, long handlerRefcon, 
											  AEDesc *result)
{
	OSErr err = noErr;
	try
	{
		TTimeCodeSubUnit* unit = reinterpret_cast<TTimeCodeSubUnit*>(handlerRefcon);
		*result = unit->BaseToUnit(typeCode, dataPtr, dataSize, toType);
	}
	catch (CException_AC& fi)
	{
		err = fi.GetError();
	}
	catch (...)
	{
		err = errAECoercionFail;
	}
	return err;
}

//----------------------------------------------------------------------------------------
// UnitToBaseProc
//----------------------------------------------------------------------------------------

pascal OSErr TTimeCodeSubUnit::UnitToBaseProc(DescType typeCode, const void* dataPtr, 
											  Size dataSize, DescType toType, long handlerRefcon, 
											  AEDesc *result)
{
	OSErr err = noErr;
	try
	{
		TTimeCodeSubUnit* unit = reinterpret_cast<TTimeCodeSubUnit*>(handlerRefcon);
		*result = unit->UnitToBase(typeCode, dataPtr, dataSize, toType);
	}
	catch (CException_AC& fi)
	{
		err = fi.GetError();
	}
	catch (...)
	{
		err = errAECoercionFail;
	}
	return err;
}


//========================================================================================
// TFramesUnit
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

TFramesUnit::TFramesUnit(DescType unitID)
	:	TTimeCodeSubUnit(unitID)
{
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

TFramesUnit::~TFramesUnit()
{
}

//----------------------------------------------------------------------------------------
// TimeCodeToFrames
//----------------------------------------------------------------------------------------

long TFramesUnit::TimeCodeToFrames(const TimeCodeTime& timeCode) const
{
	long frames = timeCode.hours * 60 + timeCode.minutes;
	frames = frames * 60 + timeCode.seconds;
	frames = frames * gFramesPerSecond + timeCode.frames;
	return frames;
}

//----------------------------------------------------------------------------------------
// FramesToTimeCode
//----------------------------------------------------------------------------------------

TimeCodeTime TFramesUnit::FramesToTimeCode(long frames) const
{
	TimeCodeTime timeCode;
	
	long seconds = frames / gFramesPerSecond;
	timeCode.frames = frames - seconds * gFramesPerSecond;
	
	long minutes = seconds / 60;
	timeCode.seconds = seconds - minutes * 60;
	
	long hours = minutes / 60;
	timeCode.minutes = minutes - hours * 60;
	
	timeCode.hours = hours;
	
	return timeCode;
}

//----------------------------------------------------------------------------------------
// WildToFrames
//----------------------------------------------------------------------------------------

long TFramesUnit::WildToFrames(const CAEDesc_AC& fromDesc) const
{
	long frames;

	switch (fromDesc.descriptorType)
	{
		case typeInteger:
		case typeChar:
		case typeFloat:
		case typeShortInteger:
		case typeComp:
		case typeMagnitude:
		case typeSMFloat:
		case typeExtended:
			frames = CAELong_AC(fromDesc);
			break;

		case typeObjectSpecifier:
			{
				CTempDesc_AC selectionData = GetUnitData(fromDesc);
				frames = WildToFrames(selectionData);
			}
			break;

		default:
			{
				CTempDesc_AC timeCodeDesc(fromDesc.Coerce(typeTimeCode));
				CAETimeCodeTime timeCode(timeCodeDesc);
				frames = TimeCodeToFrames(timeCode);
			}
			break;
	};

	return frames;
}

//----------------------------------------------------------------------------------------
// FramesToWild
//----------------------------------------------------------------------------------------

CAEDesc_AC TFramesUnit::FramesToWild(long frames, DescType toType) const
{
	CAEDesc_AC result;

	switch (toType)
	{
		case typeInteger:
		case cNumber:
			result.Set(typeInteger, &frames, sizeof(frames));
			break;

		case typeChar:
		case typeFloat:
		case typeShortInteger:
		case typeComp:
		case typeMagnitude:
		case typeSMFloat:
		case typeExtended:
			ThrowIfOSErr(AECoercePtr(typeInteger, &frames, sizeof(frames), toType, &result));
			break;

		case typeAERecord:
			// We don't want this to happen. 
			ThrowError(errAECoercionFail);
			break;

		case typeObjectSpecifier:
			{
				CTempDesc_AC unitTypeData(typeInteger, &frames, sizeof(frames));

				CAEDesc_AC containerDesc;
				ThrowIfOSErr(CreateObjSpecifier(typeFrames, &containerDesc, formName,
												&unitTypeData, false, &result));
			}
			break;

		case typeTimeCode:
			{
				TimeCodeTime timeCode = FramesToTimeCode(frames);
				result.Set(typeTimeCode, &timeCode, sizeof(timeCode));
			}
			break;

		default:
			{
				TimeCodeTime timeCode = FramesToTimeCode(frames);
				CTempDesc_AC timeCodeDesc(typeTimeCode, &timeCode, sizeof(timeCode));
				result = timeCodeDesc.Coerce(toType);
			}
			break;
	};

	return result;
}

//----------------------------------------------------------------------------------------
// WildToUnit
//----------------------------------------------------------------------------------------

CAEDesc_AC TFramesUnit::WildToUnit(const CAEDesc_AC& fromDesc, DescType toType) const
{
	if (toType != typeFrames)
		ThrowError(errAECoercionFail);

	long frames = WildToFrames(fromDesc);

	return CAEDesc_AC(typeFrames, &frames, sizeof(frames));
}

//----------------------------------------------------------------------------------------
// UnitToWild
//----------------------------------------------------------------------------------------

CAEDesc_AC TFramesUnit::UnitToWild(DescType typeCode, const void* dataPtr, Size dataSize, 
								   DescType toType) const
{
	if ((typeCode != typeFrames) || (dataSize != sizeof(long)))
		ThrowError(errAECoercionFail);

	return FramesToWild(*static_cast<const long*>(dataPtr), toType);
}

//----------------------------------------------------------------------------------------
// BaseToUnit
//----------------------------------------------------------------------------------------

CAEDesc_AC TFramesUnit::BaseToUnit(DescType typeCode, const void* dataPtr, Size dataSize, 
								   DescType toType) const
{
	if ((typeCode != typeTimeCode) ||
		(dataSize != sizeof(TimeCodeTime)) ||
		(toType != typeFrames))
		ThrowError(errAECoercionFail);

	long frames = TimeCodeToFrames(*static_cast<const TimeCodeTime*>(dataPtr));

	return CAEDesc_AC(typeFrames, &frames, sizeof(frames));
}

//----------------------------------------------------------------------------------------
// UnitToBase
//----------------------------------------------------------------------------------------

CAEDesc_AC TFramesUnit::UnitToBase(DescType typeCode, const void* dataPtr, Size dataSize, 
								   DescType toType) const
{
	if ((typeCode != typeFrames) ||
		(dataSize != sizeof(long)) ||
		(toType != typeTimeCode))
		ThrowError(errAECoercionFail);

	TimeCodeTime timeCode = FramesToTimeCode(*static_cast<const long*>(dataPtr));

	return CAEDesc_AC(typeTimeCode, &timeCode, sizeof(timeCode));
}

//----------------------------------------------------------------------------------------
// UnitAccessor
//----------------------------------------------------------------------------------------

CAEDesc_AC TFramesUnit::UnitAccessor(DescType desiredClass, const AEDesc *container,
									 DescType containerClass, DescType form, 
									 const AEDesc *selectionData) const
{
#pragma unused (container, containerClass, form)

	if (desiredClass != typeFrames)
		ThrowError(errAECoercionFail);

	long frames = WildToFrames(selectionData);

	return CAEDesc_AC(typeFrames, &frames, sizeof(frames));
}


//========================================================================================
// TSecondsUnit
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

TSecondsUnit::TSecondsUnit(DescType unitID)
	:	TTimeCodeSubUnit(unitID)
{
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

TSecondsUnit::~TSecondsUnit()
{
}

//----------------------------------------------------------------------------------------
// TimeCodeToSeconds
//----------------------------------------------------------------------------------------

double TSecondsUnit::TimeCodeToSeconds(const TimeCodeTime& timeCode) const
{
	double seconds = timeCode.hours * 60 + timeCode.minutes;
	seconds = seconds * 60 + timeCode.seconds;
	seconds += double(timeCode.frames) / gFramesPerSecond;
	return seconds;
}

//----------------------------------------------------------------------------------------
// SecondsToTimeCode
//----------------------------------------------------------------------------------------

TimeCodeTime TSecondsUnit::SecondsToTimeCode(double seconds) const
{
	TimeCodeTime timeCode;
	
	long isecs = floor(seconds);

	long frames = (seconds - isecs) * gFramesPerSecond;
	timeCode.frames = frames;

	long minutes = isecs / 60;
	timeCode.seconds = isecs - minutes * 60;
	
	long hours = minutes / 60;
	timeCode.minutes = minutes - hours * 60;
	
	timeCode.hours = hours;
	
	return timeCode;
}

//----------------------------------------------------------------------------------------
// WildToSeconds
//----------------------------------------------------------------------------------------

double TSecondsUnit::WildToSeconds(const CAEDesc_AC& fromDesc) const
{
	double seconds;

	switch (fromDesc.descriptorType)
	{
		case typeInteger:
		case typeChar:
		case typeFloat:
		case typeShortInteger:
		case typeComp:
		case typeMagnitude:
		case typeSMFloat:
		case typeExtended:
			seconds = CAEFloat_AC(fromDesc);
			break;

		case typeObjectSpecifier:
			{
				CTempDesc_AC selectionData = GetUnitData(fromDesc);
				seconds = WildToSeconds(selectionData);
			}
			break;

		default:
			{
				CTempDesc_AC timeCodeDesc(fromDesc.Coerce(typeTimeCode));
				CAETimeCodeTime timeCode(timeCodeDesc);
				seconds = TimeCodeToSeconds(timeCode);
			}
			break;
	};

	return seconds;
}

//----------------------------------------------------------------------------------------
// SecondsToWild
//----------------------------------------------------------------------------------------

CAEDesc_AC TSecondsUnit::SecondsToWild(double seconds, DescType toType) const
{
	CAEDesc_AC result;

	switch (toType)
	{
		case typeFloat:
		case cNumber:
			result.Set(typeFloat, &seconds, sizeof(seconds));
			break;

		case typeInteger:
		case typeChar:
		case typeShortInteger:
		case typeComp:
		case typeMagnitude:
		case typeSMFloat:
		case typeExtended:
			ThrowIfOSErr(AECoercePtr(typeFloat, &seconds, sizeof(seconds), toType, &result));
			break;

		case typeAERecord:
			// We don't want this to happen. 
			ThrowError(errAECoercionFail);
			break;

		case typeObjectSpecifier:
			{
				CTempDesc_AC unitTypeData(typeFloat, &seconds, sizeof(seconds));

				CAEDesc_AC containerDesc;
				ThrowIfOSErr(CreateObjSpecifier(typeSeconds, &containerDesc, formName,
												&unitTypeData, false, &result));
			}
			break;

		case typeTimeCode:
			{
				TimeCodeTime timeCode = SecondsToTimeCode(seconds);
				result.Set(typeTimeCode, &timeCode, sizeof(timeCode));
			}
			break;

		default:
			{
				TimeCodeTime timeCode = SecondsToTimeCode(seconds);
				CTempDesc_AC timeCodeDesc(typeTimeCode, &timeCode, sizeof(timeCode));
				result = timeCodeDesc.Coerce(toType);
			}
			break;
	};

	return result;
}

//----------------------------------------------------------------------------------------
// WildToUnit
//----------------------------------------------------------------------------------------

CAEDesc_AC TSecondsUnit::WildToUnit(const CAEDesc_AC& fromDesc, DescType toType) const
{
	if (toType != typeSeconds)
		ThrowError(errAECoercionFail);

	double seconds = WildToSeconds(fromDesc);

	return CAEDesc_AC(typeSeconds, &seconds, sizeof(seconds));
}

//----------------------------------------------------------------------------------------
// UnitToWild
//----------------------------------------------------------------------------------------

CAEDesc_AC TSecondsUnit::UnitToWild(DescType typeCode, const void* dataPtr, Size dataSize, 
									DescType toType) const
{
	if ((typeCode != typeSeconds) || (dataSize != sizeof(double)))
		ThrowError(errAECoercionFail);

	return SecondsToWild(*static_cast<const double*>(dataPtr), toType);
}

//----------------------------------------------------------------------------------------
// BaseToUnit
//----------------------------------------------------------------------------------------

CAEDesc_AC TSecondsUnit::BaseToUnit(DescType typeCode, const void* dataPtr, Size dataSize, 
									DescType toType) const
{
	if ((typeCode != typeTimeCode) ||
		(dataSize != sizeof(TimeCodeTime)) ||
		(toType != typeSeconds))
		ThrowError(errAECoercionFail);

	double seconds = TimeCodeToSeconds(*static_cast<const TimeCodeTime*>(dataPtr));

	return CAEDesc_AC(typeSeconds, &seconds, sizeof(seconds));
}

//----------------------------------------------------------------------------------------
// UnitToBase
//----------------------------------------------------------------------------------------

CAEDesc_AC TSecondsUnit::UnitToBase(DescType typeCode, const void* dataPtr, Size dataSize, 
										DescType toType) const
{
	if ((typeCode != typeSeconds) ||
		(dataSize != sizeof(double)) ||
		(toType != typeTimeCode))
		ThrowError(errAECoercionFail);

	TimeCodeTime timeCode = SecondsToTimeCode(*static_cast<const double*>(dataPtr));

	return CAEDesc_AC(typeTimeCode, &timeCode, sizeof(timeCode));
}

//----------------------------------------------------------------------------------------
// UnitAccessor
//----------------------------------------------------------------------------------------

CAEDesc_AC TSecondsUnit::UnitAccessor(DescType desiredClass, const AEDesc *container,
									  DescType containerClass, DescType form, 
									  const AEDesc *selectionData) const
{
#pragma unused (container, containerClass, form)

	if (desiredClass != typeSeconds)
		ThrowError(errAECoercionFail);

	double seconds = WildToSeconds(selectionData);

	return CAEDesc_AC(typeSeconds, &seconds, sizeof(seconds));
}


//----------------------------------------------------------------------------------------
// End of UTimeCodeUnits.cpp

