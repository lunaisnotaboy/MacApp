//----------------------------------------------------------------------------------------
// UMovieDocument.cpp
// Copyright � 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		04/04/01	Change the GetUserDataItem template function so it doesn't
							throw if the item is not as expected. Add a debug function
							to get the item's actual size. 
		01/19/01	DoNeedDiskSpace is now const.  Cosmetic.  Make CString_AC from
							results of GetURLLeafName in OpenURL.  Include CString_AC.h.
		01/02/01	Update copyright.
		06/23/00	Try to prevent window drawing a blank when opening.
		03/15/00	Don't try to coerce a null desc to type type.
		03/14/00	Add support for auto play and auto present.
							Update user data.
		02/22/00	Add support for getting the time as seconds, frames or time code.
		02/21/00	Time code units.
		12/27/99	Do not MA_DEFINE_CLONE TMovieDocument.
		11/12/99	Update to Carbon, Universal headers 3.3, and new AEDesc_AC
							methods.
		07/16/99	Open URL.
		07/16/99	Fixed the view to clear the movie's grafport when it is closed,
							so we don't need the previous fix.
		07/15/99	Dispose of the movie before the window, so it won't crash
							after playing some kinds of movies.
		06/06/99	Moved into MacApp examples.
							Moved QTClassLib into ACS.
							Tweak to build with MacApp R14.
		12/10/98	Streaming movie support.
		12/09/98	Allow control over undo/redo for movie command.
							Present movie mode.
		12/04/98	Clean up for final.
		09/30/98	Add floating window style.
		09/21/98	Noload build.
		09/16/98	Utility functions for converting window styles between enum and id.
							Make movie scrap commands recordable.
		07/30/98	Play movie stalls. Fix by giving the movie some time after
							prerolling and before starting it. This also makes sure
							the movie view's idler is set up.
							Force redraw of movie view after showing controller. Need to
							give the movie some time before it is really aware the
							controller is shown -- earlier force redraw doesn't work.
							Add natural dimensions property.
		07/12/98	Script set property now can change style of an open window.
							Get movie dimensions.
							Prevent the movie from starting to play just because the window
							type has changed.
		06/25/98	Play selection. Allow selection without being registered.
		06/24/98	QuickTime registration.
		06/24/98	Deglitch go to time. Support new and save to.
		06/22/98	Go to time by name.
		06/22/98	TMovieFile.
		06/22/98	Saving.
		06/21/98	Select and select all.
		06/12/98	Full screen.
		06/06/98	Preroll the movie. Change setting rate to set the playing property.
							Set property doesn't require saving or undo.
		05/16/98	Initial version.
*/

#ifndef __UMovieDocument__
#include "UMovieDocument.h"
#endif

// Moviewer

#ifndef __Moviewer_r__
#include "Moviewer.r.h"
#endif

#ifndef __UAEUtils__
#include "UAEUtils.h"
#endif

#ifndef __UMovieFile__
#include "UMovieFile.h"
#endif

#ifndef __UMovieView__
#include "UMovieView.h"
#endif

#ifndef __UMoviewer__
#include "UMoviewer.h"
#endif

#ifndef __UPropertyCommand__
#include "UPropertyCommand.h"
#endif

#ifndef __UTimeCodeUnits__
#include "UTimeCodeUnits.h"
#endif

// MacApp

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

// ACS

#ifndef __ChapterTrack_AC__
#include "ChapterTrack_AC.h"
#endif

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

// Toolbox

#ifndef __FIXMATH__
#include <FixMath.h>
#endif

#ifndef __QUICKTIMECOMPONENTS__
#include <QuickTimeComponents.h>
#endif

//========================================================================================
// GLOBAL Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUMovieDocument
//----------------------------------------------------------------------------------------

void InitUMovieDocument()
{
	InitUTimeCodeUnits();
}

//----------------------------------------------------------------------------------------
// WindowStyleEnum
//----------------------------------------------------------------------------------------

DescType WindowStyleEnum(CommandNumber windowID)
{
	DescType windowStyle;
	switch (windowID)
	{
		case cNormalWindow:
			windowStyle = enumWindowStyle_Normal;
			break;

		case cPlainWindow:
			windowStyle = enumWindowStyle_Plain;
			break;

		case cMiniWindow:
			windowStyle = enumWindowStyle_Mini;
			break;

		case cFloatingWindow:
			windowStyle = enumWindowStyle_Floating;
			break;

		default:
			ThrowError_AC(errAETypeError);
			break;
	}
	return windowStyle;
}

//----------------------------------------------------------------------------------------
// WindowStyleID
//----------------------------------------------------------------------------------------

CommandNumber WindowStyleID(DescType windowStyle)
{
	CommandNumber windowID;
	switch (windowStyle)
	{
		case enumWindowStyle_Normal:
			windowID = cNormalWindow;
			break;

		case enumWindowStyle_Plain:
			windowID = cPlainWindow;
			break;

		case enumWindowStyle_Mini:
			windowID = cMiniWindow;
			break;

		case enumWindowStyle_Floating:
			windowID = cFloatingWindow;
			break;

		default:
			ThrowError_AC(errAETypeError);
			break;
	}
	return windowID;
}

//----------------------------------------------------------------------------------------
// MovieSizeEnum
//----------------------------------------------------------------------------------------

DescType MovieSizeEnum(CommandNumber sizeID)
{
	DescType movieSize;
	switch (sizeID)
	{
		case cHalfSize:
			movieSize = enumHalfSize;
			break;

		case cNormalSize:
			movieSize = enumNormalSize;
			break;

		case cDoubleSize:
			movieSize = enumDoubleSize;
			break;

		case cFitToScreen:
			movieSize = enumFitToScreen;
			break;
	}
	return movieSize;
}

//----------------------------------------------------------------------------------------
// MovieSizeID
//----------------------------------------------------------------------------------------

CommandNumber MovieSizeID(DescType movieSize)
{
	CommandNumber sizeID;
	switch (movieSize)
	{
		case enumHalfSize:
			sizeID = cHalfSize;
			break;

		case enumNormalSize:
			sizeID = cNormalSize;
			break;

		case enumDoubleSize:
			sizeID = cDoubleSize;
			break;

		case enumFitToScreen:
			sizeID = cFitToScreen;
			break;

		default:
			ThrowError_AC(errAETypeError);
			break;
	}
	return sizeID;
}

//----------------------------------------------------------------------------------------
// GetURLLeafName
//----------------------------------------------------------------------------------------

CStr255_AC GetURLLeafName(const Handle url)
{
	CStr255_AC theName;

	Component dhComponent = GetDataHandler(url, URLDataHandlerSubType, kDataHCanRead);
	if (dhComponent)
	{
		DataHandler	dhInstance = 0;
		OSErr theErr = OpenAComponent(dhComponent, &dhInstance);
		if (dhInstance)
		{
			if (!theErr)
			{
				theErr = DataHSetDataRef(dhInstance, url);
				if (!theErr)
					theErr = DataHGetFileName(dhInstance, theName);
			}

			CloseComponent(dhInstance);
			dhInstance = 0;
		}
	}

	// scan the URL name from the end, and just take the end part of it as "fileName"
	if (theName[0] == 0)
	{
		Size length = GetHandleSize(url);
		Size namePos = length - 1;
		while ( ( namePos >= 0 ) && ( (*url)[namePos] != '/' ) && ( namePos != ':' ) )
			namePos--;

		namePos++;
		BlockMove_AC( &((*url)[namePos]), & ( theName[1] ), length - namePos );
		theName[0] = length - namePos;
	}

	return theName;
}

//========================================================================================
// CLASS TMovieDocument
//========================================================================================

//----------------------------------------------------------------------------------------
// TMovieDocument constructor
//----------------------------------------------------------------------------------------

TMovieDocument::TMovieDocument(TFile* file, OSType itsCreator) :
	TFileBasedDocument(file, itsCreator),
	fMovie(NULL),
	fMovieView(NULL),
	fWindowStyle(reinterpret_cast<TMoviewerApplication*>(gApplication)->GetStyle()),
	fLooping(false),
	fPalindrome(false),
	fPlaying(false),
	fHasMovieSize(false),
	fMovieSize(enumNormalSize),
	fHasVolume(false),
	fVolume(0),
	fCloseWhenDone(false),
	fQuitWhenDone(false),
	fShowController(false),
	fPlaySelection(false),
	fHasPosition(false),
	fURL(NULL),
	fAutoPlay(false),
	fAutoPresent(false)
{
	// TDocument overrides
	fSavePrintInfo = FALSE;
	fSaveUserSelection = FALSE;
#if qAttachable
	fSaveAttachedScript = FALSE;
#endif
	fHowToSave = sipAlways;		// always save in place

#if qDebug
	if (file)
	{
		TMovieFile* movieFile = dynamic_cast<TMovieFile*>(file);
		ThrowIfNonObject_AC(movieFile);
	}
#endif
}

//----------------------------------------------------------------------------------------
// TMovieDocument destructor
//----------------------------------------------------------------------------------------

TMovieDocument::~TMovieDocument()
{
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoInitialState:
//----------------------------------------------------------------------------------------

void TMovieDocument::DoInitialState()
{
	TFileBasedDocument::DoInitialState();

	// Create a new movie
	if (!fMovie)
		fMovie = CMovie_AC::NewMovieActive();
}

//----------------------------------------------------------------------------------------
// TMovieDocument::OpenURL:
//----------------------------------------------------------------------------------------

void TMovieDocument::OpenURL(const Handle url, bool /*forPrinting*/)
{
	fURL = url;

	// Get a movie out of the url.
	Movie newMovie = NULL;
	short aResID = 0;
	ThrowIfOSErr_AC(NewMovieFromDataRef(&newMovie, newMovieActive, &aResID, url,
										URLDataHandlerSubType));
	fMovie = newMovie;

	fTitle = CString_AC(GetURLLeafName(url));
	SetChangeCount(0);
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoRead:
//----------------------------------------------------------------------------------------

void TMovieDocument::DoRead(TFile* file, bool forPrinting)
{
	TFileBasedDocument::DoRead(file, forPrinting);

	// Create a Movie using the document file
	if (!fMovie)
	{
		TMovieFile* movieFile = dynamic_cast<TMovieFile*>(file);
		ThrowIfNonObject_AC(movieFile);
		movieFile->OpenFile();	// in case it's not already open

		Movie newMovie = NULL;
		movieFile->ReadMovie(&newMovie);
		fMovie = newMovie;

		RetrieveUserData();
	}
}

//----------------------------------------------------------------------------------------
// TMovieDocument::AboutToSaveFile:
//----------------------------------------------------------------------------------------

void TMovieDocument::AboutToSaveFile(TFile* /*theSaveFile*/,
									 CommandNumber /*itsCmd*/,
									 bool& /*makingCopy*/)
{
	UpdateUserData();
}

//----------------------------------------------------------------------------------------
// TMovieDocument::SaveOver:
//----------------------------------------------------------------------------------------

void TMovieDocument::SaveOver()
{
	// Don't set position or truncate.

	TMovieFile* movieFile = dynamic_cast<TMovieFile*>(fFile.get());
	ThrowIfNonObject_AC(movieFile);

	OSErr ignore = movieFile->CloseFile();
	movieFile->SetPermissions(fsRdWrPerm, fsRdWrPerm); // Since we intend to write to it
	ThrowIfOSErr_AC(movieFile->OpenFile());

	DoWrite(movieFile, false);	// we're clearly not making a copy

	ThrowIfOSErr_AC(movieFile->CloseFileIfNotKeptOpen());
}

//----------------------------------------------------------------------------------------
// TMovieDocument::SaveTo:
//----------------------------------------------------------------------------------------

void TMovieDocument::SaveTo(CommandNumber itsCommandNumber,
							bool /*makingCopy*/,
							bool copyFInfo,
							TFile* itsFile)
{
	TMovieFile* movieFile = dynamic_cast<TMovieFile*>(itsFile);
	ThrowIfNonObject_AC(movieFile);

	// Retain finder information. The document will have a file object
	// even if it doesn't have a file yet.
	CInfoPBRec cInfo;
	bool validInfo = GetSaveInfo(itsCommandNumber, copyFInfo, cInfo);

	// Delete the file if it already exists since the user will have
	// already said "replace existing."
	OSErr err = itsFile->DeleteCFile();
	if ((err != noErr) && (err != fnfErr))
		ThrowError_AC(err);

	ThrowIfOSErr_AC(movieFile->Flatten(fMovie, flattenAddMovieToDataFork));

	if (validInfo)			// Change attributes of movieFile?
		ThrowIfOSErr_AC(movieFile->SetCatInfo(cInfo));
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoNeedDiskSpace:
//----------------------------------------------------------------------------------------

void TMovieDocument::DoNeedDiskSpace(TFile* file,
									 long& dataForkBytes,
									 long& rsrcForkBytes) const
{
	TFileBasedDocument::DoNeedDiskSpace(file, dataForkBytes, rsrcForkBytes);

	if (fMovie)
	{
		dataForkBytes += fMovie.GetDataSize(0, LONG_MAX);

		rsrcForkBytes += kRsrcTypeOverhead + kRsrcOverhead + 1024;
	}
	rsrcForkBytes += kRsrcFileOverhead;
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoWrite:
//----------------------------------------------------------------------------------------

void TMovieDocument::DoWrite(TFile* file, bool makingCopy)
{
	TFileBasedDocument::DoWrite(file, makingCopy);

	// Create a Movie using the document file
	TMovieFile* movieFile = dynamic_cast<TMovieFile*>(file);
	ThrowIfNonObject_AC(movieFile);

	if (fMovie)
		movieFile->UpdateMovie(fMovie);
}

//----------------------------------------------------------------------------------------
// TMovieDocument::IsChanged:
//----------------------------------------------------------------------------------------

bool TMovieDocument::IsChanged()
{
	return TDocument::IsChanged() || (fMovie && fMovie.HasChanged());
}

//----------------------------------------------------------------------------------------
// TMovieDocument::FileHasBeenSaved:
//----------------------------------------------------------------------------------------

void TMovieDocument::FileHasBeenSaved(TFile* inFile)
{
	TFileBasedDocument::FileHasBeenSaved(inFile);

	if (fMovie)
		fMovie.ClearChanged();
}

//----------------------------------------------------------------------------------------
// TMovieDocument::UpdateUserData
//----------------------------------------------------------------------------------------

static void RemoveUserDataType(UserData theUserData, OSType udType)
{
	short count = CountUserDataType(theUserData, udType);
	while (count > 0)
	{
		ThrowIfOSErr_AC(RemoveUserData(theUserData, udType, count));
		--count;
	}
}

template <class T>
static void AddUserDataItem(UserData theUserData, T& data, OSType udType)
{
	static CTempHandle_AC tempH;
	if (!tempH)
	{
		tempH = NewHandle(sizeof(T));
		ThrowIfNULL_AC(tempH);
	}

	SetHandleSize(tempH, sizeof(T));
	ThrowIfMemError_AC();
	**(T **)tempH.get() = data;
	ThrowIfOSErr_AC(AddUserData(theUserData, tempH, udType));
}

enum {
	ptvSizeNormal = 0,
	ptvSizeDouble,
	ptvSizeHalf,
	ptvSizeFullScreen,
	ptvSizeCurrent
};

typedef struct
{
	short				size;
	short				preDelay;			// obsolete
	short				postDelay;			// obsolete
	Boolean				slideShowMode;
	Boolean				playOnOpen;
} PresentUserDataRecord;

void TMovieDocument::UpdateUserData()
{
	// Get the user data handle
	UserData ud = fMovie.GetUserData();

	RemoveUserDataType(ud, kUDWindowLocation);
	if (fMovieView)
	{
		TWindow* window = fMovieView->GetWindow();
		if (window)
		{
			CPoint_AC pt = window->GetLocation().AsPoint();
			AddUserDataItem(ud, pt, kUDWindowLocation);				// Add it to the user data.
		}
	}

	RemoveUserDataType(ud, kUDLooping);
	if (fLooping)
	{
		// If looping, add a LOOP data of 0x0000,
		// If loop AND palindrome, add LOOP data of 0x0001
		long looping = 0;
		if (fPalindrome)
			looping |= 1;

		AddUserDataItem(ud, looping, kUDLooping);
	}

	// deal with the selection-only settings
	RemoveUserDataType(ud, kUDPlaySelection);
	if (fPlaySelection)
	{
		Boolean data = true;
		AddUserDataItem(ud, data, kUDPlaySelection);
	}

//	// deal with the play every frame mode setting
//	RemoveUserDataType(ud, kUDAllFrames);
//	MCDoAction(controller, mcActionGetPlayEveryFrame, &SelectionOnlyMode);
//	if (SelectionOnlyMode)
//	{
//		AddUserDataItem(ud, true, kUDAllFrames);
//	}

	// save print to video settings, if they exist
	RemoveUserDataType(ud, kUDPresent);
	if (fAutoPresent)
	{
		PresentUserDataRecord presentation;
		presentation.size = 3;
		presentation.preDelay = 0;	// obsolete
		presentation.postDelay = 0;	// obsolete
		presentation.slideShowMode = false;
		presentation.playOnOpen = true;
		AddUserDataItem(ud, presentation, kUDPresent);
	}

	// save auto play settings
	RemoveUserDataType(ud, kUDAutoPlay);
	if (fAutoPlay)
	{
		Boolean autoPlay = true;
		AddUserDataItem(ud, autoPlay, kUDAutoPlay);
	}

	if (fCloseWhenDone)
	{
		Boolean closeWhenDone = true;
		AddUserDataItem(ud, closeWhenDone, pCloseWhenDone);
	}

	if (fQuitWhenDone)
	{
		Boolean quitWhenDone = true;
		AddUserDataItem(ud, quitWhenDone, pQuitWhenDone);
	}

	if (fWindowStyle != cNormalWindow)
	{
		DescType windowStyle = WindowStyleEnum(fWindowStyle);
		AddUserDataItem(ud, windowStyle, pWindowStyle);
	}
}

//----------------------------------------------------------------------------------------
// TMovieDocument::RetrieveUserData
//----------------------------------------------------------------------------------------

#if qDebug
static Size GetUserDataItemSize(UserData theUserData, OSType udType, long index = 1)
{
	Size dataSize = 0;
	CTempHandle_AC data = NewHandle(0);
	OSErr err = ::GetUserData(theUserData, data, udType, index);
	dataSize = GetHandleSize(data);
	return dataSize;
}
#endif

template <class T>
static bool GetUserDataItem(UserData theUserData, T& item, OSType udType, long index = 1)
{
	OSErr err = ::GetUserDataItem(theUserData, &item, sizeof(item), udType, index);
	if (err && (err != userDataItemNotFound))
	{
#if qDebug
		ProgramReport_AC("GetUserDataItem size %d, actual size %d, error: %d\n", 
						 sizeof(item), GetUserDataItemSize(theUserData, udType, index), err);
#endif
	}

	return (err == noErr);
}

void TMovieDocument::RetrieveUserData()
{
	// Get the user data handle
	UserData ud = fMovie.GetUserData();

	fHasPosition = GetUserDataItem(ud, fPosition, kUDWindowLocation);

	long looping = false;
	if (GetUserDataItem(ud, looping, kUDLooping))
	{
		fLooping = true;
		fPalindrome = looping & 1;
	}

	Boolean selectionOnly = false;
	if (GetUserDataItem(ud, selectionOnly, kUDPlaySelection))
		fPlaySelection = selectionOnly;

	Boolean everyFrame = false;
	GetUserDataItem(ud, everyFrame, kUDAllFrames);

	PresentUserDataRecord presentation;
	if (GetUserDataItem(ud, presentation, kUDPresent))
		fAutoPresent = true;

	Boolean autoPlay = false;
	if (GetUserDataItem(ud, autoPlay, kUDAutoPlay))
		fAutoPlay = autoPlay;

	Boolean closeWhenDone = false;
	if (GetUserDataItem(ud, closeWhenDone, pCloseWhenDone))
		fCloseWhenDone = closeWhenDone;

	Boolean quitWhenDone = false;
	if (GetUserDataItem(ud, quitWhenDone, pQuitWhenDone))
		fQuitWhenDone = quitWhenDone;

	DescType windowStyle = 0;
	if (GetUserDataItem(ud, windowStyle, pWindowStyle))
		fWindowStyle = WindowStyleID(windowStyle);
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoMakeViews:
//----------------------------------------------------------------------------------------

void TMovieDocument::DoMakeViews(bool /*forPrinting*/)
{
	// get the default MacApp window
	// get the movie's frame
	// and set its size to that of the movie plus room for the scrollers

	TView* window = TViewServer::fgViewServer->NewTemplateWindow(fWindowStyle, this);

	// get the default MacApp view in the window
	// and let it know about the movie

	fMovieView = dynamic_cast<TMovieView*>(window->FindSubView(kIDDefaultView));
	if (fMovieView && fMovie)
	{
		fMovieView->HaveMovie(fMovie);

		fMovieView->SetLoop(fLooping);

		if (fHasMovieSize)
			fMovieView->SetMovieSize(fMovieSize);

		if (fHasVolume)
			fMovie.SetVolume(fVolume);

		fMovieView->ShowController(fShowController);

		fMovieView->SetPlaySelection(fPlaySelection);

		if (fHasPosition)
		{
			TWindow* window = fMovieView->GetWindow();
			if (window)
			{
				window->Locate(fPosition, kInvalidate);
				window->ForceOnScreen();
			}
		}

		fMovie.Preroll(fMovie.GetTime(), fMovie.GetPreferredRate());

		fMovieView->IdleMovies();
	}
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoPostMakeViews:
//----------------------------------------------------------------------------------------

void TMovieDocument::DoPostMakeViews(bool forPrinting)
{
	TDocument::DoPostMakeViews(forPrinting);

	if (fAutoPresent)
	{
		DoMenuCommand(cPresent);
	}
	else
	{
		if (fAutoPlay)
			fPlaying = true;

		if (fMovieView)
		{
			fMovieView->SetPlaying(fPlaying);
			fMovieView->IdleMovies();
		}
	}
}

//----------------------------------------------------------------------------------------
// TMovieDocument::ChangeWindowStyle
//----------------------------------------------------------------------------------------

void TMovieDocument::ChangeWindowStyle(CommandNumber newWindowStyle)
{
	if (fMovieView)
	{
		// Remember whether the movie view was playing, so
		// the new movie view will have the same state.
		fPlaying = fMovieView->IsPlaying();

		TWindow* window = fMovieView->GetWindow();
		ThrowIfNonObject_AC(window);

		fPosition = window->GetLocation().AsPoint();
		fHasPosition = true;

		window->Close();
		delete window;
		fMovieView = NULL;
	}
	fWindowStyle = newWindowStyle;
	DoMakeViews(kForDisplay);
	DoPostMakeViews(kForDisplay);
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoSetupMenus
//----------------------------------------------------------------------------------------

void TMovieDocument::DoSetupMenus()
{
	TFileBasedDocument::DoSetupMenus();

	EnableCheck(cCloseWhenDone, true, fCloseWhenDone);
	EnableCheck(cQuitWhenDone, true, fQuitWhenDone);
	EnableCheck(cPlaySelection, true, fPlaySelection);
	EnableCheck(cController, true, fShowController);

	EnableCheck(cNormalWindow, true, fWindowStyle == cNormalWindow);
	EnableCheck(cPlainWindow, true, fWindowStyle == cPlainWindow);
	EnableCheck(cMiniWindow, true, fWindowStyle == cMiniWindow);
	EnableCheck(cFloatingWindow, true, fWindowStyle == cFloatingWindow);
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoMenuCommand
//----------------------------------------------------------------------------------------

void TMovieDocument::DoMenuCommand(CommandNumber aCommandNumber)
{
	switch (aCommandNumber)
	{
		case cUndo:
		case cRedo:
			{
				CommandNumber scriptCommand = (aCommandNumber == cUndo) ? cAEUndo : cAERedo;
				PostCommand(TH_new TMovieCommand(scriptCommand, this));
				//// Let the dispatcher post the undo command
				//TFileBasedDocument::DoMenuCommand(aCommandNumber);
				//gDispatcher->DoUndoRedo(this, aCommandNumber, this);
			}
			break;

		case cCut:
			PostCommand(TH_new TMovieCommand(cAECut, this));
			break;

		case cCopy:
			PostCommand(TH_new TMovieCommand(cAECopy, this));
			break;

		case cPaste:
			PostCommand(TH_new TMovieCommand(cAEPaste, this));
			break;

		case cClear:
			// ��� Not recordable -- use kAEDelete on the selection???
			if (fMovieView)
				fMovieView->DoClear();
			break;

		case cSelectAll:
			PostCommand(TH_new TMovieCommand(cSelectAll, this));
			break;

		case cLoop:
			PostCommand(TH_new TPropertyCommand(pLooping, this, TempBooleanDesc(!fLooping)));
			break;

		case cHalfSize:
		case cNormalSize:
		case cDoubleSize:
		case cFitToScreen:
			{
				DescType newSize = MovieSizeEnum(aCommandNumber);
				PostCommand(TH_new TPropertyCommand(pMovieSize, this, TempEnumDesc(newSize)));
			}
			break;

		case cCloseWhenDone:
			PostCommand(TH_new TPropertyCommand(pCloseWhenDone, this, TempBooleanDesc(!fCloseWhenDone)));
			break;

		case cQuitWhenDone:
			PostCommand(TH_new TPropertyCommand(pQuitWhenDone, this, TempBooleanDesc(!fQuitWhenDone)));
			break;

		case cController:
			PostCommand(TH_new TPropertyCommand(pController, this, TempBooleanDesc(!fShowController)));
			break;

		case cPlaySelection:
			PostCommand(TH_new TPropertyCommand(pPlaySelection, this, TempBooleanDesc(!fPlaySelection)));
			break;

		case cNormalWindow:
		case cPlainWindow:
		case cMiniWindow:
		case cFloatingWindow:
			{
				DescType windowStyle = WindowStyleEnum(aCommandNumber);
				PostCommand(TH_new TPropertyCommand(pWindowStyle, this, TempEnumDesc(windowStyle)));
			}
			break;

		case cPresent:
			PostCommand(TH_new TMovieCommand(cPresent, this, kCantUndo, kDoesNotCauseChange));
			break;

		default:
			TFileBasedDocument::DoMenuCommand(aCommandNumber);
			break;
	}
}

//----------------------------------------------------------------------------------------
// Scripting Support
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMovieDocument::GetSpecifierForm:
//----------------------------------------------------------------------------------------

DescType TMovieDocument::GetSpecifierForm()
{
	return (!GetTitle().empty()) ? formName : TFileBasedDocument::GetSpecifierForm();
}

//----------------------------------------------------------------------------------------
// TMovieDocument::DoScriptCommand
//----------------------------------------------------------------------------------------

void TMovieDocument::DoScriptCommand(CommandNumber aCommandNumber,
									 TAppleEvent* message,
									 TAppleEvent* reply)
{
	switch (aCommandNumber)
	{
		case cAECut:
			if (fMovieView)
				fMovieView->DoCut();
			break;

		case cAECopy:
			if (fMovieView)
				fMovieView->DoCopy();
			break;

		case cAEPaste:
			if (fMovieView)
				fMovieView->DoPaste();
			break;

		case cAEUndo:
		case cAERedo:
			if (fMovieView)
				fMovieView->DoUndo();
			break;

		case cSelect:
			if (fMovieView)
			{
				TimeValue selectionTime = message->ReadLong(keyAEStartTime);
				TimeValue selectionDuration = message->HasParameter(keyAEDuration) ?
											  message->ReadLong(keyAEDuration) : -1;
				fMovieView->SetSelection(selectionTime, selectionDuration);
				fMovieView->ForceRedraw();
			}
			break;

		case cSelectAll:
			if (fMovieView)
			{
				fMovieView->SelectAll();
				fMovieView->ForceRedraw();
			}
			break;

		case cPresent:
			if (fMovieView)
				fMovieView->BeginPresent();
			break;

		default:
			TFileBasedDocument::DoScriptCommand(aCommandNumber, message, reply);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TMovieDocument::GetObjectProperty:
//----------------------------------------------------------------------------------------

bool TMovieDocument::GetObjectProperty(CAEDesc& thePropertyValue,
									   DescType whichProperty,
									   const CAEDesc& desiredType)
{
	bool hasProperty = false;

	// The desired type is either a null desc or a desc of type type.
	DescType toType = typeNull;
	if (desiredType.descriptorType == typeType)
		toType = desiredType.GetType();

	switch (whichProperty)
	{
		case pWindowStyle:
			{
				DescType windowStyle = WindowStyleEnum(fWindowStyle);
				thePropertyValue.PutEnum(windowStyle);
				hasProperty = true;
			}
			break;

		case pLooping:
			if (fMovieView)
				fLooping = fMovieView->GetLoop();

			thePropertyValue.PutBoolean(fLooping);
			hasProperty = true;
			break;

		case pDone:
			{
				bool done = fMovieView ? fMovieView->IsDone() : false;
				thePropertyValue.PutBoolean(done);
			}
			hasProperty = true;
			break;

		case pPlaying:
			if (fMovieView)
			{
				fPlaying = fMovieView->IsPlaying();
				thePropertyValue.PutBoolean(fPlaying);
				hasProperty = true;
			}
			break;

		case pMovieSize:
			if (fMovieView)
			{
				fMovieSize = fMovieView->GetMovieSize();
				fHasMovieSize = true;
			}
			if (fHasMovieSize)
			{
				thePropertyValue.PutEnum(fMovieSize);
				hasProperty = true;
			}
			break;

//		case pScale:
//			if (fMovieView)
//			{
//				VariableMovieSize movieSize = fMovieView->fMovieSize;
//				if (movieSize == normalSize)
//					fScale = fixed1;
//				else if (movieSize == halfSize)
//					fScale = fixed1 >> 1;
//				else if (movieSize == doubleSize)
//					fScale = fixed1 << 1;
//
//				fHasScale = true;
//			}
//			if (fHasScale)
//			{
//				PutFixed(thePropertyValue, fScale);
//				hasProperty = true;
//			}
//			break;

		case pVolume:
			if (fMovie)
			{
				fVolume = fMovie.GetVolume();
				fHasVolume = true;
			}
			if (fHasVolume)
			{
				thePropertyValue.PutShort(fVolume);
				hasProperty = true;
			}
			break;

		case pCloseWhenDone:
			thePropertyValue.PutBoolean(fCloseWhenDone);
			hasProperty = true;
			break;

		case pQuitWhenDone:
			thePropertyValue.PutBoolean(fQuitWhenDone);
			hasProperty = true;
			break;

		case pController:
			if (fMovieView)
				fShowController = fMovieView->IsControllerShown();

			thePropertyValue.PutBoolean(fShowController);
			hasProperty = true;
			break;

		case pPlaySelection:
			if (fMovieView)
				fPlaySelection = fMovieView->GetPlaySelection();

			thePropertyValue.PutBoolean(fPlaySelection);
			hasProperty = true;
			break;

		case keyAEPosition:
			if (fMovieView)
			{
				TWindow* window = fMovieView->GetWindow();
				if (window)
				{
					fPosition = window->GetLocation().AsPoint();
					fHasPosition = true;
				}
			}
			if (fHasPosition)
			{
				thePropertyValue.PutPoint(fPosition);
				hasProperty = true;
			}
			break;

		case pDuration:
			if (fMovie)
			{
				TimeValue duration = fMovie.GetDuration();
				thePropertyValue.PutLong(duration);
				hasProperty = true;
			}
			break;

		case pTimeScale:
			if (fMovie)
			{
				TimeScale timeScale = fMovie.GetTimeScale();
				thePropertyValue.PutLong(timeScale);
				hasProperty = true;
			}
			break;

		case pTime:
			if (fMovie)
			{
				TimeValue time = fMovie.GetTime();

				if (toType == typeSeconds)
				{
					double seconds = double(time) / fMovie.GetTimeScale();
					thePropertyValue.reset(typeSeconds, &seconds, sizeof(seconds));
				}
				else if ((toType == typeFrames) ||
						 (toType == typeTimeCode))
				{
					double seconds = double(time) / fMovie.GetTimeScale();
					ThrowIfOSErr_AC(AECoercePtr(typeSeconds, &seconds, sizeof(seconds), toType,
												&thePropertyValue));
				}
				else
				{
					thePropertyValue.PutLong(time);
				}
				hasProperty = true;
			}
			break;

		case pDimensions:
			if (fMovie)
			{
				CPoint_AC dimensions = CRect_AC(fMovie.GetBox()).GetSize();
				thePropertyValue.PutPoint(dimensions);
				hasProperty = true;
			}
			break;

		case pNaturalDimensions:
			if (fMovie)
			{
				CPoint_AC dimensions = CRect_AC(fMovie.GetNaturalBoundsRect()).GetSize();
				thePropertyValue.PutPoint(dimensions);
				hasProperty = true;
			}
			break;

		case pAutoPlay:
			thePropertyValue.PutBoolean(fAutoPlay);
			hasProperty = true;
			break;

		case pAutoPresent:
			thePropertyValue.PutBoolean(fAutoPresent);
			hasProperty = true;
			break;

		default:
			break;
	}

	if (!hasProperty)
		hasProperty = TFileBasedDocument::GetObjectProperty(thePropertyValue, whichProperty, desiredType);

	return hasProperty;
}

//----------------------------------------------------------------------------------------
// TMovieDocument::SetObjectProperty:
//----------------------------------------------------------------------------------------

void TMovieDocument::SetObjectProperty(const CAEDesc& thePropertyValue,
									   DescType whichProperty)
{
	switch (whichProperty)
	{
		case pWindowStyle:
			{
				DescType windowStyle = thePropertyValue.GetEnum();
				CommandNumber newWindowStyle = WindowStyleID(windowStyle);

				// Change the window now if there is one,
				// otherwise just remember the style for later
				if (fMovieView)
					ChangeWindowStyle(newWindowStyle);
				else
					fWindowStyle = newWindowStyle;
			}
			break;

		case pLooping:
			fLooping = thePropertyValue.GetBoolean();
			if (fMovieView)
				fMovieView->SetLoop(fLooping);
			break;

		case pDone:
			ThrowError_AC(errAECantSetReadOnly);
			break;

		case pPlaying:
			fPlaying = thePropertyValue.GetBoolean();
			if (fMovieView && (fPlaying != fMovieView->IsPlaying()))
			{
				fMovieView->SetPlaying(fPlaying);
				fMovieView->IdleMovies();
			}
			break;

		case pMovieSize:
			fMovieSize = thePropertyValue.GetEnum();
			fHasMovieSize = true;
			if (fMovieView)
				fMovieView->SetMovieSize(fMovieSize);
			break;

//		case pScale:
//			fScale = GetFixed(thePropertyValue);
//			fHasScale = true;
//			if (fMovieView)
//			{
//				VariableMovieSize movieSize;
//				if (fScale == fixed1)
//					movieSize = normalSize;
//				else if (fScale == fixed1 >> 1)
//					movieSize = halfSize;
//				else if (fScale == fixed1 << 1)
//					movieSize = doubleSize;
//
//				fMovieView->SetMovieSize(movieSize);
//			}
//			break;

		case pVolume:
			fVolume = thePropertyValue.GetShort();
			fHasVolume = true;
			if (fMovie)
				fMovie.SetVolume(fVolume);
			break;

		case pCloseWhenDone:
			fCloseWhenDone = thePropertyValue.GetBoolean();
			break;

		case pQuitWhenDone:
			fQuitWhenDone = thePropertyValue.GetBoolean();
			break;

		case pController:
			fShowController = thePropertyValue.GetBoolean();
			if (fMovieView)
			{
				fMovieView->ShowController(fShowController);
				fMovieView->IdleMovies();
				fMovieView->ForceRedraw();
			}
			break;

		case pPlaySelection:
			fPlaySelection = thePropertyValue.GetBoolean();
			if (fMovieView)
			{
				fMovieView->SetPlaySelection(fPlaySelection);
				fMovieView->IdleMovies();
			}
			break;

		case keyAEPosition:
			fPosition = thePropertyValue.GetPoint();
			fHasPosition = true;
			if (fMovieView)
			{
				TWindow* window = fMovieView->GetWindow();
				if (window)
				{
					window->Locate(fPosition, kInvalidate);
					window->ForceOnScreen();
				}
			}
			break;

		case pDuration:
			ThrowError_AC(errAECantSetReadOnly);
			break;

		case pTimeScale:
			ThrowError_AC(errAECantSetReadOnly);
			break;

		case pTime:
			if (fMovieView)
			{
				TimeValue newTime;

				if ((thePropertyValue.GetDescriptorType() == typeChar) ||
					(thePropertyValue.GetDescriptorType() == typeIntlText))
				{
					CStr255_AC name = thePropertyValue.GetString();
					newTime = FindChapterTimeByName_AC(fMovie, name);
					if (newTime == -1)
						ThrowError_AC(errAENoSuchObject);
				}
				else if ((thePropertyValue.GetDescriptorType() == typeTimeCode) ||
						 (thePropertyValue.GetDescriptorType() == typeFrames) ||
						 (thePropertyValue.GetDescriptorType() == typeObjectSpecifier))
				{
					CTempDesc_AC secondsDesc(thePropertyValue.Coerce(typeSeconds));
					double secs = CAEFloat_AC(secondsDesc);
					newTime = secs * fMovie.GetTimeScale();
				}
				else if (thePropertyValue.GetDescriptorType() == typeSeconds)
				{
					double secs = CAEFloat_AC(thePropertyValue);
					newTime = secs * fMovie.GetTimeScale();
				}
				else
				{
					newTime = thePropertyValue.GetLong();
				}
				if ((newTime == -1) && fMovie)
					newTime = fMovie.GetDuration();
				fMovieView->SetTimeValue(newTime);
			}
			break;

		case pAutoPlay:
			fAutoPlay = thePropertyValue.GetBoolean();
			break;

		case pAutoPresent:
			fAutoPresent = thePropertyValue.GetBoolean();
			break;

		default:
			TFileBasedDocument::SetObjectProperty(thePropertyValue, whichProperty);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TMovieDocument::GetSetPropertyInfo:
//----------------------------------------------------------------------------------------

void TMovieDocument::GetSetPropertyInfo(DescType whichProperty,
										CommandNumber& cmdNum,
										bool& canUndo,
										bool& causesChange,
										TCommandHandler* &theContext)
{
	TFileBasedDocument::GetSetPropertyInfo(whichProperty, cmdNum, canUndo, causesChange, theContext);

	switch (whichProperty)
	{
		case pWindowStyle:
		case pLooping:
		case pCloseWhenDone:
		case pQuitWhenDone:
		case pPlaySelection:
		case pAutoPlay:
		case pAutoPresent:
			// These properties are saved with the document.
			canUndo = false;
			causesChange = true;
			break;

		case pPlaying:
		case pMovieSize:
		case pVolume:
		case pController:
		case keyAEPosition:
		case pTime:
		default:
			// We're not saving or undoing anything
			canUndo = false;
			causesChange = false;
			break;
	}
}

//========================================================================================
// CLASS TMovieCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TMovieCommand constructor
//----------------------------------------------------------------------------------------

TMovieCommand::TMovieCommand(CommandNumber scriptCommand,
							 TMovieDocument* itsDocument,
							 bool canUndo,
							 bool causesChange) :
	TCommand(scriptCommand, itsDocument, canUndo, causesChange, itsDocument)
{
	fUseAppleEvent = true;
}

//----------------------------------------------------------------------------------------
// TMovieCommand::MakeAppleEvent:
//----------------------------------------------------------------------------------------

TAppleEvent* TMovieCommand::MakeAppleEvent()
{
	AEEventClass itsEventClass;
	AEEventID eventID;
	switch (fIdentifier)
	{
		case cAECut:
			itsEventClass = kAEMiscStandards;
			eventID = kAECut;
			break;

		case cAECopy:
			itsEventClass = kAEMiscStandards;
			eventID = kAECopy;
			break;

		case cAEPaste:
			itsEventClass = kAEMiscStandards;
			eventID = kAEPaste;
			break;

		case cAEUndo:
		case cAERedo:
			itsEventClass = kAEMiscStandards;
			eventID = kAEUndo;
			break;

		case cSelectAll:
			itsEventClass = 'MVWR';
			eventID = kAESelectAll;
			break;

		case cPresent:
			itsEventClass = 'MVWR';
			eventID = kAEPresent;
			break;

		default:
			ThrowError_AC(minErr);
			break;
	}

	CAutoPtr_AC<TAppleEvent> theEvent(TH_new TAppleEvent(itsEventClass, eventID, gServerAddress, kAEWaitReply));

	TMovieDocument* movieDocument = reinterpret_cast<TMovieDocument*>(fContext);
	ThrowIfNonObject_AC(movieDocument);
	CTempDesc objectSpecifier;
	movieDocument->MakeObjectSpecifier(objectSpecifier, movieDocument->GetSpecifierForm());
	theEvent->WriteParameter(keyDirectObject, objectSpecifier);

	return theEvent.release();
}

//----------------------------------------------------------------------------------------
// TMovieCommand::DoIt:
//----------------------------------------------------------------------------------------

void TMovieCommand::DoIt()
{
	RedoIt();
}

//----------------------------------------------------------------------------------------
// TMovieCommand::UndoIt:
//----------------------------------------------------------------------------------------

void TMovieCommand::UndoIt()
{
	TMovieDocument* movieDocument = reinterpret_cast<TMovieDocument*>(fContext);
	ThrowIfNonObject_AC(movieDocument);
	movieDocument->DoScriptCommand(cAEUndo, NULL, NULL);
}

//----------------------------------------------------------------------------------------
// TMovieCommand::RedoIt:
//----------------------------------------------------------------------------------------

void TMovieCommand::RedoIt()
{
	TMovieDocument* movieDocument = reinterpret_cast<TMovieDocument*>(fContext);
	ThrowIfNonObject_AC(movieDocument);
	movieDocument->DoScriptCommand(fIdentifier, NULL, NULL);
}

//----------------------------------------------------------------------------------------
// End of UMovieDocument.cpp
