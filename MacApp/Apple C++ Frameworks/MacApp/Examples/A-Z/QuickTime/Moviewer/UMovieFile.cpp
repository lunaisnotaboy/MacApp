//----------------------------------------------------------------------------------------
// UMovieFile.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		06/06/99	Moved into MacApp examples. 
							Moved QTClassLib into ACS. 
		09/30/98	Use typedefs for Inherited. 
		06/24/98	Fix Flatten to really return an error. Remove unnecessary
							assertion. 
		06/22/98	Moviewer version. 
*/

#ifndef __UMovieFile__
#include "UMovieFile.h"
#endif

// MacApp

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CMovie_AC__
#include "CMovie_AC.h"
#endif

// Toolbox

#ifndef __FIXMATH__
#include <FixMath.h>
#endif

#ifndef __MOVIES__
#include <Movies.h>
#endif

//========================================================================================
// CLASS TMovieFile
//========================================================================================

MA_DEFINE_CLONE(TMovieFile);

//----------------------------------------------------------------------------------------
// TMovieFile constructor
//----------------------------------------------------------------------------------------
		
TMovieFile::TMovieFile() :
	fMovieRefNum(kNoFileRefNum_AC),
	fMovieResID(0),
	fUsesMovie(true),
	fKeepMovieOpen(true)
{
}

//----------------------------------------------------------------------------------------
// TMovieFile::TMovieFile: 
//----------------------------------------------------------------------------------------
		
TMovieFile::TMovieFile(OSType itsFileType,
					   OSType itsCreator,
					   bool keepsMovieOpen) :
	TFile(itsFileType, itsCreator, !kUsesDataFork, noResourceFork, !kDataOpen, !kRsrcOpen),
	fMovieRefNum(kNoFileRefNum_AC),
	fMovieResID(0),
	fUsesMovie(true),
	fKeepMovieOpen(keepsMovieOpen)
{
}

//----------------------------------------------------------------------------------------
// TMovieFile destructor
//----------------------------------------------------------------------------------------
		
TMovieFile::~TMovieFile()
{
}

//----------------------------------------------------------------------------------------
// Creating
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMovieFile::CreateMovie: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CreateMovie(Movie *theNewMovie)
{
#if qDebug
	Assertion_AC(!IsMovieOpen(), "");
#endif
	OSErr err = CreateMovieFile(&fFileSpec, fCreator, fScriptTag,
								createMovieFileDeleteCurFile,
								&fMovieRefNum, theNewMovie);
	
	return err;
}

//----------------------------------------------------------------------------------------
// TMovieFile::Flatten: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::Flatten(Movie theMovie, long movieFlattenFlags)
{
	fMovieRefNum = movieInDataForkResID;

	FlattenMovie(theMovie, movieFlattenFlags, &fFileSpec, fCreator, fScriptTag,
				 createMovieFileDeleteCurFile, &fMovieRefNum, nil);

	return GetMoviesError();
}

//----------------------------------------------------------------------------------------
// Opening
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMovieFile::OpenFile: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::OpenFile() // override
{
	return OpenMovie();
}

//----------------------------------------------------------------------------------------
// TMovieFile::OpenFileIfKeptOpen: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::OpenFileIfKeptOpen() // override
{
	OSErr err = noErr;
	
	if (fKeepMovieOpen)
		err = OpenMovie();
	
	return err;
}

//----------------------------------------------------------------------------------------
// TMovieFile::OpenMovie: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::OpenMovie()
{
	OSErr err = noErr;
	
	if (!IsMovieOpen())			// Don't open if already open 
	{
		err = OpenMovieFile(&fFileSpec, &fMovieRefNum, fDataPermission);
	}
	
	return err;
}

//----------------------------------------------------------------------------------------
// TMovieFile::ReadMovie: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::ReadMovie(Movie* movie)
{
#if qDebug
	Assertion_AC(fMovieResID == 0, "");
#endif

	*movie = NULL;
	OSErr err = OpenMovie();
	if (err == noErr)
		err = NewMovieFromFile(movie, fMovieRefNum, &fMovieResID, NULL, newMovieActive, NULL);
	
	return err;
}

//----------------------------------------------------------------------------------------
// Writing
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMovieFile::UpdateMovie: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::UpdateMovie(Movie theMovie)
{
	OSErr err = noErr;

	if (fMovieResID == 0)
		CMovie_AC(theMovie).AddResource(fMovieRefNum, &fMovieResID, fFileSpec.name);
	else
	{
		if (HasMovieChanged(theMovie))
		{
			//short resRef;
			//FailOSErr(OpenMovieFile( &fFileSpec, &resRef, fsRdWrPerm ));

			CMovie_AC(theMovie).UpdateResource(fMovieRefNum, fMovieResID, fFileSpec.name);
			
			//err = CloseMovieFile(resRef);
		}
	}
	
	return err;
}


//----------------------------------------------------------------------------------------
// Closing
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMovieFile::CloseFile: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CloseFile() // override
{
	return CloseMovie();
}

//----------------------------------------------------------------------------------------
// TMovieFile::CloseFileIfNotKeptOpen: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CloseFileIfNotKeptOpen() // override
{
	OSErr err = noErr;

	if (fUsesMovie && !fKeepMovieOpen)
		err = CloseMovie();

	return err;
}

//----------------------------------------------------------------------------------------
// TMovieFile::CloseMovie: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CloseMovie()
{
	OSErr err = noErr;

	if (IsMovieOpen())
	{
		err = CloseMovieFile(fMovieRefNum);
		fMovieRefNum = kNoFileRefNum_AC;
		fMovieResID = 0;
	}
	
	return err;
}

//----------------------------------------------------------------------------------------
// Don't call these!
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMovieFile::CloseDataFork: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CloseDataFork() // override
{
#if qDebug
	ProgramBreak_AC("Don't call this!");
#endif
	return noErr; //minErr;
}

//----------------------------------------------------------------------------------------
// TMovieFile::CloseRsrcFork: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CloseRsrcFork() // override
{
#if qDebug
	ProgramBreak_AC("Don't call this!");
#endif
	return noErr; //minErr;
}

//----------------------------------------------------------------------------------------
// TMovieFile::CreateFile: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CreateFile() // override
{
#if qDebug
	ProgramBreak_AC("Don't call this!");
#endif
	return noErr; //minErr;
}

//----------------------------------------------------------------------------------------
// TMovieFile::CreateDataFork: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CreateDataFork() // override
{
#if qDebug
	ProgramBreak_AC("Don't call this!");
#endif
	return noErr; //minErr;
}

//----------------------------------------------------------------------------------------
// TMovieFile::CreateRsrcFork: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::CreateRsrcFork() // override
{
#if qDebug
	ProgramBreak_AC("Don't call this!");
#endif
	return noErr; //minErr;
}

//----------------------------------------------------------------------------------------
// TMovieFile::OpenDataFork: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::OpenDataFork(SignedByte /*permission*/) // override
{
#if qDebug
	ProgramBreak_AC("Don't call this!");
#endif
	return noErr; //minErr;
}

//----------------------------------------------------------------------------------------
// TMovieFile::OpenRsrcFork: 
//----------------------------------------------------------------------------------------

OSErr TMovieFile::OpenRsrcFork(SignedByte /*permission*/) // override
{
#if qDebug
	ProgramBreak_AC("Don't call this!");
#endif
	return noErr; //minErr;
}

//----------------------------------------------------------------------------------------
// End of UMovieFile.cpp
