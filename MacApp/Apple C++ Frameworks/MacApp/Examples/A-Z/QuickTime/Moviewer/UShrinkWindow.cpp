//----------------------------------------------------------------------------------------
// UShrinkWindow.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		11/16/99	Carbon: TShrinkToFitWindow::ForceOnScreen uses MacApp's version.
		06/06/99	Moved into MacApp examples. 
		09/30/98	Use typedefs for Inherited. 
		09/13/98	Try using service windows. 
		06/12/98	Full screen. 
		06/07/98	Setting window properties is not undoable. 
		05/16/98	Initial version. 
*/

#ifndef __UShrinkWindow__
#include "UShrinkWindow.h"
#endif

// MacApp

#ifndef __FLOATWINDOW__
#include "FloatWindow.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

// Toolbox

#ifndef __TEXTSERVICES__
#include <TextServices.h>
#endif


extern bool gHasTextServices;

//========================================================================================
// CLASS TShrinkToFitWindow
//========================================================================================

DEFINE_REGISTERED_AC(TShrinkToFitWindow);
MA_DEFINE_CLONE(TShrinkToFitWindow);

//----------------------------------------------------------------------------------------
// TShrinkToFitWindow Constructor
//----------------------------------------------------------------------------------------

TShrinkToFitWindow::TShrinkToFitWindow()
{
}

//----------------------------------------------------------------------------------------
// TShrinkToFitWindow destructor
//----------------------------------------------------------------------------------------

TShrinkToFitWindow::~TShrinkToFitWindow()
{
}

//----------------------------------------------------------------------------------------
// TShrinkToFitWindow::SubViewChangedFrame
//----------------------------------------------------------------------------------------

void TShrinkToFitWindow::SubViewChangedFrame(TView* theSubView,
											 const CViewRect& /*oldFrame*/,
											 const CViewRect& /*newFrame*/,
											 bool invalidate) // override
{
	if (theSubView->GetShown())
	{
		CViewPoint newSize = GetSubViewSize();
		if (newSize != GetSize())
			Resize(newSize, invalidate);
	}
}

//----------------------------------------------------------------------------------------
// TShrinkToFitWindow::GetSubViewSize
//----------------------------------------------------------------------------------------

CViewPoint TShrinkToFitWindow::GetSubViewSize()
{
	return GetSubViewExtent()[botRight];
}

//----------------------------------------------------------------------------------------
// TShrinkToFitWindow::GetSubViewExtent
//----------------------------------------------------------------------------------------

CViewRect TShrinkToFitWindow::GetSubViewExtent()
{
	CViewRect aggregateExtents(gZeroVRect);
	
	CSubViewIterator iter(this);
	for (TView* aSubView = iter.FirstSubView(); iter.Current(); aSubView = iter.NextSubView())
		if (aSubView->GetShown())
			aggregateExtents = aggregateExtents | aSubView->GetFrame();		// union the new frame into the aggregate

	return aggregateExtents;
}


//----------------------------------------------------------------------------------------
// TShrinkToFitWindow::ForceOnScreen
//----------------------------------------------------------------------------------------

void TShrinkToFitWindow::ForceOnScreen()
{
#if qCarbon
#pragma warning ("Carbon: TShrinkToFitWindow::ForceOnScreen() uses MacApp's ForceOnScreen()")
	TWindow::ForceOnScreen();
#else
	enum { kMinDragArea = 4 };

	fForcedOnScreen = true;

	CRect_AC structure;
	{
		CTempRegion_AC structureRgn;
		bool rgnsWereBuilt = BuildWindowRegions(kBuild);
		::GetWindowStructureRgn(fWMgrWindow, structureRgn);
		structure = structureRgn.Bounds();
		BuildWindowRegions(rgnsWereBuilt);
	}

	CRect_AC screen;
	GetMaxIntersectedDevice(screen);		// NOTE: uses tempRgn
	screen.Inset(kMinDragArea, kMinDragArea);
	
	// First check if the window is completely visible, in which case we're home free
	if (!screen.Contains(structure))
	{
		CViewPoint newLocation(fLocation);

		if (structure.top < screen.top)
		{
			// Top of window is off screen. Move it down. 
			newLocation.v = screen.top + fContentRegionInset.v;
		}
		else if (structure.bottom > screen.bottom)
		{
			// Bottom of window is off screen. Move it up as much as possible
			// without cutting off the top. 
			short top = screen.bottom - (structure.bottom - structure.top);
			if (top < screen.top)
				top = screen.top;
			newLocation.v = top + fContentRegionInset.v;
		}

		if (structure.left < screen.left)
		{
			// Left of window is off screen. Move it to the right. 
			newLocation.h = screen.left + fContentRegionInset.h;
		}
		else if (structure.right > screen.right)
		{
			// Right of window is off screen. Move it to the left as much
			// as possible without cutting off the left edge. 
			short left = screen.right - (structure.right - structure.left);
			if (left < screen.left)
				left = screen.left;
			newLocation.h = left + fContentRegionInset.h;
		}

		if (newLocation != fLocation)
			Locate(newLocation, kDontInvalidate);
	}
#endif
}

//----------------------------------------------------------------------------------------
// TShrinkToFitWindow::GetSetPropertyInfo:
//----------------------------------------------------------------------------------------

void TShrinkToFitWindow::GetSetPropertyInfo(DescType whichProperty,
											CommandNumber& cmdNum,
											bool& canUndo,
											bool& causesChange,
											TCommandHandler* &theContext) // override
{
	Inherited::GetSetPropertyInfo(whichProperty, cmdNum, canUndo, causesChange, theContext);

	// We're not saving or undoing anything
	canUndo = false;
	causesChange = false;
}


//----------------------------------------------------------------------------------------
// End of UShrinkWindow.cpp

#pragma segment Inline