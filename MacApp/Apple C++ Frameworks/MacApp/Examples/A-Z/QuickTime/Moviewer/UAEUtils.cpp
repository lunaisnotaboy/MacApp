//----------------------------------------------------------------------------------------
// UAEUtils.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/19/01	Use CString_AC in PutProperty.
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		02/18/00	Make InstallCoercionHandler functions extern. 
		11/11/99	Take out TempPointDesc and TempShortDesc because they're not used.
		11/08/99	Roll in new TemplateTempUPP_AC definition useage.
		07/14/99	Renamed the CreateDesc method to reset. 
		06/06/99	Moved into MacApp examples. 
					Moved QTClassLib into ACS. 
					Tweak to build with MacApp R14. 
		12/04/98	Clean up for final. 
		09/21/98	Noload build. 
		09/14/98	Add TempDesc functions. 
		09/14/98	Use QTClassLib versions of utilities. 
		06/07/98	Safer coercion in GetPoint, GetShort and GetFixed. 
		05/18/98	Add QD point support. 
		05/05/98	Coercion procs need to be pascal. 
					Changed to use new TemplateUPP_AC instead of TmplTmpRtnDescrptr. 
		04/06/98	UPP types didn't match procs. 
		04/03/98	Add InitUAEUtils. Use coercion handlers. 
		04/02/98	PutProperty. 
					Store fixed values as floats so AppleScript can understand them. 
*/

#ifndef __UAEUtils__
#include "UAEUtils.h"
#endif

// ACS

#ifndef __Bail_AC__
#include "Bail_AC.h"
#endif

#ifndef __CFixedPoint_AC__
#include "CFixedPoint_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __TemplateUPP_AC__
#include "TemplateUPP_AC.h"
#endif

// Toolbox

#ifndef __AEDATAMODEL__
#include <AEDataModel.h>
#endif

#ifndef __AEREGISTRY__
#include <AERegistry.h>
#endif

#ifndef __FIXMATH__
#include <FixMath.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif


//----------------------------------------------------------------------------------------
// GLOBAL Variables
//----------------------------------------------------------------------------------------

CTempAECoercePtrUPP pCoercePointToList;
CTempAECoerceDescUPP pCoerceListToPoint;
CTempAECoercePtrUPP pCoerceFixedPointToList;
CTempAECoerceDescUPP pCoerceListToFixedPoint;
CTempAECoercePtrUPP pCoerceFixedToFloat;
CTempAECoercePtrUPP pCoerceFloatToFixed;

//========================================================================================
// GLOBAL Functions
//========================================================================================

pascal OSErr CoercePointToList(DescType typeCode, const void *dataPtr, Size dataSize, 
							   DescType toType, long handlerRefcon, AEDesc *result);
pascal OSErr CoerceListToPoint(const AEDesc *fromDesc, DescType toType, long handlerRefcon,
							   AEDesc *toDesc);
pascal OSErr CoerceFixedPointToList(DescType typeCode, const void *dataPtr, Size dataSize, 
									DescType toType, long handlerRefcon, AEDesc *result);
pascal OSErr CoerceListToFixedPoint(const AEDesc *fromDesc, DescType toType, long handlerRefcon,
									AEDesc *toDesc);
pascal OSErr CoerceFixedToFloat(DescType typeCode, const void *dataPtr, Size dataSize, 
								DescType toType, long handlerRefcon, AEDesc *result);
pascal OSErr CoerceFloatToFixed(DescType typeCode, const void *dataPtr, Size dataSize, 
								DescType toType, long handlerRefcon, AEDesc *result);


//----------------------------------------------------------------------------------------
// InstallCoercionHandler
//----------------------------------------------------------------------------------------

void InstallCoercionHandler(DescType fromType, DescType toType,
							AECoercionHandlerUPP handler, long handlerRefcon,
							bool fromTypeIsDesc, bool isSysHandler)
{
	OSErr err = noErr;

	{
		AECoercionHandlerUPP prevHandler = NULL;
		long prevHandlerRefcon = 0;
		Boolean prevFromTypeIsDesc = false;
		err = AEGetCoercionHandler(fromType, toType, &prevHandler, &prevHandlerRefcon,
								   &prevFromTypeIsDesc, isSysHandler);
	}

	if (err == errAEHandlerNotFound)
	{
		err = noErr;
		err = AEInstallCoercionHandler(fromType, toType, handler, handlerRefcon,
									   fromTypeIsDesc, isSysHandler);
	}

	ThrowIfOSErr_AC(err);
}

//----------------------------------------------------------------------------------------
// InitUAEUtils:
//----------------------------------------------------------------------------------------

void InitUAEUtils()
{
	pCoercePointToList = CoercePointToList;
	InstallCoercePtrHandler(cQDPoint, typeAEList, pCoercePointToList);

	pCoerceListToPoint = CoerceListToPoint;
	InstallCoerceDescHandler(typeAEList, cQDPoint, pCoerceListToPoint);

	pCoerceFixedPointToList = CoerceFixedPointToList;
	InstallCoercePtrHandler(typeFixedPoint, typeAEList, pCoerceFixedPointToList);

	pCoerceListToFixedPoint = CoerceListToFixedPoint;
	InstallCoerceDescHandler(typeAEList, typeFixedPoint, pCoerceListToFixedPoint);

	pCoerceFixedToFloat = CoerceFixedToFloat;
	InstallCoercePtrHandler(typeFixed, typeFloat, pCoerceFixedToFloat);

	pCoerceFloatToFixed = CoerceFloatToFixed;
	InstallCoercePtrHandler(typeFloat, typeFixed, pCoerceFloatToFixed);
}

//----------------------------------------------------------------------------------------
// CoercePointToList
//----------------------------------------------------------------------------------------

pascal OSErr CoercePointToList(DescType typeCode, const void *dataPtr, Size dataSize, 
							   DescType toType, long /*handlerRefcon*/, AEDesc *result)
{
	OSErr err = errAECoercionFail;

	BailIf(!result, paramErr);
	result->descriptorType = typeNull;
	result->dataHandle = NULL;

	if ((typeCode == cQDPoint) && (toType == typeAEList))
	{
		BailIf(dataSize != sizeof(Point), paramErr);

		BailOSErr(AECreateList(NULL, 0, false, result));

		const Point* pointValue = static_cast<const Point *>(dataPtr);

		BailOSErr(AEPutPtr(result, 0, typeShortInteger, &pointValue->h, sizeof(pointValue->h)));
		BailOSErr(AEPutPtr(result, 0, typeShortInteger, &pointValue->v, sizeof(pointValue->v)));
		err = noErr;
	}

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// CoerceListToPoint
//----------------------------------------------------------------------------------------

pascal OSErr CoerceListToPoint(const AEDesc *fromDesc, DescType toType, long /*handlerRefcon*/,
							   AEDesc *toDesc)
{
	OSErr err = errAECoercionFail;

	BailIf(!toDesc, paramErr);
	toDesc->descriptorType = typeNull;
	toDesc->dataHandle = NULL;

	if ((fromDesc->descriptorType == typeAEList) && (toType == cQDPoint))
	{
		CPoint_AC pointValue;

		long theCount = 0;
		BailOSErr(AECountItems(fromDesc, &theCount));
		BailIf(theCount != 2, paramErr);

		DescType theAEKeyword;
		CAEDesc theDesc;
		BailOSErr(AEGetNthDesc(fromDesc, 1, typeShortInteger, &theAEKeyword, theDesc));
		pointValue.h = **reinterpret_cast<short **>(theDesc.dataHandle);

		BailOSErr(AEGetNthDesc(fromDesc, 2, typeShortInteger, &theAEKeyword, theDesc));
		pointValue.v = **reinterpret_cast<short **>(theDesc.dataHandle);

		BailOSErr(AECreateDesc(cQDPoint, &pointValue, sizeof(pointValue), toDesc));
		err = noErr;
	}

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// CoerceFixedPointToList
//----------------------------------------------------------------------------------------

pascal OSErr CoerceFixedPointToList(DescType typeCode, const void *dataPtr, Size dataSize, 
									DescType toType, long /*handlerRefcon*/, AEDesc *result)
{
	OSErr err = errAECoercionFail;

	BailIf(!result, paramErr);
	result->descriptorType = typeNull;
	result->dataHandle = NULL;

	if ((typeCode == typeFixedPoint) && (toType == typeAEList))
	{
		BailIf(dataSize != sizeof(FixedPoint), paramErr);

		BailOSErr(AECreateList(NULL, 0, false, result));

		const FixedPoint* fixedPointValue = static_cast<const FixedPoint *>(dataPtr);

		double floatValue = Fix2X(fixedPointValue->x);
		BailOSErr(AEPutPtr(result, 0, typeFloat, &floatValue, sizeof(floatValue)));

		floatValue = Fix2X(fixedPointValue->y);
		BailOSErr(AEPutPtr(result, 0, typeFloat, &floatValue, sizeof(floatValue)));
		err = noErr;
	}

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// CoerceListToFixedPoint
//----------------------------------------------------------------------------------------

pascal OSErr CoerceListToFixedPoint(const AEDesc *fromDesc, DescType toType, long /*handlerRefcon*/,
									AEDesc *toDesc)
{
	OSErr err = errAECoercionFail;

	BailIf(!toDesc, paramErr);
	toDesc->descriptorType = typeNull;
	toDesc->dataHandle = NULL;

	if ((fromDesc->descriptorType == typeAEList) && (toType == typeFixedPoint))
	{
		CFixedPoint_AC fixedPointValue;

		long theCount = 0;
		BailOSErr(AECountItems(fromDesc, &theCount));
		BailIf(theCount != 2, paramErr);

		DescType theAEKeyword;
		CAEDesc theDesc;
		BailOSErr(AEGetNthDesc(fromDesc, 1, typeFixed, &theAEKeyword, theDesc));
		fixedPointValue.x = **reinterpret_cast<Fixed **>(theDesc.dataHandle);

		BailOSErr(AEGetNthDesc(fromDesc, 2, typeFixed, &theAEKeyword, theDesc));
		fixedPointValue.y = **reinterpret_cast<Fixed **>(theDesc.dataHandle);

		BailOSErr(AECreateDesc(typeFixedPoint, &fixedPointValue, sizeof(fixedPointValue), toDesc));
		err = noErr;
	}

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// CoerceFixedToFloat
//----------------------------------------------------------------------------------------

pascal OSErr CoerceFixedToFloat(DescType typeCode, const void *dataPtr, Size dataSize, 
								DescType toType, long /*handlerRefcon*/, AEDesc *result)
{
	OSErr err = errAECoercionFail;

	BailIf(!result, paramErr);
	result->descriptorType = typeNull;
	result->dataHandle = NULL;

	if ((typeCode == typeFixed) && (toType == typeFloat))
	{
		BailIf(dataSize != sizeof(Fixed), paramErr);

		Fixed fixedValue = *static_cast<const Fixed*>(dataPtr);
		double floatValue = Fix2X(fixedValue);
		BailOSErr(AECreateDesc(typeFloat, &floatValue, sizeof(floatValue), result));
		err = noErr;
	}

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// CoerceFloatToFixed
//----------------------------------------------------------------------------------------

pascal OSErr CoerceFloatToFixed(DescType typeCode, const void *dataPtr, Size dataSize, 
								DescType toType, long /*handlerRefcon*/, AEDesc *result)
{
	OSErr err = errAECoercionFail;

	BailIf(!result, paramErr);
	result->descriptorType = typeNull;
	result->dataHandle = NULL;

	if ((typeCode == typeFloat) && (toType == typeFixed))
	{
		BailIf(dataSize != sizeof(double), paramErr);

		double floatValue = *static_cast<const double*>(dataPtr);
		Fixed fixedValue = X2Fix(floatValue);
		BailOSErr(AECreateDesc(typeFixed, &fixedValue, sizeof(fixedValue), result));
		err = noErr;
	}

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// GetFixed:
//----------------------------------------------------------------------------------------

Fixed GetFixed(const CAEDesc& thePropertyValue)
{
	Fixed value;

	if (thePropertyValue.GetDescriptorType() == typeFixed)
	{
		value = CAEFixed_AC(thePropertyValue);
	}
	else if (thePropertyValue.GetDescriptorType() == typeFloat)
	{
		double floatValue = CAEFloat_AC(thePropertyValue);
		value = X2Fix(floatValue);
	}
	else
	{
		CTempDesc tempDesc(thePropertyValue.CoerceDesc(typeFloat));
		double floatValue = CAEFloat_AC(tempDesc);
		value = X2Fix(floatValue);
	}

	return value;
}

//----------------------------------------------------------------------------------------
// PutFixed:
//----------------------------------------------------------------------------------------

void PutFixed(CAEDesc& thePropertyValue, Fixed value)
{
	double floatValue = Fix2X(value);
	thePropertyValue.reset(typeFloat, &floatValue, sizeof(floatValue));
}

//----------------------------------------------------------------------------------------
// PutProperty
//----------------------------------------------------------------------------------------

void PutProperty(CAEDesc& thePropertyValue, DescType propertyType, const void* value,
				 long propertySize)
{
	if ((propertyType == typeChar) || (propertyType == typeIntlText))
		thePropertyValue.PutString(CString_AC(static_cast<const char*>(value), propertySize));
	else if (propertyType == typeFixed)
		PutFixed(thePropertyValue, *static_cast<const Fixed *>(value));
	else if ((propertyType == typeFixedPoint) || (propertyType == cQDPoint))
		ThrowIfOSErr_AC( AECoercePtr(propertyType, value, propertySize, typeAEList, thePropertyValue) );
	else if (propertyType == typeBoolean)
		thePropertyValue.PutBoolean(*static_cast<const short *>(value));
	else
		thePropertyValue.reset(propertyType, value, propertySize);
}


//----------------------------------------------------------------------------------------
// TempFSSpecDesc
//----------------------------------------------------------------------------------------

CTempDesc TempFSSpecDesc(const CFSSpec_AC& fileSpec)
{
	CTempDesc desc;
	desc.PutFSSpec(fileSpec);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempRectDesc
//----------------------------------------------------------------------------------------

CTempDesc TempRectDesc(const CRect_AC& theRect)
{
	CTempDesc desc;
	desc.PutRect(theRect);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempTypeDesc
//----------------------------------------------------------------------------------------

CTempDesc TempTypeDesc(DescType theType)
{
	CTempDesc desc;
	desc.PutType(theType);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempStringDesc
//----------------------------------------------------------------------------------------

CTempDesc TempStringDesc(const CString_AC& theString)
{
	CTempDesc desc;
	desc.PutString(theString);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempBooleanDesc
//----------------------------------------------------------------------------------------

CTempDesc TempBooleanDesc(bool theBoolean)
{
	CTempDesc desc;
	desc.PutBoolean(theBoolean);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempEnumDesc
//----------------------------------------------------------------------------------------

CTempDesc TempEnumDesc(DescType theEnum)
{
	CTempDesc desc;
	desc.PutEnum(theEnum);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempLongDesc
//----------------------------------------------------------------------------------------

CTempDesc TempLongDesc(long theLong)
{
	CTempDesc desc;
	desc.PutLong(theLong);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempDateTimeDesc
//----------------------------------------------------------------------------------------

CTempDesc TempDateTimeDesc(unsigned long theDateTime)
{
	CTempDesc desc;
	desc.PutDateTime(theDateTime);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempRGBColorDesc
//----------------------------------------------------------------------------------------

CTempDesc TempRGBColorDesc(const CRGBColor_AC& theColor)
{
	CTempDesc desc;
	desc.PutRGBColor(theColor);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempObjectDesc
//----------------------------------------------------------------------------------------

CTempDesc TempObjectDesc(MScriptableObject* theObject)
{
	CTempDesc desc;
	PutObject(desc, theObject);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempFixedDesc
//----------------------------------------------------------------------------------------

CTempDesc TempFixedDesc(Fixed value)
{
	CTempDesc desc;
	PutFixed(desc, value);
	return desc.release();
}

//----------------------------------------------------------------------------------------
// TempPropertyDesc
//----------------------------------------------------------------------------------------

CTempDesc TempPropertyDesc(DescType propertyType, const void* value, long propertySize)
{
	CTempDesc desc;
	PutProperty(desc, propertyType, value, propertySize);
	return desc.release();
}


//----------------------------------------------------------------------------------------
// End of UAEUtils.cpp

