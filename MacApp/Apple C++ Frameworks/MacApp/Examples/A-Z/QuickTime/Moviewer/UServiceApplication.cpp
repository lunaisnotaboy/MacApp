//----------------------------------------------------------------------------------------
// UServiceApplication.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		12/08/99	Include UDebug.h for gIntenseDebugging.  Include UPerform.h for 
							PerfMonitorEnabled and EnablePerfMonitor.  Change iter to 
							iterA in CountPalettes.
		11/11/99	Upgrade to Universal headers 3.3 and Carbon.
		06/06/99	Moved into MacApp examples. 
							Tweak to build with MacApp R14. 
		12/04/98	Undo previous change so it can build with a vanilla R13.4. 
		10/16/98	GetEvent now allows events to be allocated on the stack. 
							Change operator const char* to AsText. 
		09/30/98	Use typedefs for Inherited. 
		09/21/98	Noload build. 
		09/21/98	Count service windows as palettes. 
		09/14/98	Try using service windows. 
*/

#ifndef __UServiceApplication__
#include "UServiceApplication.h"
#endif

// Moviewer

#ifndef __Moviewer_r__
#include "Moviewer.r.h"
#endif

#ifndef __UServiceWindow__
#include "UServiceWindow.h"
#endif

// MacApp

#ifndef PLATFORMMEMORY_H
#include "PlatformMemory.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UPERFORM__
#include "UPerform.h"
#endif

// Toolbox

#ifndef __TEXTSERVICES__
#include <TextServices.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

//========================================================================================
// GLOBAL Variables
//========================================================================================

bool gHasTextServices;

//========================================================================================
// GLOBAL Functions
//========================================================================================

void InitializeTSM();

//----------------------------------------------------------------------------------------
// InitializeTSM
//----------------------------------------------------------------------------------------

void InitializeTSM()
{
#if qCarbon
// Carbon pre-intializes TSM, so no need to check.
	gHasTextServices = true;
#else
	// Determine whether the Text Services Manager is available
	gHasTextServices = HasTSM();

	// Register this application with the TSM
	if (gHasTextServices)
	{
		OSErr err = ::InitTSMAwareApplication();
		if (err != noErr)
			gHasTextServices = false;
	}
#endif
}

//========================================================================================
// CLASS TServiceApplication
//========================================================================================

MA_DEFINE_CLONE(TServiceApplication);

//----------------------------------------------------------------------------------------
// TServiceApplication constructor
//----------------------------------------------------------------------------------------

TServiceApplication::TServiceApplication(OSType itsMainFileType,
										 OSType itsCreator) :
	Inherited(itsMainFileType, itsCreator)
{
	InitializeTSM();
	InitUServiceWindow();
}

//----------------------------------------------------------------------------------------
// TServiceApplication destructor
//----------------------------------------------------------------------------------------

TServiceApplication::~TServiceApplication()
{
}

//----------------------------------------------------------------------------------------
// TServiceApplication::Terminate
//----------------------------------------------------------------------------------------

void TServiceApplication::Terminate() // override
{
#if !qCarbon
// No need to terminate in Carbon
	// Terminate TSM if necessary
	if (gHasTextServices)
		::CloseTSMAwareApplication();
#endif
}

//----------------------------------------------------------------------------------------
// TServiceApplication::GetEvent - MEB experimental -Call TSMEvent after WaitNextEvent
//----------------------------------------------------------------------------------------

bool TServiceApplication::GetEvent(short eventMask, unsigned long sleep, RgnHandle sleepRegion,
								   TToolboxEvent& event) // override
{
	bool gotAnEvent = false;

	if (--gRsrcCheck <= 0)
	{
		CheckRsrcUsage();
		gRsrcCheck = kRsrcCheckInterval;
	}

#if qDebug
	if (gIntenseDebugging && gReportEvent)
	{
		ProgramReport_AC("WaitNextEvent: sleep=0%d", sleep);
		// faceless driver bug fixed in MF 7.0 
		if (!sleepRegion)
			ProgramReport_AC(", sleep region=nil");
		else
		{
			CRect_AC bBox = CRegion_AC(sleepRegion).Bounds();
			ProgramReport_AC(", sleep region = %s", bBox.AsText());
		}
		ProgramReport_AC("\n");

	}

	if (gShowCursorRegion || gShowHelpRegion || gShowSleepRegion)
	{
		if (gShowCursorRegion)
			ShowGlobalRegion(fCursorRegion);

		if (gShowHelpRegion)
			ShowGlobalRegion(fHelpRegion);

		if (gShowSleepRegion)
			ShowGlobalRegion(fSleepRegion);

		sleep = 60;
	}

#endif // qDebug

	// If we are in a nested event level than don't turn off the busy cursor since we are
	// probably in the middle of an idle or filter proc and don't want to turn on and off
	// the busy cursor each time it gets to service an event.
	bool oldActivateBusyCursor;
	if (fEventLevel <= 1)
		oldActivateBusyCursor = ActivateBusyCursor(false);				// Turn off busy cursor while we're away.

#if qPerform
	bool oldSetting = PerfMonitorEnabled();
#endif

	// Foreground applications don't really "sleep" so we have a code here to just hang around
	// til we get an event OR the sleep time expires
    unsigned long sleepTil = TickCount() + sleep;
    unsigned long snooze;
    do
    {
    	unsigned long now = TickCount();
    	
    	// don't use Max_AC with a subtraction instead of the comparison b/c the unsigned value
    	// won't go negative for overdue sleep and we'll sleep forever.
		snooze = (sleepTil > now) ? sleepTil - now : 0;

        // SystemEvents aren't queued and will be lost if not retrieved when available. So we
        // ensure here that they are always retrieved by adding osMask.
        EventRecord anEvent;
#if qDebug
		// Here is some guard code that checks to be sure that the CurResFile does
		// not change over a call to WNE.
		short	oldResFile = ::CurResFile_AC();
#endif
		bool	gotEvent = WaitNextEvent(eventMask | osMask, &anEvent, snooze, sleepRegion);
#if qDebug
		short	newResFile = ::CurResFile_AC();
		if (oldResFile != newResFile)
		{
			ProgramBreak_AC("TDispatcher::GetEvent (1): CurResFile was modified over WNE.  Old = %d, New  = %d.", oldResFile, newResFile);
			::UseResFile_AC(oldResFile);
		}
#endif
        if (gotEvent)
        {
#if qCarbon
#pragma warning ("Carbon: not supporting carbon TSMEvent" __FILE__)
#else
       	// MEB - experimental
        	if (gHasTextServices) 
        		if (TSMEvent(&anEvent))	// give TSM a chance to handle it
        			break;
#endif
//			{
//				CTempObjectAllocation tempObjectAllocation(true);
//				event = TH_new TToolboxEvent(this, &anEvent);
//			}
			gotAnEvent = true;
			event.SetMainEvent(anEvent);
            if (event.IsDoubleEvent())
            {
                // The event was part of a pair used to input 16 bit characters
                // Retrieve the second half of the pair immediately.
                // NOTE: although you would think that the second event can be retrieved with GetOSEvent
                // The two byte sytems (KanjiTalk, etc.) seem to only return the second byte thru Wait/GetNextEvent.
                EventRecord secondaryEvent;
#if qDebug
				// More guard code to checks that the CurResFile does not change over a call to WNE.
				oldResFile = ::CurResFile_AC();
#endif
				gotEvent = WaitNextEvent(keyDownMask | keyUpMask | autoKeyMask, &secondaryEvent, 0, NULL);
#if qDebug
				newResFile = ::CurResFile_AC();
				if (oldResFile != newResFile)
				{
					ProgramBreak_AC("TDispatcher::GetEvent (2): CurResFile was modified over WNE.  Old = %d, New  = %d.", oldResFile, newResFile);
					::UseResFile_AC(oldResFile);
				}
#endif
                if (gotEvent)
                    event.AddSecondaryKeyEvent(secondaryEvent);
            }

            // We have an event, let's go
           break;
        }
    } while (snooze && fAllowApplicationToSleep && IsFrontProcess());


#if qPerform
	EnablePerfMonitor(oldSetting);
#endif

	if (fEventLevel <= 1 && IsFrontProcess())						// If we're not in the background, then 
		ActivateBusyCursor(oldActivateBusyCursor);					// restore the busy cursor mechanism. 

	return gotAnEvent;
}

//----------------------------------------------------------------------------------------
// TServiceApplication::DoSetCursor - call SetTSMCursor before SetCursor
//----------------------------------------------------------------------------------------

void TServiceApplication::DoSetCursor(CPoint_AC globalMouse, RgnHandle cursorRegion) // override
{
	if (!(gHasTextServices
#if !qCarbon
		&& SetTSMCursor(globalMouse)
#endif
		))
	{
		GetDefaultCursorRegion(globalMouse, cursorRegion);
		SetCursorToArrow_AC();
	}
}

//----------------------------------------------------------------------------------------
// TServiceApplication::HandleMouseDown: 
//----------------------------------------------------------------------------------------

void TServiceApplication::HandleMouseDown(TToolboxEvent* event) // override
{
	WindowRef aWMgrWindow;
	short whereMouseDown = FindWindow(event->GetWhere(), &aWMgrWindow);
#if qCarbon
#pragma warning ("Carbon: FindServiceWindow replaced by Window Manager API" __FILE__)
#else
	if (!whereMouseDown && !aWMgrWindow && HasFloatingWindowService())
		whereMouseDown = FindServiceWindow(event->GetWhere(), &aWMgrWindow);
#endif
	event->SetClickCount(CountClicks(event, whereMouseDown));

	TWindow * aWindow = TWindow::WMgrToWindow(aWMgrWindow);

	bool proceed = true;

	if ((whereMouseDown != inMenuBar) && InModalState() && (aWindow != (GetActiveWindow(kNoFloaters))))
	{
		//
		// Allow command drag of behind windows
		//
		if ((whereMouseDown != inDrag) || !event->IsCommandKeyPressed())
		{
			Beep(2);
			proceed = false;
		}
	}

	if (proceed)
		switch (whereMouseDown)
		{
			case inMenuBar:
				{								// 3.5
					SetupTheMenus();			// gives application a chance to setup individual menu items
					SetCursorToArrow_AC();
					long menuItem = MenuSelect(event->GetWhere());
					MenuEvent(HiWord(menuItem), LoWord(menuItem));
				}
				break;
#if !qCarbon
			case inSysWindow:
				SystemClick(&event->GetEventRecord(0), (WindowPtr)aWMgrWindow);
				break;
#endif
			default:							// if a MacApp window was associated with the WindowRef then let the window object decide
				// what to do with the mouse click
				if (aWindow)
				{
					if (aWindow->Focus())		// if we can't focus, we're in trouble 
						aWindow->HandleMouseDown(aWindow->SuperViewToLocal(event->GetWhere()), event, GetStdHysteresis());
#if qDebug
					else
						::ProgramBreak_AC("In TDispatcher::HandleMouseDown: couldn't focus on a window object!");
#endif

				}
				else
					HandleAlienEvent(event);
				break;

		}

	fLastUpTime = TickCount();					// Because the toolbox often eats mouseUpEvents remember the time on the way out for
	// double/ triple detection.
}

//----------------------------------------------------------------------------------------
// TServiceApplication::MenuEvent
//----------------------------------------------------------------------------------------

void TServiceApplication::MenuEvent(short theMenuNumber, short theItemNumber) // override
{
	bool handled = false;

	if (gHasTextServices)
	{
#if qCarbon
#pragma warning ("Carbon: deal with TSM menu event" __FILE__)
#else
		long menuItem = (theMenuNumber << 16) || theItemNumber;
		handled = TSMMenuSelect(menuItem);
#endif
		HiliteMenu(0); // needed even if TSM or Script Manager handles the menu
	}

	if (!handled)
		Inherited::MenuEvent(theMenuNumber, theItemNumber);
}

//----------------------------------------------------------------------------------------
// TServiceApplication::DoIdle: 
//----------------------------------------------------------------------------------------

bool TServiceApplication::DoIdle(IdlePhase phase) // override
{
	if (phase == idleContinue)
	{
#if qCarbon
#pragma warning ("Carbon: Handle TSM DoIdel" __FILE__)
#else
		WindowPeek w = reinterpret_cast<WindowPeek>(TServiceWindow::MAFrontServiceWindow());
		while (w)
		{
			if (w->visible && !EmptyRgn(w->updateRgn))
			{
				TWindow* aWindow = TWindow::WMgrToWindow(reinterpret_cast<WindowRef>(w));
				if (aWindow)
					aWindow->Update();
			}
			w = w->nextWindow;
		}
#endif
	}
	return Inherited::DoIdle(phase);
}

#if qAppleEventAware
//----------------------------------------------------------------------------------------
// TServiceApplication::CountContainedObjects: 
//----------------------------------------------------------------------------------------

long TServiceApplication::CountContainedObjects(DescType desiredType) // override
{
	long result = 0;

	switch (desiredType)
	{
		case cPalette:
			result = CountPalettes();
			break;

		default:
			result = Inherited::CountContainedObjects(desiredType);
			break;
	}

	return result;
}

//----------------------------------------------------------------------------------------
// TServiceApplication::CountPalettes: 
//----------------------------------------------------------------------------------------

long TServiceApplication::CountPalettes()
{
	long result = 0;

	// Go through the window list and count the visible windows.
	for (CServiceWindowIterator iter; iter; ++iter)
	{
		TWindow* aWindow = TWindow::WMgrToWindow(iter);
		if (aWindow && aWindow->IsShown())
			++result;
	}

	for (CWMgrIterator iterA; iterA; ++iterA)
	{
		TWindow* aWindow = TWindow::WMgrToWindow(iterA);
		if (aWindow && aWindow->IsShown() && aWindow->GetFloats())
			++result;
	}

	return result;
}

//----------------------------------------------------------------------------------------
// TServiceApplication::GetObjectProperty: 
//----------------------------------------------------------------------------------------
bool TServiceApplication::GetObjectProperty(CAEDesc& thePropertyValue,
											DescType whichProperty,
											const CAEDesc& desiredType) // override
{
	bool hasProperty = false;

	if (whichProperty == pUserSelection)
	{
		TDocument* theDoc = GetDocumentByIndex(cDocument, 1);
		if (theDoc)
		{
			TDesignator* theUserSelection = theDoc->GetUserSelection();
			if (theUserSelection)
			{
				CAEDesc propData;
				theUserSelection->MakeObjectSpecifier(propData, formPropertyID);
				thePropertyValue = propData;

				hasProperty = true;
			}
		}
	}

	if (!hasProperty)
		hasProperty = Inherited::GetObjectProperty(thePropertyValue, whichProperty, desiredType);

	return hasProperty;
}

//----------------------------------------------------------------------------------------
// TServiceApplication::GetPaletteByIndex: 
//----------------------------------------------------------------------------------------

TWindow* TServiceApplication::GetPaletteByIndex(short index) // override
{
	TWindow* indexedPalette = NULL;

	short paletteCount = 0;

	for (CServiceWindowIterator iter; iter; ++iter)
	{
		TWindow* tempWindow = TWindow::WMgrToWindow(iter);
		if (tempWindow && tempWindow->IsShown())
		{
			++paletteCount;
			if (paletteCount == index)
			{
				indexedPalette = tempWindow;
				break;
			}
		}
	}

	if (!indexedPalette)
	{
		for (CWMgrIterator iter; iter; ++iter)
		{
			if (TWindow::IsFloatWindow(iter))
			{
				TWindow* tempWindow = TWindow::WMgrToWindow(iter);
				if (tempWindow && tempWindow->IsShown())
				{
					++paletteCount;
					if (paletteCount == index)
					{
						indexedPalette = tempWindow;
						break;
					}
				}
			}
		}
	}

	return indexedPalette;
}

//----------------------------------------------------------------------------------------
// TServiceApplication::GetDocumentByIndex: 
//----------------------------------------------------------------------------------------

TDocument* TServiceApplication::GetDocumentByIndex(DescType desiredType, short desiredIndex) // override
{
	// Go through the window list and count to the Nth window associated with a document
	// of the desired type.  Only count the first window for each document just
	// in case a document has more than one window.

	TDocument* indexedDocument = NULL;

	// Make a list for all of the documents we find until we find the one we want.
	CList_AC aDocList;
	short documentsSeen = 0;

	for (CServiceWindowIterator serviceWindow; serviceWindow; ++serviceWindow)
	{
		TWindow* tempWindow = TWindow::WMgrToWindow(serviceWindow);
		if (tempWindow && tempWindow->IsShown())
		{
			TDocument* aDocument = tempWindow->GetDocument();
			if (aDocument && (aDocument->GetOMClass() == desiredType))
			{
				// See if this document is already in the list.
				if (!aDocList.GetIdentityItemNo(aDocument))
				{
					if (++documentsSeen == desiredIndex)
					{
						indexedDocument = aDocument;
						break;
					}

					aDocList.InsertLast(aDocument);
				}
			}
		}
	}

	if (!indexedDocument)
	{
		for (CWMgrIterator window; window; ++window)
		{
			TWindow* tempWindow = TWindow::WMgrToWindow(window);
			if (tempWindow && tempWindow->IsShown())
			{
				TDocument* aDocument = tempWindow->GetDocument();
				if (aDocument && (aDocument->GetOMClass() == desiredType))
				{
					// See if this document is already in the list.
					if (!aDocList.GetIdentityItemNo(aDocument))
					{
						if (++documentsSeen == desiredIndex)
						{
							indexedDocument = aDocument;
							break;
						}

						aDocList.InsertLast(aDocument);
					}
				}
			}
		}
	}

	return indexedDocument;
}

#endif // qAppleEventAware


//----------------------------------------------------------------------------------------
// End of UServiceApplication.cpp
