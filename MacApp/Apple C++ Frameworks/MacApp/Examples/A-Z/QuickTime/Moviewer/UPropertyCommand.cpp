//----------------------------------------------------------------------------------------
// UPropertyCommand.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		11/16/99	Carbon: TPropertyCommand::UndoIt update to Carbon.
		06/06/99	Moved into MacApp examples. 
		09/30/98	Use typedefs for Inherited. 
		09/21/98	Noload build. 
		09/14/98	Initial version. 
*/

#ifndef __UPropertyCommand__
#include "UPropertyCommand.h"
#endif

#if qAppleEventAware

// MacApp

// ACS

// Toolbox

#ifndef __AEREGISTRY__
#include <AERegistry.h>
#endif

// ANSI


//==================================================================================================
// TPropertyCommand
//==================================================================================================

//----------------------------------------------------------------------------------------
// TPropertyCommand constructor
//----------------------------------------------------------------------------------------

TPropertyCommand::TPropertyCommand(DescType theProperty,
								   CList_AC* theObjectsToSet,
								   TAppleEvent* message,
								   TAppleEvent* /*reply*/) :
	Inherited(cNoCommand, NULL, kCanUndo, kCausesChange, NULL),
	fProperty(theProperty),
	fOldPropData(),
	fNewPropData()
{
	// We take charge of the temporary objects in the disposal list so we can use them
	// during execution of this command.
	// We'll free these when we commit.
	CList_AC* theDisposalList = TOSADispatcher::fgDispatcher->GetTemporaryTokens();
	fObjectsToFree.Merge(theDisposalList);
	theDisposalList->DeleteAll();

	// We'll clone the list so the caller can free it immediately.
	fObjectsToSet.Merge(theObjectsToSet);
	MScriptableObject* theFirstObject = fObjectsToSet.First();
	::ThrowIfNULL_AC(theFirstObject);

	// Get the info for this command from the object.
	CommandNumber cmdNum;
	bool canUndo;
	bool causesChange;
	TCommandHandler* itsContext = NULL;
	theFirstObject->GetSetPropertyInfo(theProperty, cmdNum, canUndo, causesChange, itsContext);

	fContext = itsContext;
	fObjectToNotify = itsContext;
	fCanUndo = canUndo;
	fCausesChange = causesChange;
	fIdentifier = cmdNum;

	fOldPropData = NULL;

	message->ReadParameter(keyAEData, typeWildCard, fNewPropData);
}

//----------------------------------------------------------------------------------------
// TPropertyCommand constructor
//----------------------------------------------------------------------------------------

TPropertyCommand::TPropertyCommand(DescType theProperty,
								   MScriptableObject* objectToSet,
								   const CAEDesc& newPropData) :
	Inherited(cNoCommand, NULL, kCanUndo, kCausesChange, NULL),
	fProperty(theProperty),
	fOldPropData(),
	fNewPropData()
{
	fUseAppleEvent = true;

	fObjectsToSet.Insert(objectToSet);

	// Get the info for this command from the object.
	CommandNumber cmdNum;
	bool canUndo;
	bool causesChange;
	TCommandHandler* itsContext = NULL;
	::ThrowIfNULL_AC(objectToSet);
	objectToSet->GetSetPropertyInfo(theProperty, cmdNum, canUndo, causesChange, itsContext);

	fContext = itsContext;
	fObjectToNotify = itsContext;
	fCanUndo = canUndo;
	fCausesChange = causesChange;
	fIdentifier = cmdNum;

	fOldPropData = NULL;

	ThrowIfOSErr_AC(AEDuplicateDesc(newPropData, &fNewPropData));
}

//----------------------------------------------------------------------------------------
// TPropertyCommand::~TPropertyCommand
//----------------------------------------------------------------------------------------

TPropertyCommand::~TPropertyCommand()
{
	while (fObjectsToFree.GetSize() > 0)
		delete fObjectsToFree.Pop();
}

//----------------------------------------------------------------------------------------
// TPropertyCommand::MakeAppleEvent
//----------------------------------------------------------------------------------------

TAppleEvent* TPropertyCommand::MakeAppleEvent()
{
	MScriptableObject* objectToSet = fObjectsToSet.First();
	CAutoPtr_AC<TSetPropertyEvent> theEvent =
		TH_new TSetPropertyEvent(gServerAddress, kAENoReply, objectToSet, fProperty);

	theEvent->WriteParameter(keyAEData, fNewPropData);

	return theEvent.release();
}

//----------------------------------------------------------------------------------------
// TPropertyCommand::DoIt
//----------------------------------------------------------------------------------------

void TPropertyCommand::DoIt()
{
	CAEDesc theOldPropList;
	if (fCanUndo)
	{
		theOldPropList.CreateList();

		for (CListOfMScriptable::Iterator iter(&fObjectsToSet); iter; ++iter)
		{
			CTempDesc thePropData;
			(*iter).GetObjectProperty(thePropData, fProperty, CAEDesc::fgNullDesc);
			::ThrowIfOSErr_AC(AEPutDesc(theOldPropList, 0, thePropData));
		}
	}
	fOldPropData = theOldPropList;
		
	RedoIt();
}

//----------------------------------------------------------------------------------------
// TPropertyCommand::UndoIt
//----------------------------------------------------------------------------------------

void TPropertyCommand::UndoIt()
{
	CAEDesc theOldPropData(fOldPropData);
#if qCarbon
	::Assertion_AC(theOldPropData.GetDataSize() != 0, "Trying to undo with no data!");
#else
	::Assertion_AC(theOldPropData.GetDataHandle() != NULL, "Trying to undo with no data!");
#endif
	short listIndex = 1;

	for (CListOfMScriptable::Iterator iter(&fObjectsToSet); iter; ++iter)
	{
		CTempDesc theOldPropDesc;
		DescType theActualKey;
		::ThrowIfOSErr_AC(AEGetNthDesc(theOldPropData, listIndex++, typeWildCard, &theActualKey, theOldPropDesc));

		(*iter).SetObjectProperty(theOldPropDesc, fProperty);
	}
}

//----------------------------------------------------------------------------------------
// TPropertyCommand::RedoIt
//----------------------------------------------------------------------------------------

void TPropertyCommand::RedoIt()
{
	CAEDesc thePropData(fNewPropData);
	for (CListOfMScriptable::Iterator iter(&fObjectsToSet); iter; ++iter)
		(*iter).SetObjectProperty(thePropData, fProperty);
}


#endif // qAppleEventAware

//----------------------------------------------------------------------------------------
// End of UPropertyCommand.cpp
