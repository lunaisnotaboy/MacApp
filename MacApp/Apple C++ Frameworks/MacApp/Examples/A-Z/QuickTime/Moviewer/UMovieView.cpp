//----------------------------------------------------------------------------------------
// UMovieView.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		09/11/00	GetClipRegion method should only be used on the view's port. 
		07/24/00	CW Pro 6: casting pointer to long. 
							Won't do CMovieController_AC == MovieController. 
		03/14/00	Movie can't be done until it's been started playing. 
		11/12/99	Update to Carbon, Universal headers 3.3, and new AEDesc_AC
							methods.
		07/16/99	Clear the movie's gworld when closing the view. Prevents a
							bad crash after playing some kinds of movies. 
		06/06/99	Moved into MacApp examples. 
							Moved QTClassLib into ACS. 
		12/21/98	Remove PrePreroll support. 
		12/18/98	Don't allow remote closing while in present mode. 
		12/12/98	Don't depend on PrePreroll if it isn't in the headers. 
		12/12/98	Use controller instead of movie where possible. 
							Add PrePreroll support. 
							Move most of the full screen code into TFullScreenCommand. 
		12/10/98	Streaming movie support. 
		12/09/98	Present movie mode. 
		12/04/98	Clean up for final. 
		09/30/98	Use typedefs for Inherited. 
		09/21/98	UpdateCoordinates is const now. 
		09/14/98	Move menu commands to the document so they can be recorded. 
		07/30/98	Set selection also sets time to start of selection. 
							Move quit/close when done code from SetIdleIfMoviePlaying
							to IdleMovies. SetPlaying calls SetIdleIfMoviePlaying. 
							Add calls to invalidate movie clip and ensure it's valid. 
							Set the clip wide open if possible. Don't set the clip
							when the view isn't shown yet. 
							Add IsDone. Support selection duration of -1. 
		07/12/98	Set playing from script doesn't obey play selection only. 
		06/25/98	Play selection. 
		06/24/98	QuickTime registration. Don't set movie GWorld to NULL. 
		06/24/98	Set playing. 
		06/21/98	Add SetSelection, SetTimeValue. 
		06/14/98	Cut and paste. 
		06/12/98	Full screen. 
		06/06/98	Add action filter, resize view when controller size changes. 
		05/16/98	Initial version. 
*/

#ifndef __UMovieView__
#include "UMovieView.h"
#endif

// Moviewer

#ifndef __Moviewer_r__
#include "Moviewer.r.h"
#endif

#ifndef __UFullScreen__
#include "UFullScreen.h"
#endif

#ifndef __UMovieDocument__
#include "UMovieDocument.h"
#endif

// MacApp

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CFixedPoint_AC__
#include "CFixedPoint_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CMovie_AC__
#include "CMovie_AC.h"
#endif

#ifndef __Configuration_AC__
#include "Configuration_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

#ifndef __WindowUtils_AC__
#include "WindowUtils_AC.h"
#endif

#ifndef __dout_AC__
#include "dout_AC.h"
#endif

// Toolbox

#ifndef __COMPONENTS__
#include <Components.h>
#endif

#ifndef __FILES__
#include <Files.h>
#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#if qDebug
	#ifndef __SOUND__
	#include <Sound.h>
	#endif
#endif


//========================================================================================
// CLASS TMovieView
//========================================================================================

MA_DEFINE_CLASS(TMovieView);

//----------------------------------------------------------------------------------------
// TMovieView Global Data
//----------------------------------------------------------------------------------------

CTempMCActionFilterWithRefConUPP TMovieView::fgActionFilter;

//----------------------------------------------------------------------------------------
// TMovieView Constructor
//----------------------------------------------------------------------------------------

TMovieView::TMovieView() :
	fMovie(NULL),
	fMovieController(NULL),
	fWasPlaying(false),
	fMovieClipIsValid(false),
	fLoop(false),
	fFullScreen(NULL)
{
}

//----------------------------------------------------------------------------------------
// TMovieView Destructor
//----------------------------------------------------------------------------------------

TMovieView::~TMovieView()
{
	EndPresent();

	if (fIdler)
		fIdler->Remove();

	fMovieController.reset();
}

//----------------------------------------------------------------------------------------
// TMovieView::DoPostCreate
//----------------------------------------------------------------------------------------

void TMovieView::DoPostCreate(TDocument* itsDocument)
{
	Inherited::DoPostCreate(itsDocument);

	InvalidateMovieClip();

	fLoop = false;

	fMovieController = (MovieController)OpenDefaultComponent(MovieControllerComponentType, kAnyComponentSubType);
	ThrowIfNULL_AC(fMovieController);

	SetActionFilter();

	BeInPort(GetGrafPort());
	fMovieController.SetVisible(fShown);
	fMovieController.DoActionSetKeysEnabled(TRUE);

	// enable the default movie controller editing
	fMovieController.EnableEditing(true);
		
	// suppress movie badge
	fMovieController.DoActionSetUseBadge(false);

	fMovieSize = enumNormalSize;
	SetMovieSize(fMovieSize);
}

//----------------------------------------------------------------------------------------
// TMovieView::BeInDocument
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMovieView::Close
//----------------------------------------------------------------------------------------

void TMovieView::Close() // override
{
	if (fFullScreen)
		ThrowError_AC(errBusyPresenting);

	if (fMovieController)
	{
		fMovieController.SetMovie(NULL, NULL, gZeroPt);
		fMovieController.reset();
	}
	
	if (fMovie)
		fMovie.SetGWorld(NULL, NULL);
		
	Inherited::Close();
}

//----------------------------------------------------------------------------------------
// TMovieView::HaveMovie
//----------------------------------------------------------------------------------------

void TMovieView::HaveMovie(Movie movie)
{
	fMovie = movie;

	Focus();

	if (fMovieController)
	{
		fMovieController.SetMovie(fMovie, GetWindowFromPort_AC(GetGrafPort()), gZeroPt);
//		fMovieController.SetControllerAttached(false);
		fMovieController.DoActionSetLooping(fLoop);
	}
	else if (fMovie)
		fMovie.SetGWorld((CGrafPtr)GetGrafPort(), NULL);

	AdjustFrame();
	if (fSuperView)
		fSuperView->AdjustFrame();

	SetMovieSize(fMovieSize);

	InvalidateMovieClip();
}

//----------------------------------------------------------------------------------------
// TMovieView::ShowController
//----------------------------------------------------------------------------------------

void TMovieView::ShowController(bool shown)
{
	if (!fMovieController)
		ThrowError_AC(minErr);

	fMovieController.SetVisible(shown);
	fMovieController.MovieChanged(fMovie);
	AdjustFrame();
	InvalidateMovieClip();
}

//----------------------------------------------------------------------------------------
// TMovieView::IsControllerShown
//----------------------------------------------------------------------------------------

bool TMovieView::IsControllerShown() const
{
	return fMovieController.GetVisible();
}

//----------------------------------------------------------------------------------------
// TMovieView::SetLoop
//----------------------------------------------------------------------------------------

void TMovieView::SetLoop(bool loop)
{
	fLoop = loop;

	if (fMovieController)
		fMovieController.DoActionSetLooping(fLoop);
}

//----------------------------------------------------------------------------------------
// TMovieView::SetMovieSize
//----------------------------------------------------------------------------------------

void TMovieView::SetMovieSize(DescType newSize)
{
	fMovieSize = newSize;

	if (fMovie)
	{
		CRect_AC box(fMovie.GetNaturalBoundsRect());
		CPoint_AC boxSize(box.GetSize());

		switch (fMovieSize)
		{
			case enumHalfSize:
				boxSize.h >>= 1;
				boxSize.v >>= 1;
				break;

			case enumNormalSize:
				break;

			case enumDoubleSize:
				boxSize.h <<= 1;
				boxSize.v <<= 1;
				break;

			case enumFitToScreen:
				{
					TWindow* window = GetWindow();
					if (window)
					{
						CRect_AC screenRect;
						window->GetMaxIntersectedDevice(screenRect);
						CFixedPoint_AC screenSize(screenRect.GetSize() - window->GetContentDifference());
						screenSize /= boxSize;
						if (screenSize.x > screenSize.y)
							screenSize.x = screenSize.y;
						else
							screenSize.y = screenSize.x;
						screenSize *= boxSize;
						boxSize = screenSize.AsPoint();
					}
				}
				break;
		}
		
		box[botRight] = box[topLeft] + boxSize;

		CRect_AC oldBox(fMovie.GetBox());
		if (box != oldBox)
		{
			fMovie.SetBox(&box);
			if (fMovieController)
				fMovieController.MovieChanged(fMovie);
		}

		// Call AdjustFrame even if the size hasn't changed, so we can be sure
		// it is called at least once when a movie is opened. 
		AdjustFrame();

		TWindow* window = GetWindow();
		if (window)
			window->ForceOnScreen();

		gDispatcher->InvalidateCursorRgn();
		InvalidateMovieClip();
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::SetFrame
//----------------------------------------------------------------------------------------

void TMovieView::SetFrame(const CViewRect& newFrame, bool invalidate)
{
	if (newFrame != GetFrame())
	{
		InvalidateMovieClip();

		Inherited::SetFrame(newFrame, invalidate);

		if (invalidate)
			ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::Focus
//----------------------------------------------------------------------------------------

bool TMovieView::Focus()
{
	bool didFocus = Inherited::Focus();

	// Keep the movie up to date with our coordinate sys… only if absolutely necessary
	// Wait until we're visible before setting the movie clip. Otherwise we set the clip
	// to nothing and the movie draws a blank. 
	if (didFocus && IsShown() && !fMovieClipIsValid)
	{
		CTempRegion_AC visRgn;
		GetVisibleRegion(visRgn);

		// If we're completely visible, set the clip wide open
		if (fFullScreen || visRgn.Contains(GetQDExtent()))
			visRgn.reset();

		if (fMovieController)
			fMovieController.SetClip(visRgn, NULL);
//		else if (fMovie)
//			fMovie.SetDisplayClipRgn(visRgn);

		fMovieClipIsValid = true;
	}

	return didFocus;
}

//----------------------------------------------------------------------------------------
// TMovieView::InvalidateMovieClip
//----------------------------------------------------------------------------------------

void TMovieView::InvalidateMovieClip()
{
	fMovieClipIsValid = false;
}

//----------------------------------------------------------------------------------------
// TMovieView::EnsureMovieClipIsValid
//----------------------------------------------------------------------------------------

void TMovieView::EnsureMovieClipIsValid()
{
	if (!fMovieClipIsValid)
		Focus();
}

//----------------------------------------------------------------------------------------
// TMovieView::Show
//----------------------------------------------------------------------------------------

void TMovieView::Show(bool state, bool redraw)
{
	Inherited::Show(state, redraw);

	if (fMovieController)
		fMovieController.SetVisible(state);

	InvalidateMovieClip();
}

//----------------------------------------------------------------------------------------
// TMovieView::ShowController
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMovieView::BeInPort
//----------------------------------------------------------------------------------------

void TMovieView::BeInPort(GrafPtr itsPort) // override
{
	Inherited::BeInPort(itsPort);

	// Don't set the movie GWorld to NULL. It crashes if we're deleting the window
	// before it was ever shown. 
	if (itsPort)
	{
		if (fMovieController)
			fMovieController.SetControllerPort((CGrafPtr)itsPort);
		else if (fMovie)
			fMovie.SetGWorld((CGrafPtr)itsPort, NULL);
	}

	InvalidateMovieClip();
}

//----------------------------------------------------------------------------------------
// TMovieView::Draw
//----------------------------------------------------------------------------------------

void TMovieView::Draw(const CViewRect& /*area*/)
{
	EnsureMovieClipIsValid();

	if (fMovieController)
	{
		// QuickTime wants apps to call MCIsPlayerEvent on update events so it can perform
		// its processing outside of BeginUpdate/EndUpdate. However, this is a little hard
		// to do with MacApp, so we'll use MCInvalidate which was built for this purpose.

		WindowPtr w = GetGrafWindowPort();
		RgnHandle areaRgn = GetClipRegion();
#if qDebug
		static bool gDebugPinkUpdatedAreas = false;
		if (gDebugPinkUpdatedAreas)
		{
			// Show the area that is going to be updated so we see when the movie draws. 
			RGBForeColor(CRGBColor_AC(65535, 32767, 65535));
			PenSize(4,4);
			FrameRgn(areaRgn);
			PenNormal();
			RGBForeColor(CRGBColor_AC(0, 0, 0));
		}
#endif
		fMovieController.Invalidate(w, areaRgn);
		fMovieController.Draw(w);
	}
	else if (fMovie)
	{
		fMovie.Update();
		fMovie.Task(0);
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::Activate
//----------------------------------------------------------------------------------------

void TMovieView::Activate(bool entering)
{
	Inherited::Activate(entering);

	SetActive(entering);
}

//----------------------------------------------------------------------------------------
// TMovieView::SetActive
//----------------------------------------------------------------------------------------

void TMovieView::SetActive(bool state)
{
	Focus();

	if (fMovieController)
		fMovieController.Activate(GetWindowFromPort_AC(GetGrafPort()), state);

#if 0
	// Because Movie ToolBox invalidates the extent of the control but we do
	// direct drawing in the unclipped area.

	CTempRegion_AC visibleRgn;
	GetVisibleRegion(visibleRgn);

	Validate(visibleRgn);

	DrawContents();						// draw in activated or deactivated state
#endif
}

//----------------------------------------------------------------------------------------
// TMovieView::HasMovie
//----------------------------------------------------------------------------------------

bool TMovieView::HasMovie() const
{
	//not totally safe - could have a movie object with no fMovie...change
	return fMovie ? true : false;
}

//----------------------------------------------------------------------------------------
// TMovieView::DoEvent
//----------------------------------------------------------------------------------------

void TMovieView::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event)
{
	if (eventNumber == mBecameTarget)
		Activate(true);
	else if (eventNumber == mResignedTarget)
		Activate(false);

	Inherited::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TMovieView::DoMouseCommand
//----------------------------------------------------------------------------------------

void TMovieView::DoMouseCommand(CViewPoint& theMouse,
								TToolboxEvent* event,
								CPoint_AC hysteresis)
{
	bool handled = false;

	// if a movieController is attached pass off mouse clicks to it
	if (IsEnabled())
	{
		if (fMovieController)
		{
			handled = fMovieController.Click(GetWindowFromPort_AC(GetGrafPort()), ViewToQD(theMouse), event->GetWhen(), event->GetModifiers());
			if (handled)
				IdleMovies();
		}
		else
		{
			SetPlaying(event->GetClickCount() > 1);
			IdleMovies();
			handled = true;
		}
	}

	if (!handled)
		Inherited::DoMouseCommand(theMouse, event, hysteresis);
}

//----------------------------------------------------------------------------------------
// TMovieView::DoKeyEvent
//----------------------------------------------------------------------------------------

void TMovieView::DoKeyEvent(TToolboxEvent* event) // override
{
	bool handled = false;

	if (fFullScreen)
	{
#if qDebug
		SysBeep(1);
#endif
		SetPlaying(true);
	}
	else if (fMovieController && IsEnabled() && Focus())
	{
		handled = fMovieController.Key(event->GetText()[1], event->GetModifiers());
		if (event->IsDoubleEvent())
			handled = fMovieController.Key(event->GetText()[2], event->GetModifiers(1));

		if (handled)
			IdleMovies();
	}

	if (!handled)
		Inherited::DoKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TMovieView::DoCommandKeyEvent
//----------------------------------------------------------------------------------------

void TMovieView::DoCommandKeyEvent(TToolboxEvent* event) // override
{
	bool handled = false;

	if (event->GetText()[1] == '.')
	{
		SetPlaying(false);
		EndPresent();
		handled = true;
	}

	if (!handled && fMovieController && IsEnabled() && Focus())
	{
		handled = fMovieController.Key(event->GetText()[1], event->GetModifiers());
		if (event->IsDoubleEvent())
			handled = fMovieController.Key(event->GetText()[2], event->GetModifiers(1));

		if (handled)
			IdleMovies();
	}

	if (!handled)
		Inherited::DoCommandKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TMovieView::SetIdleIfMoviePlaying
//----------------------------------------------------------------------------------------

bool TMovieView::SetIdleIfMoviePlaying()
{
	enum { kMagicIdleNumber = 1 };

	bool playing = IsPlaying();

	playing = true;

	if (playing)
	{
		if (!fIdler)
		{
			fIdler = TH_new TIdler(this);
			fIdler->Install();
		}
		fIdler->SetIdleFreq(0); // kMagicIdleNumber
	}
	else
	{
		if (fIdler)
			fIdler->SetIdleFreq(1);	// kMaxIdleTime
	}

	return playing;
}

//----------------------------------------------------------------------------------------
// TMovieView::IsDone
//----------------------------------------------------------------------------------------

bool TMovieView::IsDone() const
{
	bool done = false;

	if (fMovie && fWasPlaying)
	{
		done = fMovie.IsDone();
		if (!done)
		{
			if (fMovie.GetRate() == 0)
			{
				if (GetPlaySelection())
				{
					TimeValue selectionTime = 0;
					TimeValue selectionDuration = 0;
					fMovie.GetSelection(&selectionTime, &selectionDuration);
					
					TimeValue currentTime = fMovie.GetTime();
					if (selectionTime + selectionDuration == currentTime)
						done = true;
				}
			}
		}
	}

	return done;
}

//----------------------------------------------------------------------------------------
// TMovieView::IsPlaying
//----------------------------------------------------------------------------------------

bool TMovieView::IsPlaying() const
{
	bool playing = false;

	if (fMovie)
		playing = fMovie.GetRate() && !IsDone();

	return playing;
}

//----------------------------------------------------------------------------------------
// TMovieView::SetPlaying
//----------------------------------------------------------------------------------------

void TMovieView::SetPlaying(bool play)
{
	if (play != IsPlaying())
	{
		if (play)
		{
			Fixed rate = fMovie.GetPreferredRate();
			if (!rate)
				rate = fixed1;

			TimeValue time = IsDone() ? 0 : fMovie.GetTime();

			fMovieController.SetTimeValue(time);
			fMovieController.Idle();

			fMovieController.DoActionPrerollAndPlay(rate);
			
			fWasPlaying = true;
		}
		else
		{
			EndPresent();
			fMovie.Stop();
		}

		SetIdleIfMoviePlaying();
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::GetPlaySelection
//----------------------------------------------------------------------------------------

bool TMovieView::GetPlaySelection() const
{
	if (!fMovieController)
		ThrowError_AC(minErr);

	return fMovieController.DoActionGetPlaySelection();
}

//----------------------------------------------------------------------------------------
// TMovieView::SetPlaySelection
//----------------------------------------------------------------------------------------

void TMovieView::SetPlaySelection(bool playSelection)
{
	if (!fMovieController)
		ThrowError_AC(minErr);

	fMovieController.DoActionSetPlaySelection(playSelection);
}

//----------------------------------------------------------------------------------------
// TMovieView::DoIdle
//----------------------------------------------------------------------------------------

bool TMovieView::DoIdle(IdlePhase phase)
{
	if (phase == idleContinue)
		IdleMovies();

	return false;
}

//----------------------------------------------------------------------------------------
// TMovieView::IdleMovies
//----------------------------------------------------------------------------------------

bool TMovieView::IdleMovies()
{
	EnsureMovieClipIsValid();

	if (Focus())
	{
		if (fMovieController)
			fMovieController.Idle();
		else if (fMovie)
			fMovie.Task(0);
	}

	if (IsDone())
	{
		TMovieDocument* movieDocument = reinterpret_cast<TMovieDocument*>(fDocument);
		if (movieDocument)
		{
			if (movieDocument->GetQuitWhenDone())
				HandleMenuCommand(cQuit);
			else if (movieDocument->GetCloseWhenDone())
				HandleMenuCommand(cClose);
		}

		if (fLoop)
			GoToBeginningOfMovie(fMovie);
	}

	return SetIdleIfMoviePlaying();
}

//----------------------------------------------------------------------------------------
// TMovieView::UpdateCoordinates
//----------------------------------------------------------------------------------------

void TMovieView::UpdateCoordinates() const
{
	Inherited::UpdateCoordinates();

	const_cast<TMovieView*>(this)->InvalidateMovieClip();
}

//----------------------------------------------------------------------------------------
// TMovieView::CalcMinFrame
//----------------------------------------------------------------------------------------
#pragma segment ARes

CViewRect TMovieView::CalcMinFrame() // override
{
	CViewRect newFrame( Inherited::CalcMinFrame() );

	if (fMovie)
	{
		if (fMovieController && fMovieController.GetVisible())
		{
			CRect_AC bounds(fMovieController.GetControllerBoundsRect());
			if (!bounds.IsEmpty())
				newFrame[botRight] = newFrame[topLeft] + bounds.GetSize();
		}
		else
		{
			CRect_AC box(fMovie.GetBox());
			if (!box.IsEmpty())
				newFrame[botRight] = newFrame[topLeft] + box.GetSize();
		}
	}
	
	return newFrame;
}


//----------------------------------------------------------------------------------------
// TMovieView::DoSetupMenus
//----------------------------------------------------------------------------------------

void TMovieView::DoSetupMenus() // override
{
	Inherited::DoSetupMenus();

	if (HasMovie())
	{
		Enable(cPresent, !fFullScreen);

		if (fMovieController)
		{
			fMovieController.SetUpEditMenu(0L, GetMenuHandle(mEdit));

			// MCSetUpEditMenu doesn't handle Select All, so we'll do it ourselves....
			Enable(cSelectAll, fMovieController.GetInfoEditingEnabled());
		}

		EnableCheck(cLoop, true, fLoop);

		EnableCheck(cHalfSize, true, fMovieSize == enumHalfSize);
		EnableCheck(cNormalSize, true, fMovieSize == enumNormalSize);
		EnableCheck(cDoubleSize, true, fMovieSize == enumDoubleSize);
		EnableCheck(cFitToScreen, true, fMovieSize == enumFitToScreen);
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::DoMenuCommand
//----------------------------------------------------------------------------------------

void TMovieView::DoMenuCommand(CommandNumber aCommandNumber) // override
{
	Inherited::DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// TMovieView::DoUndo
//----------------------------------------------------------------------------------------

void TMovieView::DoUndo()
{
	fMovieController.Undo();
}

//----------------------------------------------------------------------------------------
// TMovieView::DoCut
//----------------------------------------------------------------------------------------

void TMovieView::DoCut()
{
	if (fMovieController)
	{
		CTempMovie_AC myMovie = fMovieController.Cut();
		if (myMovie)
			myMovie.PutOnScrap(0L);
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::DoCopy
//----------------------------------------------------------------------------------------

void TMovieView::DoCopy()
{
	if (fMovieController)
	{
		CTempMovie_AC myMovie = fMovieController.Copy();
		if (myMovie)
			myMovie.PutOnScrap(0L);
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::DoPaste
//----------------------------------------------------------------------------------------

void TMovieView::DoPaste()
{
	if (fMovieController)
		fMovieController.Paste(NULL);
}

//----------------------------------------------------------------------------------------
// TMovieView::DoClear
//----------------------------------------------------------------------------------------

void TMovieView::DoClear()
{
	if (fMovieController)
		fMovieController.Clear();
}

//----------------------------------------------------------------------------------------
// TMovieView::SelectAll: 
//----------------------------------------------------------------------------------------
#pragma segment ANonRes

void TMovieView::SelectAll()
{
	if (fMovieController)
		fMovieController.SelectAll();
}

//----------------------------------------------------------------------------------------
// TMovieView::SelectAll: 
//----------------------------------------------------------------------------------------
#pragma segment ANonRes

void TMovieView::SetSelection(TimeValue selectionTime, TimeValue selectionDuration)
{
	if (fMovieController)
	{
		if (selectionDuration < 0)
			selectionDuration = fMovie.GetDuration() - selectionTime;

		fMovieController.SetSelection(selectionTime, selectionDuration);
	}

	SetTimeValue(selectionTime);
}

//----------------------------------------------------------------------------------------
// TMovieView::SetTimeValue: 
//----------------------------------------------------------------------------------------
#pragma segment ANonRes

void TMovieView::SetTimeValue(TimeValue newtime)
{
	if (fMovieController)
	{
		bool wasPlaying = IsPlaying();
		if (wasPlaying)
			fMovie.Stop();

		fMovieController.SetTimeValue(newtime);
		IdleMovies();

		if (wasPlaying)
			fMovie.Start();
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::SetActionFilter: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TMovieView::SetActionFilter()
{
	if (fMovieController)
	{
		if (!fgActionFilter)
		{
			fgActionFilter = ActionFilterGlue;
			ThrowIfNULL_AC(fgActionFilter);
		}
		fMovieController.SetActionFilterWithRefCon(fgActionFilter, reinterpret_cast<long>(this));
	}
}

//----------------------------------------------------------------------------------------
// TMovieView::ActionFilterGlue: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

pascal Boolean TMovieView::ActionFilterGlue(MovieController mc, short action, void *params, long refCon)
{
	Boolean handled = false;
	try
	{
		TMovieView* owner = reinterpret_cast<TMovieView*>(refCon);
		if (owner->fMovieController.get() == mc)
			handled = owner->ActionFilter(action, params);
	}
	catch (...)
	{
		// don't propagate exceptions -- we're in a callback
	}
	return handled;
}

//----------------------------------------------------------------------------------------
// TMovieView::ActionFilterGlue: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

Boolean TMovieView::ActionFilter(short action, void */*params*/)
{
	Boolean handled = false;

	switch (action)
	{
		// handle window resizing
		case mcActionControllerSizeChanged: // no param
			if (fFullScreen)
				fFullScreen->FitToScreen();
			else
				AdjustFrame();
			break;

		default:
			break;
	}

	return handled;
}

//----------------------------------------------------------------------------------------
// TMovieView::BeginPresent: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TMovieView::BeginPresent()
{
	fFullScreen = TH_new TFullScreenCommand(cPresent, this, fMovie, fMovieController);
	PostCommand(fFullScreen);
}

//----------------------------------------------------------------------------------------
// TMovieView::EndPresent: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TMovieView::EndPresent()
{
	if (fFullScreen)
	{
		fFullScreen->Reset();
		fFullScreen = NULL;
	}
}


//----------------------------------------------------------------------------------------
// End of UMovieView.cpp
