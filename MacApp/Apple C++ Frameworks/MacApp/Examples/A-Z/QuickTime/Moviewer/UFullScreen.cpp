//----------------------------------------------------------------------------------------
// UFullScreen.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		03/14/00	Deal with non-orthogonal monitor scaling. 
		12/08/99	Added DoCatchMessage_AC in DoIt and PollToolboxEvent.
		11/12/99	Update to Carbon, Universal headers 3.3, and new AEDesc_AC
							methods.
		06/06/99	Moved into MacApp examples. 
							Moved QTClassLib into ACS. 
		12/21/98	Open movie clip before going into present mode. 
							Move event polling from movie view to full screen command. 
		12/18/98	Defeat focus port is incorrect debug message. 
		12/12/98	Restructure so the movie can stop full screen mode while
							being called by the full screen code. 
		12/10/98	Streaming movie support. 
*/

#ifndef __UFullScreen__
#include "UFullScreen.h"
#endif

// Moviewer

#ifndef __UMovieView__
#include "UMovieView.h"
#endif

// MacApp

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CFixedPoint_AC__
#include "CFixedPoint_AC.h"
#endif

#if qDebug
	#ifndef __dout_AC__
	#include "dout_AC.h"
	#endif
#endif

#ifndef __WindowUtils_AC__
#include "WindowUtils_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif


//========================================================================================
// CLASS TFullScreenCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TFullScreenCommand constructor
//----------------------------------------------------------------------------------------

TFullScreenCommand::TFullScreenCommand(CommandNumber itsCommandNumber,
									   TMovieView* movieView,
									   Movie movie,
									   MovieController controller) :
	TCommand(itsCommandNumber, movieView, kCantUndo, kDoesNotCauseChange, NULL),
	fMovieView(movieView),
	fMovie(movie),
	fMovieController(controller),
	fSavePort(NULL),
	fSaveMovieGW(NULL),
	fSaveMovieGD(NULL),
	fSaveMovieMatrix(),
	fOldMovieBox(),
	fSaveActiveSegmentBegin(0),
	fSaveActiveSegmentDur(0),
	fSaveHasMovieChanged(false),
	fFullState(NULL),
	fPresentDevice(NULL),
	fPresentWindow(NULL),
	fDone(false)
{
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand destructor
//----------------------------------------------------------------------------------------
#pragma segment ARes

TFullScreenCommand::~TFullScreenCommand()
{
	if (fMovieView)
	{
		fMovieView->EndPresent();
		fMovieView = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::DoIt:
//----------------------------------------------------------------------------------------


void TFullScreenCommand::DoIt()
{
	fDone = false;

	try
	{
		// Make the movie view think its clip is valid
		fMovieView->InvalidateMovieClip();
//		SetPort(fMovieView->GetGrafPort());	// defeat "Focus port is incorrect" message
		fMovieView->Focus();

		// Open the movie clip
		{
			CTempRegion_AC visRgn;
			visRgn.reset();
			if (fMovieController)
				fMovieController.SetClip(visRgn, NULL);
		}

		SaveMovieState();
		Begin();

		fMovieView->SetPlaying(true);

		while (!fDone && !fMovieView->IsDone())
		{
			Focus();

			fMovieController.Idle();
			fMovieController.Idle();
			fMovieController.Idle();

			PollToolboxEvent();
		}
	}
	catch (CException_AC& ex)
	{
		DoCatchMessage_AC(ex);
		End();
		throw;
	}

	End();
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::SaveMovieState
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TFullScreenCommand::SaveMovieState()
{
	GetPort(&fSavePort);
	fMovie.GetGWorld(&fSaveMovieGW, &fSaveMovieGD);
	fSaveMovieMatrix = fMovie.GetMatrix();
	fOldMovieBox = fMovie.GetBox();
	fMovie.GetActiveSegment(&fSaveActiveSegmentBegin, &fSaveActiveSegmentDur);
	fSaveHasMovieChanged = fMovie.HasChanged();

//	fMovieController.RemoveAMovie(fMovie);
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::RestoreMovieState
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TFullScreenCommand::RestoreMovieState()
{
	SetMovieBox(fMovie, &fOldMovieBox);
	SetMovieMatrix(fMovie, &fSaveMovieMatrix);
	{
		CRect_AC box = fMovie.GetBox();
		fMovieController.SetMovie(fMovie, (WindowPtr)fSaveMovieGW, box[topLeft]);
	}
	fMovie.SetGWorld(fSaveMovieGW, fSaveMovieGD);
	fMovie.SetActiveSegment(fSaveActiveSegmentBegin, fSaveActiveSegmentDur);
	if (!fSaveHasMovieChanged)
		fMovie.ClearChanged();

	SetPort(fSavePort);
	
//	fMovieController.SetMovie(fMovie, fSavePort, gZeroPt);
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::Begin: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TFullScreenCommand::Begin()
{
	// Hide the cursor before the full screen setup
	HideCursor();

	ThrowIfOSErr_AC(GetBestDeviceRect(&fPresentDevice, NULL));
	fOldDeviceSize = CRect_AC((*fPresentDevice)->gdRect).GetSize();

	CPoint_AC desired = CRect_AC(fMovie.GetNaturalBoundsRect()).GetSize();
	ThrowIfOSErr_AC(BeginFullScreen(&fFullState, fPresentDevice, &desired.h, &desired.v, &fPresentWindow, NULL, 0));

	// Let the monitor resync before jumping into the movie
	DelayFuture_AC(1);

	SetGWorld((CGrafPtr)fPresentWindow, NULL);

	RGBBackColor(&gRGBBlack);
	fMovie.SetGWorld((CGrafPtr)fPresentWindow, NULL);
	RGBBackColor(&gRGBWhite);

	FitToScreen();
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::Focus: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TFullScreenCommand::Focus()
{
//	SetGWorld( (CGrafPtr) fPresentWindow, NULL );
	SetPortWindowPort(fPresentWindow);

#if qDebug
	CGrafPtr port = NULL;
	GDHandle gdh = NULL;
	fMovie.GetGWorld(&port, &gdh);
	if (port != (CGrafPtr) fPresentWindow)
	{
		dout << "Movie port has changed" << endl_AC;
	}
#endif
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::FitToScreen: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TFullScreenCommand::FitToScreen()
{
	// Get the natural size of the movie
	CPoint_AC boxSize(CRect_AC(fMovie.GetNaturalBoundsRect()).GetSize());

	// Get the size of the present window
	CPoint_AC screenSize = CRect_AC(GetPortBounds_AC(fPresentWindow)).GetSize();

	// Compute the ratio of the screen size to the movie size both horizontally
	// and vertically. 
	CFixedPoint_AC scale = CFixedPoint_AC(screenSize) / CFixedPoint_AC(boxSize);

	// Adjust the scale for unequal changes in monitor resolution
	CFixedPoint_AC deviceScale(fixed1, fixed1);
	CPoint_AC newDeviceSize(CRect_AC((*fPresentDevice)->gdRect).GetSize());
	if (newDeviceSize != fOldDeviceSize)
	{
		// If the resolution changed in only one direction, 
		// the screen is probably warped now. 
		if ((newDeviceSize.h == fOldDeviceSize.h) || (newDeviceSize.v == fOldDeviceSize.v))
		{
			deviceScale = CFixedPoint_AC(newDeviceSize) / CFixedPoint_AC(fOldDeviceSize);
			scale /= deviceScale;
		}
	}

	// Choose the smaller of the two scales and use it for both
	// directions. 
	if (scale.x > scale.y)
		scale.x = scale.y;
	else
		scale.y = scale.x;

	// Scale back to the current monitor resolution
	scale *= deviceScale;

	// Scale the movie size to the screen
	boxSize = (scale * boxSize).AsPoint();

	// Center the movie on the screen
	CPoint_AC margin = screenSize - boxSize;
	margin.h >>= 1;
	margin.v >>= 1;
	CRect_AC box(margin, margin + boxSize);

	// This is it
	fMovie.SetBox(&box);
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::End: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TFullScreenCommand::End()
{
	fDone = true;
	fMovie.SetRate(0);

	if (fFullState)
	{
		EndFullScreen(fFullState, 0);
		fFullState = NULL;
		fPresentWindow = NULL;
	}
	else if (fPresentWindow)
	{
		DisposeWindow(fPresentWindow);
		fPresentWindow = NULL;
	}

	RestoreMovieState();

	ShowCursor();
	
	FlushEvents(mouseDown | keyDown, 0);

	fMovieView->InvalidateMovieClip();
	TMenuBarManager::InvalidateMenuBar();

	fMovieView->EndPresent();
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::Reset: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TFullScreenCommand::Reset()
{
	fDone = true;
}

//----------------------------------------------------------------------------------------
// TFullScreenCommand::PollToolboxEvent: 
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TFullScreenCommand::PollToolboxEvent()
{
	short eventLevel = gDispatcher->GetEventLevel();

	try
	{
		// This is brutal but we are in front, and it makes the events keep going to us
		fMovieView->BecomeTarget();

		// Optimize away computing the sleep region and idling
		//gDispatcher->PollEvent(!kAllowApplicationToSleep);
		gDispatcher->SetEventLevel(eventLevel + 1);
#if 0
		TToolboxEvent* event = gDispatcher->GetEvent(gDispatcher->GetMainEventMask(), 0, NULL);
		if (event)
			gDispatcher->ProcessEvent(event);
#else
		{
			TToolboxEvent event(fMovieView, NULL, TToolboxEvent::kDontFree);
			bool gotAnEvent = gDispatcher->GetEvent(gDispatcher->GetMainEventMask(), 0, NULL, event);
			if (gotAnEvent)
				gDispatcher->HandleToolboxEvent(&event);
		}
#endif
		gDispatcher->SetEventLevel(eventLevel);
	}
	catch (CException_AC& ex)
	{
		DoCatchMessage_AC(ex);
		gDispatcher->SetEventLevel(eventLevel);
		throw;
	}
}



//----------------------------------------------------------------------------------------
// End of UFullScreen.cpp
