//----------------------------------------------------------------------------------------
// UServiceWindow.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		03/01/01	Don't include Windows_AC. 
		01/02/01	Update copyright.
		12/22/00	Don't need to override ReadFields anymore because TWindow
							has a CreateToolboxWindow method we can override. 
		12/21/00	Globally scope call to ParseTitleTemplate.
		09/03/00	Eliminated qNeedsSystem7_5.
		06/23/00	Removed GetRegionCode call.
		06/06/99	Moved into MacApp examples. 
		09/30/98	Use typedefs for Inherited. 
		09/21/98	Noload build. 
		09/21/98	Improve test for service window support so we don't crash in
							68K builds on pre-Allegro systems. 
		09/21/98	Floating window needs to identify itself as a palette so the
							rest of MacApp isn't confused. 
		09/16/98	Service window iterator. 
		09/13/98	Try using service windows. 
*/

#ifndef __UServiceWindow__
#include "UServiceWindow.h"
#endif

// MacApp

#ifndef __FLOATWINDOW__
#include "FloatWindow.h"
#endif

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

// ACS

// Toolbox

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __MACWINDOWS__
#include <MacWindows.h>
#endif

#ifndef __TEXTSERVICES__
#include <TextServices.h>
#endif


//========================================================================================
// GLOBAL Functions
//========================================================================================

bool HasTSMTE();
bool HasAllegroWindowMgr();

//----------------------------------------------------------------------------------------
// InitUServiceWindow
//----------------------------------------------------------------------------------------

void InitUServiceWindow()
{
}

//----------------------------------------------------------------------------------------
// GetTSMgrVersion: 
//----------------------------------------------------------------------------------------

long GetTSMgrVersion()
{
	static bool defined;
	static long version;
	if (!defined)
	{
		defined = true;
		OSErr err = ::Gestalt(gestaltTSMgrVersion, &version);
	}
	return version;
}

//----------------------------------------------------------------------------------------
// HasTSM: 
//----------------------------------------------------------------------------------------

bool HasTSM()
{
	static bool defined;
	static bool hasTSM;
	if (!defined)
	{
		defined = true;
		hasTSM = (GetTSMgrVersion() >= 1);
	}
	return hasTSM;
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::InitializeTSM
//----------------------------------------------------------------------------------------

bool HasTSMTE()
{
	static bool defined;
	static bool hasTSMTE;
	if (!defined)
	{
		defined = true;
		hasTSMTE = HasTSM() && GestaltAttribute_AC(gestaltTSMTEAttr, gestaltTSMTEPresent);
	}
	return hasTSMTE;
}

//----------------------------------------------------------------------------------------
// HasFloatingWindowService: 
//----------------------------------------------------------------------------------------

bool HasFloatingWindowService()
{
	static bool defined;
	static bool hasFloatingWindowService;
	if (!defined)
	{
		defined = true;
		hasFloatingWindowService = (GetTSMgrVersion() >= gestaltTSMgr15);
		if (hasFloatingWindowService)
		{
#if qPowerPC || qModelCFM
			// verify presence of shared library
#if qCarbon
			// In Carbon, the Services window is just a regular floating window
			hasFloatingWindowService = true;
#else
			hasFloatingWindowService = ((void*)NewCServiceWindow != (void*) kUnresolvedCFragSymbolAddress);
#endif
#endif
		}
	}
	return hasFloatingWindowService;
}

//----------------------------------------------------------------------------------------
// HasAllegroWindowMgr
//----------------------------------------------------------------------------------------
#pragma	segment	AOpen

bool HasAllegroWindowMgr()
{
	static bool defined;
	static bool hasAllegroWindowMgr;
	if (!defined)
	{
		defined = true;
		long response;
		OSErr err = Gestalt(gestaltWindowMgrAttr, &response);
		hasAllegroWindowMgr = (err == noErr) && ((response & gestaltWindowMgrPresent) != 0);
	}
	return hasAllegroWindowMgr;
}


//========================================================================================
// CLASS TServiceWindow
//========================================================================================

DEFINE_REGISTERED_AC(TServiceWindow);
MA_DEFINE_CLONE(TServiceWindow);

//----------------------------------------------------------------------------------------
// TServiceWindow static globals
//----------------------------------------------------------------------------------------

long TServiceWindow::fServiceWindowCount;

//----------------------------------------------------------------------------------------
// TServiceWindow Constructor
//----------------------------------------------------------------------------------------

TServiceWindow::TServiceWindow(WindowRef itsWMgrWindow,
							   bool canResize,
							   bool canClose,
							   bool inDispose) :
	TWindow(itsWMgrWindow, canResize, canClose, inDispose),
	fUseFloatingWindowService(false)
{
	++fServiceWindowCount;
	if (gApplication->GetIdleFreq() > 1)
		gApplication->SetIdleFreq(1);
}

//----------------------------------------------------------------------------------------
// TServiceWindow destructor
//----------------------------------------------------------------------------------------

TServiceWindow::~TServiceWindow()
{
	if (--fServiceWindowCount <= 0)
	{
		//gApplication->SetIdleFreq(kMaxIdleTime);
	}
}

//----------------------------------------------------------------------------------------
// TServiceWindow::CreateToolboxWindow:
//----------------------------------------------------------------------------------------

void TServiceWindow::CreateToolboxWindow()
{
	fOMClassID = fFloats ? cPalette : cWindow;

	if (fFloats)
		fUseFloatingWindowService = true;

	if (fUseFloatingWindowService)
	{
		if (!HasFloatingWindowService())
			fUseFloatingWindowService = false;
	}

	if (!fUseFloatingWindowService)
	{
		TWindow::CreateToolboxWindow();
	}
	else
	{
		// retrieve the window's title from the resource
		CStr255_AC title(fStrListID, fIndex);

		CRect_AC theBounds = GetFrame().ToRect();

#if qCarbon
		// In Carbon, the CreateNewWindow function should be called for both TSM and non-TSM.
		WindowClass windowClass = kFloatingWindowClass;
		WindowAttributes attributes = kWindowStandardFloatingAttributes;

#if qCarbonEvents
		if (gDispatcher->UseCarbonEvents())
			attributes |= kWindowStandardHandlerAttribute;
#endif

		fWMgrWindow.Create(windowClass, attributes, theBounds);
		::ThrowIfNULL_AC(fWMgrWindow);

		SetTitle(title);
#else
		short procID = fProcID;					// default
		if ((fProcID & 0xFFF0) == kSystem75AndLess_kWindoidWDEF)
			procID = kSystem75_kWindoidWDEF | (fProcID & 0x000F);

		WindowRef behind = IsModal() ? reinterpret_cast<WindowRef>(-1) : GetBehindWindowPtr();

		CWindowRecord* storage = NULL;
		if (!fDisposeOnFree)
			storage = TH_new CWindowRecord;

		WindowRef aWMgrWindow = NULL;
		ThrowIfOSErr_AC(NewCServiceWindow(storage, theBounds, title, false,
										  procID, behind, fIsClosable,
										  (ComponentInstance) kCurrentProcess, &aWMgrWindow));
	if (!aWMgrWindow)
	{
		delete storage;
		::ThrowIfNULL_AC(aWMgrWindow);
	}
		
		reinterpret_cast<WindowPeek>(aWMgrWindow)->refCon = reinterpret_cast<long>(this);
		fWMgrWindow = aWMgrWindow;
#endif
		if (!WMgrToWindow(fWMgrWindow))
			RegisterWindow(this);					// add to the lookup table
	}
}

//----------------------------------------------------------------------------------------
// TServiceWindow::GetPartCode:
//----------------------------------------------------------------------------------------

short TServiceWindow::GetPartCode(const CViewPoint& theMouse) const // override
{
	short returnVal = inDesk;

	// Call FindWindow to determine the partcode
	WindowRef aWMgrWindow;
	CPoint_AC superPoint(LocalToSuperView(theMouse).ToPoint());
	short partCode = FindWindow(superPoint, &aWMgrWindow);

	if (!partCode && !aWMgrWindow && HasFloatingWindowService())
#if !qCarbon
		partCode = FindServiceWindow(superPoint, &aWMgrWindow);
#else
		if (FindWindowOfClass(superPoint, kFloatingWindowClass, &aWMgrWindow, &partCode) != noErr)
			aWMgrWindow = 0;	// force to be invalid
#endif

	if (aWMgrWindow == fWMgrWindow)				// if we fail this sanity check, then
		returnVal = partCode;						// passed the sanity check so return the
													// part code we got back from FindWindow
#if qDebug
	else
		::ProgramBreak_AC("in TWindow.GetPartCode: passed a CViewPoint that didn't belong to the window");
#endif

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TServiceWindow::CloseWMgrWindow:
//----------------------------------------------------------------------------------------

void TServiceWindow::CloseWMgrWindow(WindowPtr window)
{
#if qCarbon
	// In Carbon, we created the window normally, so we need to just dispose of it--
	// floating windows are just another type of windows
	DisposeWindow(window);
#else
	if (fUseFloatingWindowService)
		ThrowIfOSErr_AC(CloseServiceWindow(window));
	else
		CloseWindow(window);
#endif
}

//----------------------------------------------------------------------------------------
// TServiceWindow::MAFrontServiceWindow:
//----------------------------------------------------------------------------------------

WindowRef TServiceWindow::MAFrontServiceWindow()
{
	WindowRef aWMgrWindow = NULL;
	if (HasFloatingWindowService())
#if qCarbon
		aWMgrWindow = GetFrontWindowOfClass(kFloatingWindowClass, true /* must be visible */);
#else
		ThrowIfOSErr_AC(GetFrontServiceWindow(&aWMgrWindow));
#endif
	return aWMgrWindow;
}

//----------------------------------------------------------------------------------------
// TServiceWindow::HandleMouseDown:
//----------------------------------------------------------------------------------------

bool TServiceWindow::HandleMouseDown(const CViewPoint& theMouse,
									 TToolboxEvent* event,
									 CPoint_AC hysteresis,
									 EMouseDownType	/* mouseDownType */) // override
{
	bool wasHandled = false;

	// Find out where the mouse was pressed
	short aPartCode = GetPartCode(theMouse);

	// Test to determine if the window should be selected. To be selected,
	//  ¥ this window must not be the active window; and
	//  ¥ this window must not float, or if it does, it must not be front-most.
	EMouseDownType mouseDownType = kDragOrClick;
	if ((gDispatcher->GetActiveWindow(kNoFloaters) != this) &&
		(!fFloats ||
		 ((fWMgrWindow != FrontWindow()) && (fWMgrWindow != MAFrontServiceWindow()))))
	{
		mouseDownType = fDoFirstClick ? kFirstClick_dragOrClick : kFirstClick_dragOnly;

		if (aPartCode != inContent && (aPartCode != inDrag || !event->IsCommandKeyPressed()))
		{
			Select();
			gDispatcher->UpdateAllWindows();
		}
	}

	// dispatch according to where the mouse was pressed
	switch (aPartCode)
	{
		case inContent:
			wasHandled = TView::HandleMouseDown(theMouse, event, hysteresis, mouseDownType);
			break;

		case inDrag:
#if qAllegro
			if (!HandlePathSelect(event))
				MoveByUser(theMouse);
#else
			MoveByUser(theMouse);
#endif
			wasHandled = true;
			break;

		case inGrow:

			if(GetIsResizable())
			{
				ResizeByUser(theMouse);
				wasHandled = true;
			}
			else
				wasHandled = TView::HandleMouseDown(theMouse, event, hysteresis, mouseDownType);

			break;

		case inGoAway:
			GoAwayByUser(theMouse);
			wasHandled = true;
			break;

		case inZoomIn:
		case inZoomOut:
			ZoomByUser(theMouse, aPartCode);
			wasHandled = true;
			break;

		case inDesk:
			wasHandled = true;
			break;

#if qAllegro
		case inProxyIcon:
			TrackProxyDrag(theMouse);
			wasHandled = true;
			break;
#endif

		default:
			break;
	}

	return wasHandled;
}

#if qAppleEventAware
//----------------------------------------------------------------------------------------
// TServiceWindow::GetObjectProperty:
//----------------------------------------------------------------------------------------

bool TServiceWindow::GetObjectProperty(CAEDesc& thePropertyValue,
									   DescType whichProperty,
									   const CAEDesc& desiredType) // override
{
	bool hasProperty = true;

	switch (whichProperty)
	{
		case pIndex:
			{
				hasProperty = false;
				long index = GetIndex();
				if (index > 0)
				{
					thePropertyValue.PutLong(index);
					hasProperty = true;
					break;
				}
				break;
			}

		default:
			hasProperty = false;
			break;
	}

	if (!hasProperty)
		hasProperty = Inherited::GetObjectProperty(thePropertyValue, whichProperty, desiredType);

	return hasProperty;
}

//----------------------------------------------------------------------------------------
// TServiceWindow::GetIndex:
//----------------------------------------------------------------------------------------

long TServiceWindow::GetIndex() const
{
	long index = 0;

	long count = 0;
	if (fFloats)
	{
		for (CServiceWindowIterator iter; iter; ++iter)
		{
			TWindow* aWindow = WMgrToWindow(iter);
			if (aWindow && aWindow->IsShown())
			{
				++count;
				if (aWindow == this)
				{
					index = count;
					break;
				}
			}
		}
	}

	for (CWMgrIterator iter; iter; ++iter)
	{
		TWindow* aWindow = WMgrToWindow(iter);
		// count its index either as a floater or non-floater
		if (aWindow && aWindow->IsShown() && (aWindow->GetFloats() == fFloats))
		{
			++count;
			if (aWindow == this)
			{
				index = count;
				break;
			}
		}
	}

	return index;
}

#endif // qAppleEventAware


//========================================================================================
// CLASS CServiceWindowIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CServiceWindowIterator::CServiceWindowIterator: 
//----------------------------------------------------------------------------------------

CServiceWindowIterator::CServiceWindowIterator(bool itsForward) :
	fIterateForward(itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CServiceWindowIterator::First: 
//----------------------------------------------------------------------------------------

WindowRef CServiceWindowIterator::First()
{
	return fCurrent = fIterateForward ? FirstWindow() : LastWindow();
}

//----------------------------------------------------------------------------------------
// CServiceWindowIterator::Next: 
//----------------------------------------------------------------------------------------

WindowRef CServiceWindowIterator::Next()
{
	if (fCurrent)
		fCurrent = fIterateForward ? NextWindow(fCurrent) : PreviousWindow(fCurrent);

	return Current();
}

//----------------------------------------------------------------------------------------
// CServiceWindowIterator::FirstWindow: 
//----------------------------------------------------------------------------------------

WindowRef CServiceWindowIterator::FirstWindow()
{
	WindowRef currentWindow = TServiceWindow::MAFrontServiceWindow();
	if (currentWindow && (currentWindow == gWorkPort))
		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CServiceWindowIterator::NextWindow: 
//----------------------------------------------------------------------------------------

WindowRef CServiceWindowIterator::NextWindow(WindowRef aWindow)
{
	WindowRef currentWindow = GetNextWindow_AC(aWindow);

	while (currentWindow && (currentWindow == gWorkPort))
		// ignore the work window
		currentWindow = GetNextWindow_AC(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CServiceWindowIterator::PreviousWindow: 
//----------------------------------------------------------------------------------------

WindowRef CServiceWindowIterator::PreviousWindow(WindowRef aWindow)
{
	WindowRef currentWindow = FirstWindow();
	while (currentWindow && (NextWindow(currentWindow) != aWindow))
		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CServiceWindowIterator::LastWindow: 
//----------------------------------------------------------------------------------------

WindowRef CServiceWindowIterator::LastWindow()
{
	WindowRef currentWindow = FirstWindow();
	while (currentWindow && NextWindow(currentWindow))
		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}


//----------------------------------------------------------------------------------------
// End of UServiceWindow.cpp

#pragma segment Inline
