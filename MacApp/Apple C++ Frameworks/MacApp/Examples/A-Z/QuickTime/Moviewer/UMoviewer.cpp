//----------------------------------------------------------------------------------------
// UMoviewer.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		07/18/01	Qualify strlen with std::.
		05/12/01	Need access to TMovieView to register it. 
		01/19/01	Use CString_AC and include CString_AC.h.
		01/02/01	Update copyright.
		10/13/00	Removing USimpleWindowDef. 
		06/23/00	Custom window definition behavior. 
		03/14/00	Add support for auto play and auto present. 
		02/21/00	Time code units. 
		02/03/00	Don't dispose of handles in CAEDesc_AC on Carbon. 
		02/02/00	Call AddDocument right after DoMakeDocument in Play.
		08/17/99	Change obsoleted macros to ACS versions. 
		07/15/99	Get URL. 
		06/06/99	Moved into MacApp examples. 
							Moved QTClassLib into ACS. 
							Tweak to build with MacApp R14. 
		12/10/98	Streaming movie support. 
							Open any file that can be converted into a movie. 
		12/09/98	Present movie mode. 
		12/04/98	Clean up for final. 
		09/30/98	Select all readable files in nav open dialog. 
							Use typedefs for Inherited. 
							Add floating window style. 
		09/21/98	Noload build. 
		09/16/98	Make setting the window style at the application level recordable. 
							Make movie scrap commands recordable. 
		09/13/98	Try using service windows. 
		07/12/98	Play command should start playing by default. 
		06/25/98	Short cut access to first movie. 
		06/24/98	QuickTime registration. 
		06/22/98	TMovieFile. 
		06/07/98	Script menu. 
		05/16/98	Initial version. 
*/

#ifndef __UMoviewer__
#include "UMoviewer.h"
#endif

// Moviewer

#ifndef __Moviewer_r__
#include "Moviewer.r.h"
#endif

#ifndef __UAEUtils__
#include "UAEUtils.h"
#endif

#ifndef __UMovieDocument__
#include "UMovieDocument.h"
#endif

#ifndef __UMovieFile__
#include "UMovieFile.h"
#endif

#ifndef __UMovieView__
#include "UMovieView.h"
#endif

#ifndef __UPropertyCommand__
#include "UPropertyCommand.h"
#endif

#ifndef __USCRIPTMENU__
#include "UScriptMenu.h"
#endif

#ifndef __UShrinkWindow__
#include "UShrinkWindow.h"
#endif

// DemoWDEF

//#ifndef __USimpleWindowDef__
//#include "USimpleWindowDef.h"
//#endif

// MacApp

#ifndef __UAPPLEEVENTS__
#include "UAppleEvents.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

// ACS

#ifndef __CMovie_AC__
#include "CMovie_AC.h"
#endif

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

// Toolbox

#ifndef __TEXTSERVICES__
#include <TextServices.h>
#endif


//========================================================================================
// CLASS TMoviewerApplication
//========================================================================================

MA_DEFINE_CLONE(TMoviewerApplication);

//----------------------------------------------------------------------------------------
// TMoviewerApplication constructor
//----------------------------------------------------------------------------------------

TMoviewerApplication::TMoviewerApplication() :
	Inherited(kFileType, kSignature),
	fStyle(cNormalWindow)
{
	fLaunchWithNewDocument = false;
	
	// So the view server can create views by name
	
	REGISTER_CLASS_AC(TMovieView);
	REGISTER_CLASS_AC(TShrinkToFitWindow);

	InitUAEUtils();

	InitUMovieDocument();
//	TSimpleWindowDef::Register();
	
#if qAttachable
	if (fOSAScript)
		fOSAScript->fNextScriptIdle = 0;
#endif
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication destructor
//----------------------------------------------------------------------------------------

TMoviewerApplication::~TMoviewerApplication()
{
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::DoInitialState 
//----------------------------------------------------------------------------------------

void TMoviewerApplication::DoInitialState() // override
{
	Inherited::DoInitialState();

	AddBehavior(TH_new TScriptMenuBehavior);
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::GetNavSvcsFileParameters
//----------------------------------------------------------------------------------------

void TMoviewerApplication::GetNavSvcsFileParameters(CommandNumber itsCommandNumber,
													CAEDesc_AC*& defaultLocation,
													NavReplyRecord& customReply,
													NavDialogOptions& dialogOptions,
													NavEventProcPtr& eventFilter,
													NavPreviewProcPtr& previewProc,
													NavCallBackUserData& callBackUD,
													NavTypeListHandle& navTypeList,
													NavObjectFilterProcPtr& objectFilter) // override
{
	Inherited::GetNavSvcsFileParameters(itsCommandNumber, defaultLocation, customReply,
										dialogOptions, eventFilter, previewProc,
										callBackUD, navTypeList, objectFilter);

	dialogOptions.dialogOptionFlags |= kNavSelectDefaultLocation;
	if ((itsCommandNumber == cOpen) || (itsCommandNumber == cPlay))
		dialogOptions.dialogOptionFlags |= kNavAllFilesInPopup | kNavSelectAllReadableItem;
	
	objectFilter = NavObjectFilterProc;
	callBackUD = this;
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::TMoviewerApplication::NavObjectFilterProc
//----------------------------------------------------------------------------------------

pascal Boolean TMoviewerApplication::NavObjectFilterProc(AEDesc* theItem,
														 void* info,
														 NavCallBackUserData callBackUD,
														 NavFilterModes filterMode)
{
	Boolean display = true;

	try
	{
		if (callBackUD)
			display = static_cast<TMoviewerApplication*>(callBackUD)->NavObjectFilter(theItem, info, filterMode);
	}
	catch (...)
	{
		// don't propagate exceptions -- we're in a callback
	}

	return display;
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::TMoviewerApplication::NavObjectFilter
//----------------------------------------------------------------------------------------

bool TMoviewerApplication::NavObjectFilter(AEDesc* theItem,
										   void* info,
										   NavFilterModes filterMode)
{
	bool display = true;

	if (filterMode == kNavFilteringBrowserList)
	{
		NavFileOrFolderInfo* theInfo = static_cast<NavFileOrFolderInfo*>(info);
		if (!theInfo->isFolder)
		{
			if (theItem->descriptorType == typeFSS)
			{
				TFile aFile(theInfo->fileAndFolder.fileInfo.finderInfo.fdType, theInfo->fileAndFolder.fileInfo.finderInfo.fdCreator);
				aFile.Specify(CAEDesc_AC(*theItem).GetFSSpec());
				display = CanOpenDocument(cOpen, &aFile);
			}
		}
	}

	return display;
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::CanOpenDocument: 
//----------------------------------------------------------------------------------------

// This is called only when opening/printing from the finder and from standard file;
// it simulates the filtering done by Std File.

bool TMoviewerApplication::CanOpenDocument(CommandNumber itsCommandNumber, TFile* aFile) // override
{
	bool canOpen = Inherited::CanOpenDocument(itsCommandNumber, aFile);

	if (!canOpen)
	{
		AliasHandle alias = NULL;
		ThrowIfOSErr_AC(aFile->GetAlias(alias));
		CTempHandle_AC aliasH(reinterpret_cast<Handle>(alias));

		Component importer = NULL;
		GetMovieImporterForDataRef(rAliasType, aliasH, kGetMovieImporterDontConsiderGraphicsImporters, &importer);

		if (importer != NULL)		// this file is a movie file
			canOpen = true;
	}

	return canOpen;
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::DoMakeFile:
//----------------------------------------------------------------------------------------
			
TFile* TMoviewerApplication::DoMakeFile(CommandNumber /*itsCommandNumber*/) // override
{
	return new TMovieFile(fMainFileType, fCreator, TMovieFile::kKeepMovieOpen);
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::DoMakeDocument:
//----------------------------------------------------------------------------------------
			
TDocument* TMoviewerApplication::DoMakeDocument(CommandNumber /*itsCommandNumber*/, TFile* itsFile) // override
{
	return TH_new TMovieDocument(itsFile, kSignature);
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::DoSetupMenus
//----------------------------------------------------------------------------------------

void TMoviewerApplication::DoSetupMenus() // override
{
	Inherited::DoSetupMenus();

	EnableCheck(cNormalWindow, true, fStyle == cNormalWindow);
	EnableCheck(cPlainWindow, true, fStyle == cPlainWindow);
	EnableCheck(cMiniWindow, true, fStyle == cMiniWindow);
	EnableCheck(cFloatingWindow, true, fStyle == cFloatingWindow);
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::DoMenuCommand
//----------------------------------------------------------------------------------------

void TMoviewerApplication::DoMenuCommand(CommandNumber aCommandNumber) // override
{
	switch (aCommandNumber)
	{
		case cNormalWindow:
		case cPlainWindow:
		case cMiniWindow:
		case cFloatingWindow:
			{
				DescType windowStyle = WindowStyleEnum(aCommandNumber);
				PostCommand(TH_new TPropertyCommand(pWindowStyle, this, TempEnumDesc(windowStyle)));
			}
			break;

		default:
			Inherited::DoMenuCommand(aCommandNumber);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::DoPlay: 
//----------------------------------------------------------------------------------------

void TMoviewerApplication::DoPlay(CommandNumber theCmdNumber)
{
	CList_AC* aFileList = NULL;

	if (ChooseDocument(theCmdNumber, &aFileList))
	{
		TPlayCommand* aPlayCommand = TH_new TPlayCommand(theCmdNumber, aFileList);
		aPlayCommand->SetUseAppleEvent(true);
		PostCommand(aPlayCommand);
	}
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::Play: 
//----------------------------------------------------------------------------------------

TDocument* TMoviewerApplication::Play(CommandNumber itsOpenCommand,
									  CList_AC* aFileList,
									  TAppleEvent* message,
									  TAppleEvent* reply)
{
	TDocument* aDocument = NULL;

	CTempDesc_AC result;
	result.CreateList();

	for (TemplateIterator_AC<TFile*> iter(aFileList); iter; ++iter)
	{
		TFile* aFile = iter;
		aFileList->Delete(aFile);
		aDocument = Play(itsOpenCommand, aFile, message);
		if (aDocument && reply)
		{
			CTempDesc_AC specifier;
			aDocument->MakeObjectSpecifier(specifier, formName);
			result.PutListItem(0, specifier);
		}
	}

	// Return the document's object specifier
	if (reply && reply->dataHandle)
		reply->WriteParameter(keyAEResult, result);

	return aDocument;
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::Play: 
//----------------------------------------------------------------------------------------

TDocument* TMoviewerApplication::Play(CommandNumber itsOpenCommand,
									  CAutoPtr_AC<TFile> aFile,
									  TAppleEvent* message)
{
	CAutoPtr_AC<TDocument> aDocument;

	Size oldCodeReserve;
	Size oldMemReserve;

	CString_AC fileName(aFile->GetName());	// If failure occurs the file may already be
											// freed so we will save the name just in
											// case.

	try
	{
		// Set reserve down a little to ensure that we can open existing documents 
		GetReserveSize(oldCodeReserve, oldMemReserve);
		SetReserveSize(oldCodeReserve, oldMemReserve / 2);

		CommandNumber kindOfDocCmd = KindOfDocument(itsOpenCommand, aFile);

		TDocument* otherDoc = FindDocument(aFile);
		bool isStationery = aFile->IsStationery();

		if (otherDoc && !isStationery)
		{
			otherDoc->OpenAgain(kindOfDocCmd, aDocument);
			aFile.reset();
			SetReserveSize(oldCodeReserve, oldMemReserve);
		}
		else if (CanOpenDocument(kindOfDocCmd, aFile))
		{
			aDocument = DoMakeDocument(kindOfDocCmd, aFile.release());
			ThrowIfNULL_AC(aDocument);
			AddDocument(aDocument);

			if (!isStationery)
				aDocument->ReadDocument(kForDisplay);
			else
			{
				CAutoPtr_AC<TFile> aNewFile = DoMakeFile(kindOfDocCmd);
				aDocument->ReadStationery(aNewFile.release());
			}

			// The play command starts playing by default
			{
				CTempDesc_AC value;
				value.PutBoolean(true);
				aDocument->SetObjectProperty(value, pPlaying);
			}

			if (message)
			{
				// Apply the properties if any.
				aDocument->SetPropertiesFromEvent(message);
			}

			aDocument->DoMakeViews(kForDisplay);

			if (isStationery)
				aDocument->SetTitle(aDocument->UntitledName());

			FailSpaceIsLow();			// Fail if the document leaves us with no
										// memory
										// Set the reserve back to where it was 
			SetReserveSize(oldCodeReserve, oldMemReserve);

			// Don't attempt to show the windows until we're sure we won't fail 
			aDocument->DoPostMakeViews(kForDisplay);
		}
		else
		{
			// If we ended up without a document because we didn't understand this type
			// of file then let's get rid of the file.
			aFile.reset();
			ThrowException_AC(errNotMyType, 0);
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		if (!theException.GetExceptionMessage())
			gErrorParm3 = fileName;

		// Set the reserve back to where it was 
		SetReserveSize(oldCodeReserve, oldMemReserve);

		ThrowNewMessage_AC(theException.GetError(), theException.GetExceptionMessage(), messageOpenFailed);
	}

	return aDocument.release();
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::OpenURL: 
//----------------------------------------------------------------------------------------

TDocument* TMoviewerApplication::OpenURL(CommandNumber itsOpenCommand, const Handle url)
{
	CAutoPtr_AC<TMovieDocument> aDocument = NULL;

	try
	{
		aDocument = TH_new TMovieDocument(NULL, kSignature);
		ThrowIfNULL_AC(aDocument);

		aDocument->SetIdentifier(itsOpenCommand);

		AddDocument(aDocument);

		aDocument->OpenURL(url, kForDisplay);

		aDocument->DoMakeViews(kForDisplay);

		FailSpaceIsLow();			// Fail if the document leaves us with no
									// memory

		// Don't attempt to show the windows until we're sure we won't fail 
		aDocument->DoPostMakeViews(kForDisplay);
	}
	catch (CException_AC& theException)
	{
		if (!theException.GetExceptionMessage())
			gErrorParm3 = CString_AC(GetURLLeafName(url));

		throw;
	}

	return aDocument.release();
}

//----------------------------------------------------------------------------------------
// Scripting
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMoviewerApplication::DoScriptCommand: 
//----------------------------------------------------------------------------------------

void TMoviewerApplication::DoScriptCommand(CommandNumber aCommandNumber,
										   TAppleEvent* message,
										   TAppleEvent* reply) // override
{
	switch (aCommandNumber)
	{
		case cAECut:
		case cAECopy:
		case cAEPaste:
		//case cAEUndo:
		//case cAERedo:
			// Don't allow TDispatcher to pass these off to HandleMenuCommand. 
			// We want the document's DoMenuCommand to be recordable. 
			// Proper factoring is for UI code to call AE code, not the other
			// way around. 
			break;

		case cPlay:
			{
				TPlayCommand* playCommand = TH_new TPlayCommand(aCommandNumber, *message, *reply);
				playCommand->Process();
			}
			break;

		case cSelect:
		case cSelectAll:
		case cPresent:
			{
				TDocument* document = GetDocumentByIndex(cDocument, 1);
				if (document)
					document->DoScriptCommand(aCommandNumber, message, reply);
			}
			break;

		case cGetURL:
			{
				TGetURLCommand* getURLCommand = TH_new TGetURLCommand(aCommandNumber, *message, *reply);
				getURLCommand->Process();
			}
			break;

		default:
			Inherited::DoScriptCommand(aCommandNumber, message, reply);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::GetObjectProperty:
//----------------------------------------------------------------------------------------

bool TMoviewerApplication::GetObjectProperty(CAEDesc_AC& thePropertyValue,
											 DescType whichProperty,
											 const CAEDesc_AC& desiredType) // override
{
	bool hasProperty = false;

	switch (whichProperty)
	{
		case pWindowStyle:
		case pLooping:
		case pDone:
		case pPlaying:
		case pMovieSize:
		case pVolume:
		case pCloseWhenDone:
		case pQuitWhenDone:
		case pController:
		case pPlaySelection:
		case keyAEPosition:
		case pDuration:
		case pTimeScale:
		case pTime:
		case pDimensions:
		case pNaturalDimensions:
		case pAutoPlay:
		case pAutoPresent:
			{
				TDocument* document = GetDocumentByIndex(cDocument, 1);
				if (document)
				{
					hasProperty = document->GetObjectProperty(thePropertyValue, whichProperty, desiredType);
				}
				else if (whichProperty == pWindowStyle)
				{
					DescType windowStyle = WindowStyleEnum(fStyle);
					thePropertyValue.PutEnum(windowStyle);
					hasProperty = true;
				}
			}
			break;

		default:
			break;
	}

	if (!hasProperty)
		hasProperty = Inherited::GetObjectProperty(thePropertyValue, whichProperty, desiredType);

	return hasProperty;
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::SetObjectProperty:
//----------------------------------------------------------------------------------------

void TMoviewerApplication::SetObjectProperty(const CAEDesc_AC& thePropertyValue,
											 DescType whichProperty) // override
{
	switch (whichProperty)
	{
		case pWindowStyle:
		case pLooping:
		case pDone:
		case pPlaying:
		case pMovieSize:
		case pVolume:
		case pCloseWhenDone:
		case pQuitWhenDone:
		case pController:
		case pPlaySelection:
		case keyAEPosition:
		case pDuration:
		case pTimeScale:
		case pTime:
		case pAutoPlay:
		case pAutoPresent:
			{
				TDocument* document = GetDocumentByIndex(cDocument, 1);
				if (document)
				{
					document->SetObjectProperty(thePropertyValue, whichProperty);
				}
				else if (whichProperty == pWindowStyle)
				{
					DescType windowStyle = thePropertyValue.GetEnum();
					fStyle = WindowStyleID(windowStyle);
				}
			}
			break;

		default:
			Inherited::SetObjectProperty(thePropertyValue, whichProperty);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TMoviewerApplication::GetSetPropertyInfo:
//----------------------------------------------------------------------------------------

void TMoviewerApplication::GetSetPropertyInfo(DescType whichProperty,
											  CommandNumber& cmdNum,
											  bool& canUndo,
											  bool& causesChange,
											  TCommandHandler* &theContext) // override
{
	switch (whichProperty)
	{
		case pWindowStyle:
		case pLooping:
		case pDone:
		case pPlaying:
		case pMovieSize:
		case pVolume:
		case pCloseWhenDone:
		case pQuitWhenDone:
		case pController:
		case pPlaySelection:
		case keyAEPosition:
		case pDuration:
		case pTimeScale:
		case pTime:
		case pAutoPlay:
		case pAutoPresent:
			{
				TDocument* document = GetDocumentByIndex(cDocument, 1);
				if (document)
				{
					document->GetSetPropertyInfo(whichProperty, cmdNum, canUndo, causesChange, theContext);
				}
				else if (whichProperty == pWindowStyle)
				{
					Inherited::GetSetPropertyInfo(whichProperty, cmdNum, canUndo, causesChange, theContext);
					// We're not saving or undoing anything
					canUndo = false;
					causesChange = false;
				}
			}
			break;

		default:
			Inherited::GetSetPropertyInfo(whichProperty, cmdNum, canUndo, causesChange, theContext);
			break;
	}
}


//========================================================================================
// CLASS TPlayCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TPlayCommand::MakeAppleEvent: 
//----------------------------------------------------------------------------------------

TAppleEvent* TPlayCommand::MakeAppleEvent()
{
	CAutoPtr_AC<TAppleEvent> theEvent(TH_new TAppleEvent('MVWR', kAEPlay, gServerAddress, kAEWaitReply));

	CTempDesc_AC theList;
	theList.CreateList();

	for (TemplateIterator_AC<TFile*> iter(fFileList); iter; ++iter)
	{
		AliasHandle theAlias = NULL;
		OSErr theErr = iter->GetAlias(theAlias);
		if (theErr == noErr)
		{
#if qCarbon
			CTempHLock_AC theAliasLock((Handle)theAlias);
			theList.PutListPtr(0, typeAlias, *(Handle)theAlias, GetHandleSize((Handle)theAlias));
#else
			CAEDesc_AC theAliasDesc(typeAlias, (Handle)theAlias);
			theList.PutListItem(0, theAliasDesc);
#endif
		}
	}

	theEvent->WriteParameter(keyDirectObject, theList);

	return theEvent.release();
}

//----------------------------------------------------------------------------------------
// TPlayCommand::DoIt: 
//----------------------------------------------------------------------------------------

void TPlayCommand::DoIt()
{
	reinterpret_cast<TMoviewerApplication*>(gApplication)->Play(fIdentifier, fFileList, 
																fMessage, fReply);
}


//========================================================================================
// CLASS TGetURLCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TGetURLCommand constructor
//----------------------------------------------------------------------------------------

TGetURLCommand::TGetURLCommand(CommandNumber itsCommandNumber,
							   const char* url) :
	TServerCommand(itsCommandNumber, gApplication, kCantUndo, kDoesNotCauseChange, NULL),
	fURL(NULL)
{
	fCausesChange = false;

	Size urlSize = std::strlen(url) + 1;
	fURL = NewPermHandle(urlSize);
	ThrowIfNULL_AC(fURL);
	BlockMove_AC(url, *fURL, urlSize);
}

//----------------------------------------------------------------------------------------
// TGetURLCommand constructor
//----------------------------------------------------------------------------------------

TGetURLCommand::TGetURLCommand(CommandNumber itsCommandNumber,
							   const TAppleEvent& itsMessage,
							   const TAppleEvent& itsReply) :
	TServerCommand(itsCommandNumber, gApplication, kCantUndo, kDoesNotCauseChange, NULL, itsMessage, itsReply),
	fURL(NULL)
{
	fCausesChange = false;

	// Check to see what is in the direct object list
	CAEDesc_AC directObj;
	::ThrowIfOSErr_AC(fMessage->ReadParameter(keyDirectObject, typeAEList, directObj));
	long theCount = directObj.CountListItems();
	if (theCount > 0)
	{
		// Get the first descriptor and coerce it to characters
		CTempDesc_AC urlDesc(directObj.GetNthItem(1, typeChar));
		fURL = urlDesc.GetDataAsHandle();
		Size urlSize = GetHandleSize(fURL) + 1;
		SetPermHandleSize(fURL, urlSize);
		ThrowIfMemError_AC();
		(*fURL)[urlSize - 1] = 0;
	}
}

//----------------------------------------------------------------------------------------
// TGetURLCommand destructor
//----------------------------------------------------------------------------------------

TGetURLCommand::~TGetURLCommand()
{
}

//----------------------------------------------------------------------------------------
// TGetURLCommand::MakeAppleEvent: 
//----------------------------------------------------------------------------------------

TAppleEvent* TGetURLCommand::MakeAppleEvent()
{
	CAutoPtr_AC<TAppleEvent> theEvent(TH_new TAppleEvent('GURL', 'GURL', gServerAddress, kAEWaitReply));

	CTempDesc_AC theList;
	theList.CreateList();

	// the URL is a c-string in a handle
	{
		CTempHLock_AC urlLock(fURL);
		long urlLength = std::strlen(*fURL);
		theList.PutListPtr(1, typeChar, *fURL, urlLength);
	}

	theEvent->WriteParameter(keyDirectObject, theList);

	return theEvent.release();
}

//----------------------------------------------------------------------------------------
// TGetURLCommand::DoIt: 
//----------------------------------------------------------------------------------------

void TGetURLCommand::DoIt()
{
	reinterpret_cast<TMoviewerApplication*>(gApplication)->OpenURL(fIdentifier, fURL.release());
}


//----------------------------------------------------------------------------------------
// End of UMoviewer.cpp
