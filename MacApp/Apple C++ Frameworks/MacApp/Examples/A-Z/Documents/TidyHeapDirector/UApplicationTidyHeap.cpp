//----------------------------------------------------------------------------------------
// UApplicationTidyHeap.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		07/13/00	Stripped out MA_DEFINE_CLASS of TApplicationTidyHeap.
		12/08/99	Took out MA_DEFINE_CLASS of TApplicationTidyHeap.
		11/09/99	Change MA_DEFINE_CLASS_M1 macro to MA_DEFINE_CLASS to update
					to new macro scheme.
		03/24/99	Update copyright notice.
*/


// MacApp Includes

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UApplicationTidyHeap__
#include "UApplicationTidyHeap.h"
#endif

#ifndef __UDocumentTidyHeap__
#include "UDocumentTidyHeap.h"
#endif

#ifndef __UDocumentTidyHeap5__
#include "UDocumentTidyHeap5.h"
#endif

// Toolbox

#ifndef __SOUND__
#include <Sound.h>
#endif

//----------------------------------------------------------------------------------------
// Constants:

static const short kAboutWindowID = 1000;

//========================================================================================
// CLASS TApplicationTidyHeap
//========================================================================================

#undef Inherited
#define Inherited TApplication

//----------------------------------------------------------------------------------------
// TApplicationTidyHeap constructor
//----------------------------------------------------------------------------------------

TApplicationTidyHeap::TApplicationTidyHeap()
	:	TApplication(kFileType, kSignature)
{
	fLaunchWithNewDocument = false;
}

//----------------------------------------------------------------------------------------
// TApplicationTidyHeap destructor
//----------------------------------------------------------------------------------------

TApplicationTidyHeap::~TApplicationTidyHeap()
{
}

//----------------------------------------------------------------------------------------
// TApplicationTidyHeap::DoMakeDocument
//----------------------------------------------------------------------------------------

TDocument* TApplicationTidyHeap::DoMakeDocument(CommandNumber /* itsCommandNumber */,
														TFile* itsFile) // Override 
{
	TDocument* outPtr = NULL;

	OSErr err = itsFile->OpenDataFork();
	
	if(!err)
	{
		short version;
		
		long count = sizeof(short);
		
		if(!err)
			err = itsFile->ReadData(&version, count);
		
		if(!err)
		{
			switch(version)
			{
				case 5:
					outPtr = new TDocumentTidyHeap5(itsFile);
					break;
					
				default:
					outPtr = new TDocumentTidyHeap(itsFile);
					break;
			}
		}
		
		itsFile->CloseDataFork();
	}
	

	return outPtr;
} // TApplicationTidyHeap::DoMakeDocument 

//----------------------------------------------------------------------------------------
// TApplicationTidyHeap::DoMenuCommand
//----------------------------------------------------------------------------------------

void TApplicationTidyHeap::DoMenuCommand(CommandNumber aCommandNumber) // Override 
{
	switch (aCommandNumber) 
	{
		default:
			Inherited::DoMenuCommand(aCommandNumber);
			break;
	}
} // TApplicationTidyHeap::DoMenuCommand 

//----------------------------------------------------------------------------------------
// TApplicationTidyHeap::DoSetupMenus
//----------------------------------------------------------------------------------------

void TApplicationTidyHeap::DoSetupMenus() // Override 
{
	Inherited::DoSetupMenus();				// Always call the inherited method first

	Enable(cNew,FALSE);
	Enable(cSaveAs, FALSE);
	
} // TApplicationTidyHeap::DoSetupMenus 

//----------------------------------------------------------------------------------------
// TApplicationTidyHeap::DoAboutBox
//----------------------------------------------------------------------------------------

void TApplicationTidyHeap::DoAboutBox()
{
	TWindow* window = TViewServer::fgViewServer->NewTemplateWindow(kAboutWindowID, NULL);
	::ThrowIfNULL_AC(window);
	::SysBeep(30);
	window->PoseModally();
	window->Close();
}

//----------------------------------------------------------------------------------------
// TApplicationTidyHeap::DoMakeFile: 
//----------------------------------------------------------------------------------------
TFile* TApplicationTidyHeap::DoMakeFile(CommandNumber)
{
	return NewFile(kFileType, kSignature, true, noResourceFork, false, false);
}