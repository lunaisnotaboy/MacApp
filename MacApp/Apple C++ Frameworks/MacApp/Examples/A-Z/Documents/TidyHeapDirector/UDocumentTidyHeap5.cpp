//----------------------------------------------------------------------------------------
// UDocumentTidyHeap5.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/19/01	DoNeedDiskSpace is now const.  Cosmetic.
		01/02/01	Update copyright.
		12/08/99	To help MrCpp: added explicit operator () calls and explicit
					(bool&) cast in several places.  Changed 'i' index to 'j'
					in SetToDefault for SCPP.
		03/24/99	Update copyright notice.
*/

#ifndef __UDocumentTidyHeap__
#include "UDocumentTidyHeap5.h"
#endif

// MacApp

#ifndef __UCHECKBOX__
#include "UCheckBox.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UNUMBERTEXT__
#include "UNumberText.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __CFileStream_AC__
#include "CFileStream_AC.h"
#endif

enum eCommand
{
	cSetToDefault = 400
};

//----------------------------------------------------------------------------------------
// operator <<
//----------------------------------------------------------------------------------------

inline CStream_AC& operator << (CStream_AC& inStream, const TPrefsFormat5& inFormat)
{
	inStream << inFormat.fVersion;

	for(short i = 0; i < TPrefsFormat5::kNumProperties; i++)
		inStream << inFormat.fPrefs[i]();

	inStream.WriteBytes(inFormat.fSessionName, TPrefsFormat5::kStringLen);

	inStream 	<< inFormat.fFailCount
				<< inFormat.SettingsModifiedExternally()
				<< inFormat.fLastWriteSeconds;

	return inStream;
}

//----------------------------------------------------------------------------------------
// operator >>
//----------------------------------------------------------------------------------------

inline CStream_AC& operator >> (CStream_AC& inStream, TPrefsFormat5& inFormat)
{
	inStream >> inFormat.fVersion;

	for(short i = 0; i < TPrefsFormat5::kNumProperties; i++)
		inStream >> (bool&)inFormat.fPrefs[i];

	inStream.ReadBytes(inFormat.fSessionName, TPrefsFormat5::kStringLen);

	inStream 	>> inFormat.fFailCount
				>> (bool&)inFormat.SettingsModifiedExternally
				>> inFormat.fLastWriteSeconds;

	return inStream;
}

//----------------------------------------------------------------------------------------
// Constants:

const ResNumber kTidyHeapWindowID = kDefaultWindowID + 1;

//========================================================================================
// CLASS TDocumentTidyHeap5
//========================================================================================

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5 constructor
//----------------------------------------------------------------------------------------

TDocumentTidyHeap5::TDocumentTidyHeap5(TFile* inFile)
	: TFileBasedDocument(inFile),
	fFailCountText(NULL)
{
	Erase_AC(fBoxes, kNumCheckBoxes);

	fSavePrintInfo = false;

} // TDocumentTidyHeap5::TDocumentTidyHeap5

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5 destructor
//----------------------------------------------------------------------------------------

TDocumentTidyHeap5::~TDocumentTidyHeap5()
{
}

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5::DoNeedDiskSpace
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::DoNeedDiskSpace(TFile* itsFile,
								 long& dataForkBytes,
								 long& rsrcForkBytes) const
{
	#pragma unused (itsFile)
	dataForkBytes = TPrefsFormat5::GetStreamedSize();
	rsrcForkBytes = 0;
}

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5::DoRead
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::DoRead(TFile* aFile, bool forPrinting)
{
	#pragma unused (forPrinting)
	CFileStream_AC fileStream(aFile);
	fileStream 	>> fSettings;
}

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5::DoWrite
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::DoWrite(TFile* aFile, bool makingCopy)
{
	#pragma unused (makingCopy)
// sync checkboxes up with data

	for(short i = 0; i < kNumCheckBoxes; i++)
		fSettings.fPrefs[ConvertBoxIndexToPrefIndex(i)] = fBoxes[i]->IsOn();

	fSettings.fFailCount = fFailCountText->GetValue();

	fSettings.SettingsModifiedExternally(true);
	GetDateTime(&fSettings.fLastWriteSeconds);
	// stream data to the file

	CFileStream_AC fileStream(aFile);

	fileStream << fSettings;

}

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5::DoMakeViews:
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::DoMakeViews(bool /*forPrinting*/)
{
	TWindow* aWindow = gViewServer->NewTemplateWindow(kTidyHeapWindowID, this);
	::ThrowIfNULL_AC(aWindow);

	CStr255_AC theText = fSettings.fSessionName;

	aWindow->SetTitle(theText);

	for(short i = 0; i < kNumCheckBoxes; i++)
	{
		fBoxes[i] = dynamic_cast_AC(TCheckBox*, aWindow->FindSubView(i));
		::ThrowIfNULL_AC(fBoxes[i]);
	}

	fFailCountText = (TNumberText*) aWindow->FindSubView('NUM1');
	::ThrowIfNULL_AC(fFailCountText);

	SyncViewsWithData(false);

	aWindow->Open();
} // TDocumentTidyHeap5::DoMakeViews

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5::DoMenuCommand
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::DoMenuCommand(CommandNumber aCommandNumber)
{
	switch (aCommandNumber)
	{
		case cSetToDefault:
			SetToDefault();
			break;
		default:
			TFileBasedDocument::DoMenuCommand(aCommandNumber);
			break;
	}
} // TDocumentTidyHeap5::DoMenuCommand

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5::DoSetupMenus
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::DoSetupMenus()
{
	TFileBasedDocument::DoSetupMenus();

	Enable(cSetToDefault,TRUE);
	Enable(cSaveAs, FALSE);
} // TDocumentTidyHeap5::DoSetupMenus

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5::DoEvent
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event)
{
	if(	eventNumber == mCheckBoxHit/* || eventNumber == 27*/ )
	{
		fChangeCount++;
	}

	TFileBasedDocument::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TDocumentTidyHeap5::SyncViewsWithData
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::SyncViewsWithData(bool drawNow)
{
	for(short i = 0; i < kNumCheckBoxes; i++)
	{
		fBoxes[i]->SetState( fSettings.fPrefs[ConvertBoxIndexToPrefIndex(i)](), drawNow);
	}

	fFailCountText->SetValue( fSettings.fFailCount, drawNow );
}

//----------------------------------------------------------------------------------------
//  TDocumentTidyHeap5::SetToDefault
//----------------------------------------------------------------------------------------

void TDocumentTidyHeap5::SetToDefault()
{
	fChangeCount++;
		// dirty the document

	fSettings.fFailCount = 0;

	for(short i = 0; i <= kPrintExtraInfo; i++)
		fSettings.fPrefs[i] = true;

	for(short j = kInstallGarbageIn; j < TPrefsFormat5::kNumProperties; j++)
		fSettings.fPrefs[j] = false;

	fSettings.fPrefs[TPrefsFormat5::kInstallGarbageIn] = true;
	fSettings.fPrefs[TPrefsFormat5::kInstallNewVerifyAction] = true;
	fSettings.fPrefs[TPrefsFormat5::kInstallGarbageOut] = true;
	fSettings.fPrefs[TPrefsFormat5::kInstallDeleteVerifyAction] = true;

	fSettings.SettingsModifiedExternally(false);

	SyncViewsWithData(true);
		// update the checkboxes
}

