//----------------------------------------------------------------------------------------
// UOutlineView.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/19/01	GetName and SetName now take CString_AC.
		01/02/01	Update copyright.
		11/05/00	Allow using the toolbox triangle instead of just the emulated one. 
		08/17/99	Change obsoleted macros to ACS versions. 
		05/26/99	Work around a compile error by changing OutlineNode::GetName
					to return a CStr255_AC instead of an empty C string.
					InstallBackgroundColors may not be a method of CDisclosureTriangle.
		05/01/98	Update for Brian's new appearance.
*/


#ifndef __UOUTLINEVIEW__
#include "UOutlineView.h"
#endif

// Outline

#ifndef __Outline_r_h__
#include "Outline.r.h"
#endif

#ifndef __UMOREDEBUG__
#include "UMoreDebug.h"
#endif

#ifndef __UOUTLINE__
#include "UOutline.h"
#endif

#ifndef __UOUTLINEDOCUMENT__
#include "UOutlineDocument.h"
#endif

// MacApp

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

// ACS

#ifndef __CCustomControl_AC__
#include "CCustomControl_AC.h"
#endif

#if qEmulateStandardControls
	#ifndef __CDisclosureTriangle_AC__
	#include "CDisclosureTriangle_AC.h"
	#endif
#endif

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

// Toolbox

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __SOUND__
#include <Sound.h>
#endif

//----------------------------------------------------------------------------------------
// Constants:
//----------------------------------------------------------------------------------------

//========================================================================================
// Global Initialization Procedure
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// InitUOutlineView:
//----------------------------------------------------------------------------------------

void InitUOutlineView()
{
	// So the linker doesn't dead strip class info
	REGISTER_CLASS_AC(TOutlineView);
}


//========================================================================================
// struct OutlineNode
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// OutlineNode constructor
//----------------------------------------------------------------------------------------
#pragma segment ListRes

OutlineNode::OutlineNode(MOutlineContainer* item, long index, long indent) :
	fItem(item),
	fIndex(index),
	fIndent(indent),
	fExpandable(item->Expandable()),
	fExpanded(item->Expanded())
{
}

//----------------------------------------------------------------------------------------
// OutlineNode::Free
//----------------------------------------------------------------------------------------
#pragma segment ListRes

void OutlineNode::Free()
{
	if (fItem)
	{
		fItem->Free();
		fItem = nil;
	}
}

//----------------------------------------------------------------------------------------
// OutlineNode::Compare
//----------------------------------------------------------------------------------------
#pragma segment ListRes

CompareResult_AC OutlineNode::Compare(const OutlineNode& other) const
{
	CompareResult_AC returnVal;

	if (fIndex > other.fIndex)
		returnVal = kItem1GreaterThanItem2_AC;
	else if (fIndex < other.fIndex)
		returnVal = kItem1LessThanItem2_AC;
	else
		returnVal = kItem1EqualItem2_AC;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// Outline Structure
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// OutlineNode::GetOutlineContainer:
//----------------------------------------------------------------------------------------

MOutlineContainer* OutlineNode::GetOutlineContainer() const
{
	return fItem ? fItem->GetOutlineContainer() : nil;
}

//----------------------------------------------------------------------------------------
// OutlineNode::GetID:
//----------------------------------------------------------------------------------------

long OutlineNode::GetID() const
{
	return fItem ? fItem->GetID() : 0;
}

//----------------------------------------------------------------------------------------
// OutlineNode::GetName:
//----------------------------------------------------------------------------------------

CString_AC OutlineNode::GetName() const
{
	return fItem ? fItem->GetName() : CString_AC();
}

//----------------------------------------------------------------------------------------
// OutlineNode::SetName:
//----------------------------------------------------------------------------------------

void OutlineNode::SetName(const CString_AC& name)
{
	if (fItem)
		fItem->SetName(name);
}

//----------------------------------------------------------------------------------------
// OutlineNode::CountContainedItems:
//----------------------------------------------------------------------------------------

long OutlineNode::CountContainedItems() const
{
	return fItem ? fItem->CountContainedItems() : 0;
}

//----------------------------------------------------------------------------------------
// OutlineNode::GetIndItem:
//----------------------------------------------------------------------------------------

MOutlineContainer* OutlineNode::GetIndItem(long index) const
{
	return fItem ? fItem->GetIndItem(index) : nil;
}

//----------------------------------------------------------------------------------------
// OutlineNode::SetExpanded:
//----------------------------------------------------------------------------------------

void OutlineNode::SetExpanded(bool expanded)
{
	if (fItem)
		fItem->SetExpanded(expanded);

	fExpanded = expanded;
}

//----------------------------------------------------------------------------------------
// OutlineNode::UpdateExpanded:
//----------------------------------------------------------------------------------------

void OutlineNode::UpdateExpanded()
{
	fExpanded = fItem ? fItem->Expanded() : false;
}

//----------------------------------------------------------------------------------------
// OutlineNode::CompletelyExpanded:
//----------------------------------------------------------------------------------------

bool OutlineNode::CompletelyExpanded() const
{
	return fItem ? fItem->CompletelyExpanded() : false;
}

//----------------------------------------------------------------------------------------
// OutlineNode::SetCompletelyExpanded:
//----------------------------------------------------------------------------------------

void OutlineNode::SetCompletelyExpanded(bool expanded)
{
	if (fItem)
		fItem->SetCompletelyExpanded(expanded);

	fExpanded = expanded;
}


//========================================================================================
// CLASS TOutlineArray
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// TOutlineArray destructor
//----------------------------------------------------------------------------------------
#pragma segment MADestructorRes

TOutlineArray::~TOutlineArray()
{
	FreeAll();
}

//----------------------------------------------------------------------------------------
// TOutlineArray::Clone
//----------------------------------------------------------------------------------------
#pragma segment ListRes

MA_DEFINE_CLONE(TOutlineArray);

//----------------------------------------------------------------------------------------
// TOutlineArray::FreeAll
//----------------------------------------------------------------------------------------
#pragma segment ListRes

void TOutlineArray::FreeAll()
{
	for (long i = 1; i <= fSize; ++i)
	{
		OutlineNode node = At(i);
		node.Free();
	}
	DeleteAll();
}

//----------------------------------------------------------------------------------------
// TOutlineArray::Compare:
//----------------------------------------------------------------------------------------
#pragma segment ListRes

CompareResult_AC TOutlineArray::Compare(const OutlineNode& item1, const OutlineNode& item2) const
{
	return item1.Compare(item2);
}

//----------------------------------------------------------------------------------------
// TOutlineArray::InsertChildren:
//----------------------------------------------------------------------------------------
#pragma segment ListOpen

long TOutlineArray::InsertChildren(const MOutlineContainer* container, long indent)
{
	return InsertChildrenBefore(fSize + 1, container, indent);
}

//----------------------------------------------------------------------------------------
// TOutlineArray::InsertChildrenBefore:
//----------------------------------------------------------------------------------------
#pragma segment ListOpen

long TOutlineArray::InsertChildrenBefore(ArrayIndex_AC index, const MOutlineContainer* container, long indent)
{
	long total = 0;
	long count = container->CountContainedItems();
	for (long child = 1; child <= count; ++child)
	{
		MOutlineContainer* item = container->GetIndItem(child);
		OutlineNode node(item, child, indent);
		InsertBefore(index, node);
		++total;
		++index;
		if (node.Expanded())
		{
			long n = InsertChildrenBefore(index, item, indent + 1);
			total += n;
			index += n;
		}
	}
	return total;
}

//----------------------------------------------------------------------------------------
// TOutlineArray::CountChildrenDeep:
//----------------------------------------------------------------------------------------
#pragma segment ListOpen

long TOutlineArray::CountChildrenDeep(ArrayIndex_AC index) const
{
	long total = 0;
	OutlineNode node = At(index);
	if (node.Expanded())
	{
		long count = node.CountContainedItems();
		total += count;
		for (long child = 1; child <= count; ++child)
		{
			++index;	// move to the child
			long n = CountChildrenDeep(index);	// count its children
			total += n;
			index += n;
		}
	}
	return total;
}

//----------------------------------------------------------------------------------------
// TOutlineArray::DeleteChildren:
//----------------------------------------------------------------------------------------
#pragma segment ListOpen

long TOutlineArray::DeleteChildren(ArrayIndex_AC index)
{
	long count = CountChildrenDeep(index);

	if (count > 0)
	{
		for (long child = 1; child <= count; ++child)
			At(index + child).Free();

		DeleteElementsAt(index + 1, count);
	}

	return count;
}

//----------------------------------------------------------------------------------------
// TOutlineArray::FindByID:
//----------------------------------------------------------------------------------------
#pragma segment ListOpen

ArrayIndex_AC TOutlineArray::FindByID(long id) const
{
	ArrayIndex_AC index;

	for (CArrayIterator_AC iter(this); iter.Current(); ++iter)
	{
		if (At(iter.Current()).GetID() == id)
		{
			index = iter.Current();
			break;
		}
	}

	return index;
}


//========================================================================================
// CLASS TOutlineView
//========================================================================================
#undef Inherited
#define Inherited TTextGridView

MA_DEFINE_CLASS(TOutlineView);

//----------------------------------------------------------------------------------------
// TOutlineView constructor
//----------------------------------------------------------------------------------------

TOutlineView::TOutlineView() :
	fOutlineArray(0),
	fTriangleRow(0)
{
}

//----------------------------------------------------------------------------------------
// TOutlineView copy constructor
//----------------------------------------------------------------------------------------

TOutlineView::TOutlineView(const TOutlineView& in) :
	TTextGridView(in),
	fOutlineArray(0),
	fTriangleRow(0)
{
}

//----------------------------------------------------------------------------------------
// TOutlineView destructor
//----------------------------------------------------------------------------------------

TOutlineView::~TOutlineView()
{
}

//----------------------------------------------------------------------------------------
// TOutlineView::DoPostCreate:
//----------------------------------------------------------------------------------------

void TOutlineView::DoPostCreate(TDocument* itsDocument) // override
{
	Inherited::DoPostCreate(itsDocument);

	CreateTriangle();

	BuildOutline();

	TOutlineDocument* outlineDocument = dynamic_cast_AC(TOutlineDocument*, fDocument);
	if (outlineDocument)
		outlineDocument->AddSelectionDependency(this);
}

//----------------------------------------------------------------------------------------
// TOutlineView::CreateTriangle
//----------------------------------------------------------------------------------------

void TOutlineView::CreateTriangle()
{
	CViewRect aRect(0, 0, kTriangleWidth, fLineHeight + fRowInset);
	CRect_AC qdTriangleRect(ViewToQD(aRect));

	// Instantiate the particular CControl_AC subclass.
#if qEmulateStandardControls
	if (::EmulateControls_AC())
	{
		enum { kEnabled = true };
		fTriangle = TH_new CDisclosureTriangle_AC(qdTriangleRect, kEnabled, CDisclosureTriangle_AC::kAutomaticState);
	}
	else
#endif
	{
		WindowRef theWindow = GetWindow()->GetWindowRef();
		fTriangle = CreateDisclosureTriangle_AC(theWindow, qdTriangleRect);
	}

	// Disclosure triangle has to erase when animating, so make sure that
	// it doesn't assume we're on a gray background.
	Focus();

#if 0
	MControlBackground_AC* controlBackground = dynamic_cast<MControlBackground_AC*>(fTriangle);
	if (controlBackground)
		controlBackground->InstallBackgroundColors(MControlBackground_AC::kInstallOnlyIfCustom);
#endif
}

//----------------------------------------------------------------------------------------
// TOutlineView::TriangleRect:
//----------------------------------------------------------------------------------------

CViewRect TOutlineView::TriangleRect(GridCoordinate row)
{
	CViewRect aRect(CellToVRect(GridCell(1, row)));
	aRect.Inset(CViewPoint(fColInset / 2, fRowInset / 2));
	return TriangleRect(aRect);
}

//----------------------------------------------------------------------------------------
// TOutlineView::TriangleRect:
//----------------------------------------------------------------------------------------

CViewRect TOutlineView::TriangleRect(const CViewRect& aRect)
{
	return CViewRect(aRect.left, aRect.top, aRect.left + kTriangleWidth, aRect.bottom);
}

//----------------------------------------------------------------------------------------
// TOutlineView::LocateTriangle:
//----------------------------------------------------------------------------------------

void TOutlineView::LocateTriangle(GridCoordinate row)
{
#if qDebug
	AssumeFocused();
#endif
	ThrowIfNonObject_AC(fTriangle);

	bool expanded = Expanded(row);
	if ((fTriangleRow != row) || (fTriangle->GetValue() != expanded))
	{
		fTriangle->SetVisibility(false);
		CRect_AC bounds(ViewToQD(TriangleRect(row)));
		fTriangle->SetBounds(bounds);
		fTriangle->SetValue(expanded);
		fTriangle->SetVisibility(true);
		fTriangleRow = row;
	}
}

//----------------------------------------------------------------------------------------
// TOutlineView::InvalidateTriangle:
//----------------------------------------------------------------------------------------

void TOutlineView::InvalidateTriangle(GridCoordinate row)
{
	Invalidate(TriangleRect(row));
}

//----------------------------------------------------------------------------------------
// TOutlineView::DrawTriangle:
//----------------------------------------------------------------------------------------

void TOutlineView::DrawTriangle(GridCoordinate row)
{
	if (fTriangle)
	{
		LocateTriangle(row);
		fTriangle->DrawControl();
	}
}

//----------------------------------------------------------------------------------------
// TOutlineView::DrawCell:
//----------------------------------------------------------------------------------------

void TOutlineView::DrawCell(const GridCell& aCell, const CViewRect& aRect) // override
{
	OutlineNode node = At(aCell.v);
	if (node.Expandable())
		DrawTriangle(aCell.v);

	CViewRect cellRect(aRect);
	cellRect.left += kTriangleWidth + node.Indent() * kIndentWidth;

#if qDebug && 0
	{
		CRect_AC border(ViewToQD(cellRect));
		CTempForeColor_AC saveForeColor(CRGBColor_AC(0x3333, 0xFFFF, 0x3333));
		FrameRect(border);
	}
#endif

	Inherited::DrawCell(aCell, cellRect);
}

//----------------------------------------------------------------------------------------
// TOutlineView::DoSetupMenus:
//----------------------------------------------------------------------------------------

void TOutlineView::DoSetupMenus() // override
{
	Inherited::DoSetupMenus();

	Enable(cCommandHandledByView, true);
}

//----------------------------------------------------------------------------------------
// TOutlineView::DoMenuCommand:
//----------------------------------------------------------------------------------------

void TOutlineView::DoMenuCommand(CommandNumber aCommandNumber) // override
{
	switch (aCommandNumber)
	{
		case cCommandHandledByView :
			::SysBeep(2);
			break;

		default:
			Inherited::DoMenuCommand(aCommandNumber);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TOutlineView::DoMouseCommand:
//----------------------------------------------------------------------------------------

void TOutlineView::DoMouseCommand(CViewPoint& theMouse, TToolboxEvent* event, CPoint_AC hysteresis) // override
{
#pragma unused (event, hysteresis)

	bool handled = false;

	if ((theMouse.h > 0) && (theMouse.h < kTriangleWidth))
	{
		GridCoordinate row = fRowHeights.FindItem(theMouse.v);
		if (row)
		{
			if (Expandable(row))
			{
				CViewRect triangleRect = TriangleRect(row);
				if (triangleRect.Contains(theMouse))
				{
					handled = true;
					LocateTriangle(row);
					if (fTriangle->TrackMouse(ViewToQD(theMouse), event->GetModifiers()))
						SetExpanded(row, fTriangle->GetValue());
				}
			}
		}
	}

	if (!handled)
		Inherited::DoMouseCommand(theMouse, event, hysteresis);
}

//----------------------------------------------------------------------------------------
// TOutlineView::DoUpdate:
//----------------------------------------------------------------------------------------
#pragma segment MAApplicationRes

void TOutlineView::DoUpdate(ChangeID_AC theChange,
							MDependable_AC* changedObject,
							void* changeData,
							CDependencySpace_AC* dependencySpace) // override
{
	// If this is undo we know we're being changed by a command
	// and it has the real identifier
	ChangeID_AC id = (theChange == cUndo) ? static_cast_AC(TCommand*, changeData)->GetIdentifier() : theChange;

	switch (id)
	{
		case TOutlineDocument::cUserSelectionChanged:
			UpdateUserSelectionChanged(static_cast_AC(TView*, changeData));
			break;

		case pExpanded:
			UpdateExpanded(*static_cast_AC(long*, changeData));
			break;
	}

	Inherited::DoUpdate(theChange, changedObject, changeData, dependencySpace);
}

//----------------------------------------------------------------------------------------
// TOutlineView::UpdateUserSelectionChanged:
//----------------------------------------------------------------------------------------
#pragma segment MAApplicationRes

void TOutlineView::UpdateUserSelectionChanged(TView* changedView)
{
#pragma unused (changedView)
}

//----------------------------------------------------------------------------------------
// TOutlineView::UpdateExpanded:
//----------------------------------------------------------------------------------------
#pragma segment MAApplicationRes

void TOutlineView::UpdateExpanded(long id)
{
	long row = fOutlineArray.FindByID(id);
	if ((row > 0) && Focus())
	{
		OutlineNode node = At(row);
		long n = 0;
		if (node.Expanded())
		{
			// Delete children before marking node as collapsed
			n = -fOutlineArray.DeleteChildren(row);
		}

		// Update the cached state of the node
		node.UpdateExpanded();
		AtPut(row, node);

		// Get the triangle image up to date
		bool triangleInvalid = (fTriangleRow != row) || (fTriangle->GetValue() != node.Expanded());
			InvalidateTriangle(row);

		// Delete old rows
		if (n < 0)
			DelRowAt(row + 1, -n);

		if (node.Expanded())
		{
			// Insert its children
			n = fOutlineArray.InsertChildrenBefore(row + 1, node.GetItem(), node.Indent() + 1);
		}

		// Insert new rows
		if (n > 0)
			InsRowBefore(row + 1, n, fLineHeight + fRowInset);
	}
}

//----------------------------------------------------------------------------------------
// Outline Structure
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TOutlineView::BuildOutline:
//----------------------------------------------------------------------------------------

void TOutlineView::BuildOutline()
{
	fOutlineArray.DeleteAll();

	TOutlineDocument* outlineDocument = dynamic_cast_AC(TOutlineDocument*, fDocument);
	if (outlineDocument)
	{
		MOutlineContainer* container = outlineDocument->GetOutline();
		if (container)
		{
			fOutlineArray.InsertChildren(container, 0);
			container->Free();
		}
	}

	long n = fOutlineArray.GetSize();
	if (n < fNumOfRows)
	{
		DelRowAt(fNumOfRows - n + 1, n);
	}
	else if (n > fNumOfRows)
	{
		InsRowLast(n, fLineHeight + fRowInset);
	}
}

//----------------------------------------------------------------------------------------
// TOutlineView::GetText:
//----------------------------------------------------------------------------------------

CStr255_AC TOutlineView::GetText(const GridCell& aCell) const // override
{
	if ((aCell.h == 1) && (aCell.v <= fOutlineArray.GetSize()))
	{
		return At(aCell.v).GetName();
	}
	else
	{
		return gEmptyString;
	}
}

//----------------------------------------------------------------------------------------
// TOutlineView::At:
//----------------------------------------------------------------------------------------

OutlineNode TOutlineView::At(GridCoordinate row) const
{
	OutlineNode node;

	if ((row > 0) && (row <= fOutlineArray.GetSize()))
		node = fOutlineArray.At(row);

	return node;
}

//----------------------------------------------------------------------------------------
// TOutlineView::AtPut:
//----------------------------------------------------------------------------------------

void TOutlineView::AtPut(GridCoordinate row, const OutlineNode& node)
{
	if ((row > 0) && (row <= fOutlineArray.GetSize()))
		fOutlineArray.AtPut(row, node);
}

//----------------------------------------------------------------------------------------
// TOutlineView::Indent:
//----------------------------------------------------------------------------------------

long TOutlineView::Indent(GridCoordinate row) const
{
	return At(row).Indent();
}

//----------------------------------------------------------------------------------------
// TOutlineView::Expandable:
//----------------------------------------------------------------------------------------

bool TOutlineView::Expandable(GridCoordinate row) const
{
	return At(row).Expandable();
}

//----------------------------------------------------------------------------------------
// TOutlineView::Expanded:
//----------------------------------------------------------------------------------------

bool TOutlineView::Expanded(GridCoordinate row) const
{
	return At(row).Expanded();
}

//----------------------------------------------------------------------------------------
// TOutlineView::SetExpanded:
//----------------------------------------------------------------------------------------

void TOutlineView::SetExpanded(GridCoordinate row, bool expanded)
{
	OutlineNode node = At(row);
	if (expanded != node.Expanded())
	{
		node.SetExpanded(expanded);
	}
	else
	{
		// State of triangle doesn't match state of node!!!
		SysBeep(10);
	}
}


//----------------------------------------------------------------------------------------
// End of UOutlineView.cpp

