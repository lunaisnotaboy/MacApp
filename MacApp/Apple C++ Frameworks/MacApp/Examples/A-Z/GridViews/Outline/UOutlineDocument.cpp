//----------------------------------------------------------------------------------------
// UOutlineDocument.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/19/01	DoNeedDiskSpace is now const.  Cosmetic.  GetName and
					SetName now take CString_AC.  GetText returns a CString_AC.
		01/02/01	Update copyright.
		12/08/99	Include UScripting.h.  Removed unnecessary copy
					constructor and Clone.
*/

#ifndef __UOUTLINEDOCUMENT__
#include "UOutlineDocument.h"
#endif

// Outline

#ifndef __Outline_r_h__
#include "Outline.r.h"
#endif

#ifndef __UOUTLINE__
#include "UOutline.h"
#endif

// MacApp

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __USCRIPTING__
#include "UScripting.h"
#endif

//========================================================================================
// CLASS TBooleanList
//========================================================================================

//----------------------------------------------------------------------------------------
// TBooleanList destructor
//----------------------------------------------------------------------------------------
#pragma segment MADestructorRes

TBooleanList::~TBooleanList()
{
}

//========================================================================================
// CLASS TOutlineDocument
//========================================================================================

//----------------------------------------------------------------------------------------
// TOutlineDocument constructor
//----------------------------------------------------------------------------------------

TOutlineDocument::TOutlineDocument(TFile* itsFile, OSType itsCreator) :
	TFileBasedDocument(itsFile, itsCreator)
{
}

//----------------------------------------------------------------------------------------
// TOutlineDocument destructor
//----------------------------------------------------------------------------------------

TOutlineDocument::~TOutlineDocument()
{
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::FreeData:
//----------------------------------------------------------------------------------------

void TOutlineDocument::FreeData()
{
	TFileBasedDocument::FreeData();
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::DoInitialState:
//----------------------------------------------------------------------------------------

void TOutlineDocument::DoInitialState()
{
	TFileBasedDocument::DoInitialState();

	fText = NewPermHandle_AC(0);

	ComputeLineStarts();
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::DoMakeViews:
//----------------------------------------------------------------------------------------

void TOutlineDocument::DoMakeViews(bool /*forPrinting*/)
{
	TWindow* aWindow = gViewServer->NewTemplateWindow(kOutlineWindowID, this);
	ThrowIfNULL_AC(aWindow);

	TView* aOutlineView = aWindow->FindSubView('SKEL');
	TStdPrintHandler* aHandler = TH_new TStdPrintHandler(this, aOutlineView, kFixedSize, kFixedSize);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::DoSetupMenus:
//----------------------------------------------------------------------------------------

void TOutlineDocument::DoSetupMenus()
{
	TFileBasedDocument::DoSetupMenus();

	Enable(cCommandHandledByDocument, true);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::DoMenuCommand:
//----------------------------------------------------------------------------------------

void TOutlineDocument::DoMenuCommand(CommandNumber aCommandNumber)
{
	switch (aCommandNumber)
	{
		case cCommandHandledByDocument:
			//PostCommand(TH_new TOutlineCommand(aCommandNumber, this));
			break;

		default:
			TFileBasedDocument::DoMenuCommand(aCommandNumber);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::DoNeedDiskSpace:
//----------------------------------------------------------------------------------------

void TOutlineDocument::DoNeedDiskSpace(TFile* itsFile, long& dataForkBytes, long& rsrcForkBytes) const
{
	if (fText)
		dataForkBytes += GetHandleSize(fText);

	TFileBasedDocument::DoNeedDiskSpace(itsFile, dataForkBytes, rsrcForkBytes);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::DoRead:
//----------------------------------------------------------------------------------------

void TOutlineDocument::DoRead(TFile* aFile, bool forPrinting)
{
	TFileBasedDocument::DoRead(aFile, forPrinting);

	long n = 0;
	ThrowIfOSErr_AC(aFile->GetDataLength(n));
	n -= aFile->GetPosition();
	CTempHandle_AC text = NewPermHandle_AC(n);
	{
		CTempHandleLock_AC lockText(text);
		aFile->ReadData(*text, n);
	}
	SetPermHandleSize_AC(text, n);
	fText = text.release();
		// Must use release() because CTempHandle_AC::operator== doesn't !!!
		// This is different from CAutoPtr_AC

	ComputeLineStarts();
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::DoWrite:
//----------------------------------------------------------------------------------------

void TOutlineDocument::DoWrite(TFile* aFile, bool makingCopy)
{
	if (fText)
	{
		CTempHandleLock_AC lockText(fText);
		long n = GetHandleSize(fText);
		aFile->WriteData(*fText, n);
	}

	TFileBasedDocument::DoWrite(aFile, makingCopy);
}

//----------------------------------------------------------------------------------------
// Text
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TOutlineDocument::ComputeLineStarts:
//----------------------------------------------------------------------------------------

void TOutlineDocument::ComputeLineStarts()
{
	fLineStarts.DeleteAll();
	fIndents.DeleteAll();
	fExpanded.DeleteAll();

	long n = GetHandleSize(fText);
	long i = 0;
	long indent = -1;
	while (i < n)
	{
		// Insert the line start
		fLineStarts.Insert(i);
		fExpanded.Insert(true);

		// Compute the indent
		{
			char* c = &(*fText)[i];
			long j = 0;
			while (c[j] == '\t') ++j;
			indent = Min_AC(j, indent + 1);
			fIndents.Insert(indent);
			i += j;
		}

		// Skip to the end of the line
		while ((*fText)[i] != '\n') ++i;
		++i;	// skip the return
	}

	// One more for convenience
	fLineStarts.Insert(n);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::GetNumberOfLines:
//----------------------------------------------------------------------------------------

long TOutlineDocument::GetNumberOfLines()
{
	return fLineStarts.GetSize() - 1;
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::GetLineStart:
//----------------------------------------------------------------------------------------

long TOutlineDocument::GetLineStart(long line)
{
	return fLineStarts.At(line);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::GetIndent:
//----------------------------------------------------------------------------------------

long TOutlineDocument::GetIndent(long line)
{
	return (line == 0) ? -1 : fIndents.At(line);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::GetText:
//----------------------------------------------------------------------------------------

CString_AC TOutlineDocument::GetText(long line)
{
	if (fText && (line > 0))
	{
		long i = GetLineStart(line) + GetIndent(line);
		long j = GetLineStart(line + 1);
		CTempHandleLock_AC lockText(fText);
			// use void* instead of char* because CPascalStr_AC::CopyFrom(const char*, unsigned char)
			// will truncate the string to strlen(str) modulo 256
		return CString_AC(&(*fText)[i], j - i);
	}
	else
		return CString_AC();
}

//----------------------------------------------------------------------------------------
// Outline structure
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TOutlineDocument::GetOutline:
//----------------------------------------------------------------------------------------

MOutlineContainer* TOutlineDocument::GetOutline()
{
	return new TMyOutlineNode(this, 0);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::Expanded:
//----------------------------------------------------------------------------------------

bool TOutlineDocument::Expanded(long line) const
{
	return (line > 0) ? fExpanded.At(line) : true;
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::SetExpanded:
//----------------------------------------------------------------------------------------

void TOutlineDocument::SetExpanded(long line, bool expanded)
{
	if (line > 0)
	{
		fExpanded.AtPut(line, expanded);
		NotifyExpanded(line);
	}
}

//----------------------------------------------------------------------------------------
// Selection
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TOutlineDocument::AddSelectionDependency
//----------------------------------------------------------------------------------------
#pragma segment ASelCommand

void TOutlineDocument::AddSelectionDependency(MDependable_AC* dependent)
{
	fSelectionNotifier.AddDependent(dependent);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::RemoveSelectionDependency
//----------------------------------------------------------------------------------------
#pragma segment ASelCommand

void TOutlineDocument::RemoveSelectionDependency(MDependable_AC* dependent)
{
	fSelectionNotifier.RemoveDependent(dependent);
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::UserSelectionChanged
//----------------------------------------------------------------------------------------
#pragma segment ASelCommand

void TOutlineDocument::UserSelectionChanged(TView* changedView)
{
	fSelectionNotifier.Changed(cUserSelectionChanged, changedView);

	// No need to call Inherited method -- it's empty
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::NotifyExpanded
//----------------------------------------------------------------------------------------
#pragma segment ASelCommand

void TOutlineDocument::NotifyExpanded(long id)
{
	fSelectionNotifier.Changed(pExpanded, &id);
}

//----------------------------------------------------------------------------------------
// Scripting
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TOutlineDocument::CountContainedObjects:
//----------------------------------------------------------------------------------------
long TOutlineDocument::CountContainedObjects(DescType desiredType)
{
	long count = 0;

	if (desiredType == cContainer)
		count = 1;
	else
		count = TFileBasedDocument::CountContainedObjects(desiredType);

	return count;
}

//----------------------------------------------------------------------------------------
// TOutlineDocument::GetContainedObject:
//----------------------------------------------------------------------------------------
MScriptableObject* TOutlineDocument::GetContainedObject(DescType desiredType,
														DescType selectionForm,
														const CAEDesc& selectionData)
{
	MScriptableObject* result = NULL;
	if (desiredType == cContainer)
	{
		MOutlineContainer* outline = GetOutline();
		result = dynamic_cast_AC(MScriptableObject*, outline);
	}
	else
		result = TFileBasedDocument::GetContainedObject(desiredType, selectionForm, selectionData);

	return result;
}

//========================================================================================
// CLASS TMyOutlineNode
//========================================================================================

//----------------------------------------------------------------------------------------
// TMyOutlineNode constructor
//----------------------------------------------------------------------------------------

TMyOutlineNode::TMyOutlineNode(TOutlineDocument* itsDocument, long line) :
	fDocument(itsDocument),
	fLine(line)
{
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode copy constructor
//----------------------------------------------------------------------------------------

TMyOutlineNode::TMyOutlineNode(const TMyOutlineNode& in) :
	TOutlineObject(in),
	fDocument(in.fDocument),
	fLine(in.fLine)
{
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::Clone:
//----------------------------------------------------------------------------------------

void* TMyOutlineNode::Clone() const
{
	return TH_new TMyOutlineNode(*this);
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode destructor
//----------------------------------------------------------------------------------------

TMyOutlineNode::~TMyOutlineNode()
{
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::Free
//----------------------------------------------------------------------------------------

void TMyOutlineNode::Free()
{
	// Make sure we'll get deleted sometime
	TOSADispatcher::fgDispatcher->AddTemporaryToken(this);
}

//----------------------------------------------------------------------------------------
// Outline Structure
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TMyOutlineNode::GetOutlineContainer:
//----------------------------------------------------------------------------------------

MOutlineContainer* TMyOutlineNode::GetOutlineContainer() const
{
	MOutlineContainer* container = nil;

	long n = 0;
	long indent = fDocument->GetIndent(fLine);
	for (long line = fLine - 1; line >= 1; --line)
	{
		if (fDocument->GetIndent(line) == indent - 1)
		{
			container = new TMyOutlineNode(fDocument, line);
			break;
		}
	}

	return container;
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::GetID:
//----------------------------------------------------------------------------------------

long TMyOutlineNode::GetID() const
{
	return fLine;
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::GetName:
//----------------------------------------------------------------------------------------

CString_AC TMyOutlineNode::GetName() const
{
	return fDocument->GetText(fLine);
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::SetName:
//----------------------------------------------------------------------------------------

void TMyOutlineNode::SetName(const CString_AC& name)
{
	#pragma unused (name)
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::CountContainedItems:
//----------------------------------------------------------------------------------------

long TMyOutlineNode::CountContainedItems() const
{
	long n = 0;
	long indent = fDocument->GetIndent(fLine);
	long numOfLines = fDocument->GetNumberOfLines();
	for (long line = fLine + 1; line <= numOfLines; ++line)
	{
		long lineIndent = fDocument->GetIndent(line);
		if (lineIndent <= indent)
			break;

		if (lineIndent == indent + 1)
			++n;
	}
	return n;
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::GetIndItem:
//----------------------------------------------------------------------------------------

MOutlineContainer* TMyOutlineNode::GetIndItem(long index) const
{
	MOutlineContainer* item = nil;

	long n = 0;
	long indent = fDocument->GetIndent(fLine);
	long numOfLines = fDocument->GetNumberOfLines();
	for (long line = fLine + 1; line <= numOfLines; ++line)
	{
		long lineIndent = fDocument->GetIndent(line);
		if (lineIndent <= indent)
			break;

		if (lineIndent == indent + 1)
		{
			if (++n == index)
			{
				item = new TMyOutlineNode(fDocument, line);
				break;
			}
		}
	}

	return item;
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::Expandable:
//----------------------------------------------------------------------------------------

bool TMyOutlineNode::Expandable() const
{
	return CountContainedItems() > 0;
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::Expanded:
//----------------------------------------------------------------------------------------

bool TMyOutlineNode::Expanded() const
{
	return fDocument->Expanded(fLine);
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::SetExpanded:
//----------------------------------------------------------------------------------------

void TMyOutlineNode::SetExpanded(bool expanded)
{
	fDocument->PostCommand(new TExpandCommand(pExpanded, fDocument, fLine, expanded));
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::CompletelyExpanded:
//----------------------------------------------------------------------------------------

bool TMyOutlineNode::CompletelyExpanded() const
{
	return false;
}

//----------------------------------------------------------------------------------------
// TMyOutlineNode::SetCompletelyExpanded:
//----------------------------------------------------------------------------------------

void TMyOutlineNode::SetCompletelyExpanded(bool expanded) const
{
#pragma unused (expanded)
}

//========================================================================================
// CLASS TExpandCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TExpandCommand destructor
//----------------------------------------------------------------------------------------
#pragma segment MADestructorRes

TExpandCommand::~TExpandCommand()
{
}

//----------------------------------------------------------------------------------------
// TExpandCommand::MakeAppleEvent:
//----------------------------------------------------------------------------------------

TAppleEvent* TExpandCommand::MakeAppleEvent()
{
	return NULL;
}

//----------------------------------------------------------------------------------------
// TExpandCommand::DoIt:
//----------------------------------------------------------------------------------------
#pragma segment ADoCommand

void TExpandCommand::DoIt()
{
	static_cast_AC(TOutlineDocument*, fContext)->SetExpanded(fLine, fExpand);
}

//----------------------------------------------------------------------------------------
// End of UOutlineDocument.cpp

