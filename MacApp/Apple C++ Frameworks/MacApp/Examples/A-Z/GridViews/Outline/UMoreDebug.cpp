//----------------------------------------------------------------------------------------
// UMoreDebug.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		03/24/99	Update copyright notice.
		11/13/98	[2279264] Add false to ProgramBreak_AC call.
*/

#ifndef __UMOREDEBUG__
#include "UMoreDebug.h"
#endif

// MacApp

// ANSI

#ifndef __STDIO__
#include <stdio.h>
#endif


//========================================================================================
// Global Functions
//========================================================================================
#undef Inherited

//========================================================================================
// Debug only functions
//========================================================================================

#if qDebug
//----------------------------------------------------------------------------------------
// DebugWarning:
//----------------------------------------------------------------------------------------
#pragma segment MAFailureRes

void DebugIfWarning(bool condition, const CStr255_AC& description, const char* inFile, short inLine)
{
	if (!condition)
		ProgramReport_AC("Warning condition: %s. File: %s, Line: %d\n", CChar255_AC(description), inFile, inLine);
}
#endif


//----------------------------------------------------------------------------------------
// RangeCheck
//----------------------------------------------------------------------------------------
#pragma segment MAFailureRes

Boolean RangeCheck(ArrayIndex_AC index, ArrayIndex_AC minimum, ArrayIndex_AC maximum,
				   const char* message)
{
	Boolean inRange = (index >= minimum) && (index <= maximum);
#if qDebugMsg
	if (!inRange)
	{
		if (message)
		{
			fprintf(stderr, "index %d out of range %d..%d %s\n",
					index, minimum, maximum, message);
		}
		else
		{
			fprintf(stderr, "index %d out of range %d..%d\n",
					index, minimum, maximum);
		}
	}
#else
#pragma unused(message)
#endif
	return inRange;
}

//----------------------------------------------------------------------------------------
// End of UMoreDebug.cpp

#pragma segment Inline