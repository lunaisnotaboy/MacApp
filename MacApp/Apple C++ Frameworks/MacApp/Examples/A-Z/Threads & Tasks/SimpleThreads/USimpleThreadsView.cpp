//----------------------------------------------------------------------------------------
// USimpleThreadsView.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		07/24/00	CW Pro 6: implicit 'int' no longer supported in C++. 
					Namespacing. 
		02/07/00	Merge context completely into thread. 
		01/31/00	Don't have to allocate CThreadRunner on the heap. 
		12/08/99	Fixed file name in banner.
		12/10/99	pi not implemented in Carbon, so setting pi to 3.14159265.
		11/09/99	Change the API for GetContextualMenu so it has access to the click
					event and can fill in all of the parameters for the menu. 
		10/25/99	Update to support Carbon.
		08/17/99	Change obsoleted macros to ACS versions. 
		03/24/99	Update copyright notice.
		03/18/99	Removed '&' on parms to a variety of Toolbox calls.
		01/15/99	CAEDesc_AC is now in ACS. 
		11/13/98	[2279263] Cast result of Random to unsigned short in DrawSpirograph.
*/


#ifndef __USIMPLETHREADSVIEW__
#include "USimpleThreadsView.h"
#endif

// SimpleThreads

#ifndef __UDocumentSimpleThreads__
#include "UDocumentSimpleThreads.h"
#endif

#ifndef __USimpleThread__
#include "USimpleThread.h"
#endif

// MacApp

#if qWantsContextualMenus
	#ifndef __UContextualMenu__
	#include "UContextualMenu.h"
	#endif
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

// ACS

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __CThreadRunner_AC__
#include "CThreadRunner_AC.h"
#endif

// Toolbox

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __FP__
#include <fp.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

using std::cos;
using std::sin;

//========================================================================================
// Constants
//========================================================================================

enum
{
	mRunningThread = 1000,
	mStoppedThread = 1001
};

enum
{
	cStartThread = 409,
	cStopThread = 410
};

//========================================================================================
// Global Initialization Procedure
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// InitUSimpleThreadsView: 
//----------------------------------------------------------------------------------------

void InitUSimpleThreadsView()
{
	// So the linker doesn't dead strip class info 
	REGISTER_CLASS_AC(TSimpleThreadsView);
}

//========================================================================================
// CLASS TSimpleThreadsView
//========================================================================================
#undef Inherited
#define Inherited TView

MA_DEFINE_CLASS(TSimpleThreadsView);

//----------------------------------------------------------------------------------------
// TSimpleThreadsView constructor 
//----------------------------------------------------------------------------------------

TSimpleThreadsView::TSimpleThreadsView(const CViewPoint& itsLocation,
						 				const CViewPoint& itsSize) : 
	TView(itsLocation,itsSize,sizeFixed, sizeFixed),
	fThreadRunner(NULL)
{
}

//----------------------------------------------------------------------------------------
// TSimpleThreadsView copy constructor 
//----------------------------------------------------------------------------------------

TSimpleThreadsView::TSimpleThreadsView(const TSimpleThreadsView& from) : 
	TView(from),
	fThreadRunner(NULL) // do not copy the thread
{
}

//----------------------------------------------------------------------------------------
// TSimpleThreadsView destructor
//----------------------------------------------------------------------------------------

TSimpleThreadsView::~TSimpleThreadsView()
{
//	StopThreadExample();
}

//----------------------------------------------------------------------------------------
// TSimpleThreadsView::DoPostCreate: 
//----------------------------------------------------------------------------------------
	
void TSimpleThreadsView::DoPostCreate(TDocument* itsDocument) // Override 
{
	Inherited::DoPostCreate(itsDocument);
	
	// StartThreadExample();
}
	
//----------------------------------------------------------------------------------------
// TSimpleThreadsView::Draw: 
//----------------------------------------------------------------------------------------

void TSimpleThreadsView::Draw(const CViewRect& /*area*/) // Override 
{
	CRect_AC aRect(GetQDExtent());
	::PenNormal();	
	PenPatBlack();
	gRGBBlack.SetForeColor();
	::PaintRect(aRect);
}


//----------------------------------------------------------------------------------------
// TSimpleThreadsView StartThreadExample
//----------------------------------------------------------------------------------------

void TSimpleThreadsView::StartThreadExample()
{
	if (fThreadRunner == NULL)
	{
		fThreadRunner = TH_new TSimpleThread(this);
		
		// set fUserArea so the document knows our thread is running
		fUserArea = true;
	}
}

//----------------------------------------------------------------------------------------
// TSimpleThreadsView StopThreadExample
//----------------------------------------------------------------------------------------

void TSimpleThreadsView::StopThreadExample()
{
	if (fThreadRunner != NULL) 
	{
		fThreadRunner->Join();
		fThreadRunner.reset();
		
		ForceRedraw();
		
		// set fUserArea so the document knows our thread has stopped
		fUserArea = false;
	}
}

//----------------------------------------------------------------------------------------
// TSimpleThreadsView DrawSpirograph
//----------------------------------------------------------------------------------------

void TSimpleThreadsView::DrawSpirograph(int& iter)
{
	if (Focus()) 
	{
		::PenNormal();
		CRGBColor_AC color;
		if (iter >= 16) 
		{	// Clear the view every so often.
			CViewRect aVRect = GetVisibleExtent();
			::PenNormal();	
			PenPatBlack();
			color.Set(0, 0, 0);
			color.SetForeColor();
			::PaintRect(ViewToQD(aVRect));
			iter = 0;
		}
		++iter;
		color.Set(::Random(), ::Random(), ::Random());
		color.SetForeColor();
		PenPatBlack();
		// Generate three random polar coordinates on the unit circle.
		float r1, r2, r3, theta1, theta2, theta3;
		r1 = float(::Random())/float(32767);
		r2 = float(::Random())/float(32767);
		r3 = float(::Random())/float(32767);
#pragma warning ("pi not implemented in Carbon, so setting pi to 3.14159265");
		theta1 = float(::Random())/(2.0*3.14159265);
		theta2 = float(::Random())/(2.0*3.14159265);
		theta3 = float(::Random())/(2.0*3.14159265);
		// Generate random number of increments.
		int count = 3 + static_cast<unsigned short>(::Random())/1024;
		// Get dimensions.
		CViewPoint center(fSize.h / 2, fSize.v / 2); 
		CViewPoint radii = center;
		--radii.h;
		--radii.v;
		// Compute starting point.
		CViewPoint start;
		start.h = center.h + (cos(theta1) * r1) * radii.h;
		start.v = center.v + (sin(theta1) * r1) * radii.v;
		CPoint_AC temp = ViewToQD(start);
		
		for (int i = 0; i < count; ++i) 
		{
			color.SetForeColor();
			PenPatBlack();
			::MoveTo(temp.h, temp.v);
			// Convert points to view coordinates.
			
			CViewPoint p1, p2, p3;
			p1.h = center.h + (cos(theta1) * r1) * radii.h;
			p1.v = center.v + (sin(theta1) * r1) * radii.v;
			p2.h = center.h + (cos(theta2) * r2) * radii.h;
			p2.v = center.v + (sin(theta2) * r2) * radii.v;
			p3.h = center.h + (cos(theta3) * r3) * radii.h;
			p3.v = center.v + (sin(theta3) * r3) * radii.v;
			// Draw the figure.
			temp = ViewToQD(p1);
			::LineTo(temp.h, temp.v);
			temp = ViewToQD(p2);
			::LineTo(temp.h, temp.v);
			temp = ViewToQD(p3);
			::LineTo(temp.h, temp.v);
			// Increment the angles.
			theta1 += 2.0*3.14159265/float(count);
			theta2 += 2.0*3.14159265/float(count);
			theta3 += 2.0*3.14159265/float(count);
			::YieldToAnyThread();
			// Reestablish Focus after yield.
			Focus();
		}
		::MoveTo(temp.h, temp.v);
		temp = ViewToQD(start);
		::LineTo(temp.h, temp.v);	// Close the figure.
	}
}

//----------------------------------------------------------------------------------------
// TSimpleThreadsView::DoEvent: 
//----------------------------------------------------------------------------------------
			
void TSimpleThreadsView::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event)
{
	switch (eventNumber)
	{
		case mStartThread:
			StartThreadExample();
			break;
			
		case mStopThread:
			StopThreadExample();
			break;
		
		case mToggleThread:
			if (fThreadRunner)
				StopThreadExample();
			else
				StartThreadExample();
			break;
	}
	Inherited::DoEvent(eventNumber, source, event);
}

#if qWantsContextualMenus

//----------------------------------------------------------------------------------------
// TSimpleThreadsView:: 
//----------------------------------------------------------------------------------------

void TSimpleThreadsView::DoSetupMenus()
{
	Inherited::DoSetupMenus();

	Enable(cStartThread, true /*(fThreadRunner == NULL)*/);
	Enable(cStopThread, true /*(fThreadRunner != NULL)*/);
} // TSimpleThreadsView::DoSetupMenus 

//----------------------------------------------------------------------------------------
//
//----------------------------------------------------------------------------------------

void TSimpleThreadsView::DoMenuCommand(CommandNumber aCommandNumber)
{
	switch (aCommandNumber)
	{
		case cStartThread:
			StartThreadExample();
			break;
		
		case cStopThread:
			StopThreadExample();
			break;
			
		default:
			Inherited::DoMenuCommand(aCommandNumber);
			break;
	}
} // TSimpleThreadsView::DoMenuCommand 

//----------------------------------------------------------------------------------------
// Contextual menu example
//----------------------------------------------------------------------------------------

void TSimpleThreadsView::GetContextualMenu(const CViewPoint& theMouse,
										   TToolboxEvent* event,
										   CContextualMenu& contextualMenu)
{
#pragma unused (theMouse, event)

	// Contextual menu example code
	ResNumber menuID = (fThreadRunner == NULL) ? mStoppedThread : mRunningThread;
	contextualMenu.SetMenu(::MAGetMenu(menuID));
		
	// Pass back our web site address for the selection!!!
}

#endif // qWantsContextualMenus

//----------------------------------------------------------------------------------------
// End of USimpleThreadsView.cpp
