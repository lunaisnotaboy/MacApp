//-------------------------------------------------------------------------------------------
// UFracApp.cpp
// Copyright © 1991-2001 by Apple Computer, Inc., all rights reserved.
//-------------------------------------------------------------------------------------------

//	Contains:	FracApp source

/*
	Change History
		07/23/01	Removing old features. 
		06/22/01	Always use 32-bit QuickDraw. Remove support for palette animation
					because it only works on indexed-color displays. 
		06/13/01	Protected gClipboardMgr fields. 
		05/07/01	Comment out pragma messages for Carbon. 
		03/04/01	Clean up string casting. 
		02/06/01	Include StdStringUtils_AC.h.  Change document title setting
					in AutoSaveThisGuy.
		01/02/01	Update copyright.
		01/31/00	Replace CExtended with CExtended80. 
		12/08/99	Fixed file name in banner.  Take out MA_DEFINE_CLASS of
					TFracAppApplication.  Don’t ExitToShell for MrC or SCPP
					since difficulty at static destruction time bomb is fixed.
		03/24/99	Update copyright notice.
*/

#ifndef __FRACAPP__
#include "UFracApp.h"
#endif

// FracApp

#ifndef __CEXTENDED__
#include "CExtended.h"
#endif

#ifndef __UFRACDOC__
#include "UFracDoc.h"
#endif

#ifndef __UFRACGLOBALS__
#include "UFracGlobals.h"
#endif

#ifndef __UFRACVIEWS__
#include "UFracViews.h"
#endif

// MacApp

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UERRORMGR__
#include "UErrorMgr.h"
#endif

#ifndef __UCLIPBOARDMGR__
#include "UClipBoardMgr.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOWMENUBEHAVIOR__
#include "UWindowMenuBehavior.h"
#endif

// ACS

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// Toolbox

#ifndef __THREADS__
#include <Threads.h>
#endif

#ifndef __PACKAGES__
#include <Packages.h>
#endif

#ifndef __FP__
#include <fp.h>
#endif


//-------------------------------------------------------------------------------------------

/* We define two different palettes for two different situations. We’d like to be able to
  animate when we can; in that case, we attach the palette identified with
  kAnimatingPaletteID to each window we make. If we can’t animate our colors (which occurs
  when we don’t have 32-bit Color QuickDraw), then we fall back on a palette that at least
  guarantees we have the colors we need (kTolerantPalette). */

enum
{
	kTolerantPalette	= 1001,						// palette ID for not animating
	kAnimatingPalette	= 1002,						// palette ID for animating
	kClut				= 501						// ID for the clut resource that we use for offscreen blinging.
};

/* When calling SetPalette, we need to pass a bool that tells the Palette manager whether
  or not we want updates when our window is activated. These two constants help clarify what
  we are passing to SetPalette. */

enum
{
	kWantUpdates		= true,
	kDontWantUpdates	= false
};													// for offscreen blinging.

enum
{
	kNo32BCQD			= - 25002					// error code if 32bCQD is not around. for offscreen blinging.
};
													// Used to display a warning that some menu items will be disabled.

enum
{
	mWindows			= 6							// windows menu
};

//-------------------------------------------------------------------------------------------
//------------------------------TFracAppApplication Methods----------------------------------
//-------------------------------------------------------------------------------------------


/* Initializes the application and globals. Called by the main application when the
  applicaton object is created. */

#undef Inherited
#define Inherited TApplication

TFracAppApplication::TFracAppApplication(OSType itsMainFileType) :
	TApplication(itsMainFileType, kSignature)
{
	//fWindowList = NULL; •••  removed, use TWindowMenuBehavior
	fLastCalculated = NULL;

	/* We can calculate our fractals in one of two different ways. There is a
	  pixel-by-pixel method, which is good for complicated fractals, and there is
	  another method that incurs some additional overhead, but more than makes this
	  up in optimizations on documents that have some large areas that are all the
	  same color. By default, we use the latter, faster method. */

	gUseFastAlgorithm = true;

	/* Initialize so we can use TFracAppDocument and its associated views */
	InitUFracDoc();

	CreateManyColors();

	// We want a windows menu, add the behavior
	AddBehavior(TH_new TWindowMenuBehavior(kNoIdentifier, mWindows));
}

//-------------------------------------------------------------------------------------------


/* The Close method to allow us to clean up before the application quits. We override this
  method rather than TFracAppApplication::Free, because .Free rarely gets called. The
  only time it can get called is when TApplication.Run returns to the main program. At that
  point, it is the main procedure’s responsibility to call .Free. However, hardly anyone
  ever does that, so we override TFracAppApplication::Close instead, which gets called when
  the user selects Quit.

  Our Quit item just removes the time manager task. Failure to do so will leave a pointer to
  a no-longer existant task record and task procedure. Once another application is launched,
  these will get overridden in memory, and the time manager will crash your machine with
  glee. */

void TFracAppApplication::Close()
{
	Inherited::Close();

//	// •••  kludge.
//	// we are getting a serious bomb in the palette manager around static destruction time,
//	// so for the time being, do an ES abruptly.
//#if !(defined(__MRC__) || defined(__SC__))
//	ExitToShell();
//#endif
} // TFracAppApplication::Close

//-------------------------------------------------------------------------------------------


/* Called during the initialization of our application to set up some color stuff. First of
  all, if we can take advantage of the default application palette, we get the palette,
  and set set it as the default. Note that it’s documented in technote #211 that we can just
  define a ‘pltt’ resource of ID 0, and that will automatically be used as the default
  application palette. However, through the wonders of System Software Engineering, that no
  longer works on a Mac IIci and System 6.0.4. Explicitly setting the application palette is
  the workaround. But I digress...After we set the palette, we read in and save a reference
  to the color table used for our offscreen devices and palette manager animation stuff. */

void TFracAppApplication::CreateManyColors()
{
	/* Now allocate a color table that we will use whenever we create a new
	  document. This is so we have the same color table for each document. */

	bool oldPerm = PermAllocation(true);
	gOurColors = ::GetCTable(kClut);
	oldPerm = PermAllocation(oldPerm);
	::ThrowIfNULLResource_AC(Handle(gOurColors));
}

//-------------------------------------------------------------------------------------------


/* Looks for a document that needs calculation time. Round-robins among open
  documents. It does this by calling EachWMgrWindowDoTil with a procedure that
  looks at the document attached to that window, and asks if it needs calculation
  time. If it does, then we return that document to the caller. If we don’t find
  one, we return NULL. If 'lastCalculated' is NULL, it returns the first qualifying
  document it finds. Otherwise, it returns the first qualifying document (if any)
  after it finds 'lastCalculated'. */

TFracAppDocument* TFracAppApplication::GetDocumentToCalculate(TFracAppDocument* lastCalculated)
{
	TFracAppDocument* returnVal = NULL;

	for (CWMgrIterator iter; iter; ++iter)
	{
		TWindow* aWindow = TWindow::WMgrToWindow(iter);
		if (aWindow && dynamic_cast<TFracAppDocument*> (aWindow->GetDocument()))
		{
			TFracAppDocument* doc = dynamic_cast_AC(TFracAppDocument*,aWindow->GetDocument());
			if (lastCalculated == NULL && !doc->GetDone())
			{
				returnVal = doc;
				break;
			}
			if (lastCalculated == doc)
				lastCalculated = NULL;
		}
	}

	return returnVal;
}

//-------------------------------------------------------------------------------------------


/* Finds a document that will do some animation for us. This routine calls
  EachWMgrWindowDoTil to find the first TFracAppWindow it can, and returns the
  attached document. If there are no such windows, then return NULL. */

TFracAppDocument* TFracAppApplication::GetDocumentToAnimate()
{
	TFracAppDocument* returnVal = NULL;
	for (CWMgrIterator iter; iter; ++iter)
	{
		TWindow* aWindow = TWindow::WMgrToWindow(iter);
		if (aWindow && dynamic_cast<TFracAppDocument*> (aWindow->GetDocument()))
		{
			returnVal = dynamic_cast_AC(TFracAppDocument*,aWindow->GetDocument());
			break;
		}
	}

	return returnVal;
}

//-------------------------------------------------------------------------------------------


/* Performs Idle time processing for the application. This will do the fractal calculation
  during idle time. It will allow each open document a chance to calculate.  The way we
  do this is in a front to back order. We get a reference to the top document. If it is not
  done, we call its engine to calculate a little bit of the fractal, and then get out
  of here. If the top document IS done, we find the next document behind it, and give
  it some time, if needed. This process is carried all the way back for as many documents as
  we have.

  This routine is also responsible for doing the Palette Manager animation, if the user has
  selected that option. Finally, if a document signals that it’s done, and that document is
  part of a multipage set, we save that document to disk and start a new one. */

bool TFracAppApplication::DoIdle(IdlePhase phase)
{
	/* MacApp calls us before and after every event, with phase codes of
	  idleBegin and idleEnd.  Phase idleContinue is the 'true' idle.
	  In order to give decent performance to the rest of the application
	  (mouse clicks, menu commands), we want to do real work only on idleContinue. */

	if (phase != idleContinue)
		return false;

//	YieldToAnyThread();

	/* round-robin on documents */
	TFracAppDocument* documentToCalculate = GetDocumentToCalculate(fLastCalculated);
	if ((documentToCalculate == NULL) && fLastCalculated)
	{
		documentToCalculate = GetDocumentToCalculate(NULL);
	}

	fLastCalculated = documentToCalculate;

	bool done = false;
	if (documentToCalculate)
		done = documentToCalculate->CalcTown();

	if (documentToCalculate == NULL)
		SetIdleFreq(kMaxIdleTime);

	/* Idle Time handler have to return a boolean value that states whether or not
	  they have removed themselves from memory. This was something that was
	  supported transparently in MacApp 1.x, but things have changed since then.
	  Now that MacApp 2.0 is MultiFinder aware, it tries to be more intelligent
	  about giving time up to background apps. Because of this, it manages the time
	  given to idle time handlers more thoroughly. It maintains fields that say how
	  often they should be called, and when the last time one was called. Normally,
	  it tries to set this latter field when the TEvtHandler.DoIdle method is done.
	  However, what happens if the object removed itself from the chain and freed
	  itself from memory? The reference to the object is no longer valid, and
	  MacApp would be writing to random memory. To prevent this from happening, we
	  tell MacApp if we are still around. If we return true, MacApp knows that we
	  are history. */

	return false;
}

//-------------------------------------------------------------------------------------------


/* Launches a TFracAppDocument; called when application’s icon is opened, or when New, New
  From Selection, New MultiPage, or Open is requested by the user. After it is done, the
  view and window can be created, relying upon the data in the document. Every application
  which uses documents MUST override this method */

TDocument* TFracAppApplication::DoMakeDocument(CommandNumber itsCommandNumber,
											   TFile* itsFile)
{
	// Allocate and initialize the document.

	/* Now initialize the document fields, and set up the global state of the
	  fractal to a default set of the starting fractal. We specify here what kind
	  of COffscreen object to create in IFracAppDocument. In order to use
	  CNewCoolOffscreen (ie, the new 32-bit CQD stuff), we both have to have 32-bit
	  CQD and want to use it. This could be specified by a menu item, for example. */
	  
	TFracAppDocument* aFracAppDocument = TH_new TFracAppDocument(itsFile, true, itsCommandNumber);
	::ThrowIfNULL_AC(aFracAppDocument);

	// Set the idle time so that we start calculating now!

	SetIdleFreq(3);

	/* We successfully created a document so we can return the document object for
	  use by the application. */

	return aFracAppDocument;
}

//-------------------------------------------------------------------------------------------


/* Handles the menu selections that have global thermonuclear impact. In this case, we handle
  the menu items that determine the characteristics of the next fractal document we create
  (dpi settings, calculation method, or use of 32 Bit CQD), and the Windows menu. Note that
  we have to do some special handling of the Windows menu, as MacApp knows nothing about it;
  we created that puppy ourselves. */

void TFracAppApplication::DoMenuCommand(CommandNumber aCommandNumber)
{
	// A menu item that MacApp knows about was selected.

	switch (aCommandNumber)
	{
		/* Which algorithm to use. Either calculate everything a pixel at a time, or use
		  the Mariani/Silver algorithm to preflight certain solid areas. */

		case cSlowAlgorithm:
			gUseFastAlgorithm = false;
			break;

		case cFastAlgorithm:
			gUseFastAlgorithm = true;
			break;

		// E. None of the above.

		default:
			Inherited::DoMenuCommand(aCommandNumber);
	}
}

//-------------------------------------------------------------------------------------------


/* Determines the state of our menus. Before MacApp calls DoSetupMenus, it goes through and
  disables all the menu items, and removes any check marks. Then, starting with gTarget, it
  calls DoSetupMenus. Each DoSetupMenus should call its Inherited::method first so that they
  can set up the world the way the like it, and then we have a chance to override that
  (there’s that word again...). In this case, TFracAppApplication deals with all menu items
  that have a global aspect (like the options for creating a new document), but aren’t
  handled by TApplication. */

void TFracAppApplication::DoSetupMenus()
{
	Inherited::DoSetupMenus(); 					// Do mainline stuff first.

	EnableCheck(cSlowAlgorithm, true, ! gUseFastAlgorithm);
	EnableCheck(cFastAlgorithm, true, gUseFastAlgorithm);
}

//-------------------------------------------------------------------------------------------


/* Show our own About box rather than MacApp’s fine but rather standard one. We simply use a
  MacApp view and window, and call PoseModally on its TDialogView. */

void TFracAppApplication::DoAboutBox()
{
	TWindow* theWindow = dynamic_cast_AC(TWindow*,(gViewServer->NewTemplateWindow(kAbout, NULL)));
	IDType dismisser;
	do
	{
		dismisser = theWindow->PoseModally();
		if (dismisser == 'icon')
		{
			TWindow* theWindow2 = dynamic_cast_AC(TWindow*,gViewServer->NewTemplateWindow(kAbout2, NULL));
			IDType dismisser2 = theWindow2->PoseModally();
			theWindow2->Close();
		}
	} while (dismisser != 'okok');
	theWindow->Close();
}


//-------------------------------------------------------------------------------------------
// End of UFracApp.cpp
