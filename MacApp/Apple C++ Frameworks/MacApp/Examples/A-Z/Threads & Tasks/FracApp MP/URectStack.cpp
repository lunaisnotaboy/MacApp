//-------------------------------------------------------------------------------------------
// URectStack.cpp
// Copyright © 1997-2001 by Apple Computer, Inc.  All rights reserved.
//-------------------------------------------------------------------------------------------

/*
	Change History
		07/23/01	Removing old features. 
		03/01/01	Don't include Threads_AC. 
		01/02/01	Update copyright.
		02/15/00	Use new synchronization classes. 
		12/08/99	Moved include of Files.h down ANSI header so that ConditionalMacros_AC.h
					is included earlier than ConditionalMacros.h.  Work around
					SCPP problem with array delete and __vec_delete().
		03/24/99	Update copyright notice.
		12/03/98	Include Multiprocessing.h.
		11/13/98	[2279259] Work around MrC’s inability to handle array delete in
					CRectStack and CRectQueue’s ctors and dtors.
		11/12/98	[2279245] Included MacAppRequired.h.  [2279247] Include Threads_AC.h.
*/

#ifndef __URECTSTACK__
#include "URectStack.h"
#endif

// MacApp

#ifndef __MacAppRequired__
#include "MacAppRequired.h"
#endif

// ACS

#ifndef __ThreadUtilities_AC__
#include "ThreadUtilities_AC.h"
#endif

// Toolbox

#ifndef __MULTIPROCESSING__
#include <Multiprocessing.h>
#endif

#ifndef __FILES__
#include <Files.h>
#endif


//-------------------------------------------------------------------------------------------
//----------------------------------CRectStack Methods---------------------------------------
//-------------------------------------------------------------------------------------------


// Initialize a new array with numberOfRects rects.
CRectStack::CRectStack(long numberOfRects) :
	fSize(0),
	fAllocatedSize(0),
#if qTuneRectStack
	fHighWaterMark(0),
#endif
	fData(NULL),
	fLock(CTempMutex::kCreate)
{
#if !(defined(__SC__) && !FIXED_MPW_BUG)
	fData = TH_new CRect_AC[numberOfRects];
#else
	// Workaround for SCpp which has a problem with array delete[]
	#if qTidyHeap
		fData = static_cast<CRect_AC*>(operator new( sizeof(CRect_AC)*numberOfRects, _FILE_AC, __LINE__ ));
	#else
		fData = static_cast<CRect_AC*>(operator new( sizeof(CRect_AC)*numberOfRects ));
	#endif
#endif
	fAllocatedSize = numberOfRects;
}

//-------------------------------------------------------------------------------------------


// Free the array.

CRectStack::~CRectStack()
{
	if (fData)
	{
#if !(defined(__SC__) && !FIXED_MPW_BUG)
		delete[] fData;

#else
		// Workaround for SCpp since it has problem with language support routine __vec_delete()
		delete static_cast<void*>(fData);
#endif
		fData = NULL;
		fSize = 0;
		fAllocatedSize = 0;
	}
}

//------------------------------------------------------------------------------------
// Array manipulation primitives
//-------------------------------------------------------------------------------------------


// Takes the CRect_AC you pass it, and pushes it on the stack.

void CRectStack::PushRect(const CRect_AC& theRect)
{
	CWhileSynchronized entry(fLock);

	register long newSize = fSize + 1;
#if qTuneRectStack
	if (fHighWaterMark < newSize)
		fHighWaterMark = newSize;
#endif
	if (newSize >= fAllocatedSize)
		TFracThread::ProgramBreak("\pCRectStack overflow!");
	else
		fData[fSize++] = theRect;
}

//-------------------------------------------------------------------------------------------


// Returns the first CRect_AC on the stack. That CRect_AC is then removed from
// the stack.

bool CRectStack::PopRect(CRect_AC& theRect)
{
	CWhileSynchronized entry(fLock);

	bool result = false;
	if (fSize > 0)
	{
		theRect = fData[--fSize];
		result = true;
	}
	return result;
}

// Test if this array is empty or not.

bool CRectStack::IsEmpty()
{
	CWhileSynchronized entry(fLock);

	return (fSize <= 0);
}

//-------------------------------------------------------------------------------------------
// Input/Output functions
//-------------------------------------------------------------------------------------------


void CRectStack::DoRead(short aRefNum, bool /*forPrinting*/)
{
	DeleteAll();

	long newSize;
	long recSize = sizeof(fSize);
	::ThrowIfError_AC(::FSRead(aRefNum, &recSize, &newSize));
	if (fSize > 0)
	{
#if qTuneRectStack
		if (fHighWaterMark < newSize)
			fHighWaterMark = newSize;
#endif
		if (newSize >= fAllocatedSize)
			TFracThread::ProgramBreak("\pCRectStack overflow!");
		else
		{
			recSize = sizeof(CRect_AC) * newSize;
			::ThrowIfError_AC(::FSRead(aRefNum, &recSize, fData));
			fSize = newSize;
		}
	}
}

//-------------------------------------------------------------------------------------------


void CRectStack::DoWrite(short aRefNum, bool /*makingCopy*/)
{
	long recSize = sizeof(fSize);
	::ThrowIfError_AC(::FSWrite(aRefNum, &recSize, &fSize));
	if (fSize > 0)
	{
		recSize = sizeof(CRect_AC) * fSize;
		::ThrowIfError_AC(::FSWrite(aRefNum, &recSize, fData));
	}
}

//-------------------------------------------------------------------------------------------
//----------------------------------CRectQueue Methods---------------------------------------
//-------------------------------------------------------------------------------------------


// Initialize a new array with numberOfRects rects.

CRectQueue::CRectQueue(long numberOfRects) :
	fSize(0),
	fAllocatedSize(0),
#if qTuneRectStack
	fHighWaterMark(0),
#endif
	fHead(0),
	fTail(0),
	fData(NULL),
	fLock(CTempMutex::kCreate),
	fSpaceAvailable(numberOfRects, numberOfRects)
{
#if !(defined(__SC__) && !FIXED_MPW_BUG)
	fData = TH_new CRect_AC[numberOfRects];
#else
	// Workaround for SCpp which has a problem with array delete[]
	#if qTidyHeap
		fData = static_cast<CRect_AC*>(operator new( sizeof(CRect_AC)*numberOfRects, _FILE_AC, __LINE__ ));
	#else
		fData = static_cast<CRect_AC*>(operator new( sizeof(CRect_AC)*numberOfRects ));
	#endif
#endif

	fAllocatedSize = numberOfRects;
}

//-------------------------------------------------------------------------------------------


// Free the array.

CRectQueue::~CRectQueue()
{
	if (fData)
	{
#if !(defined(__SC__) && !FIXED_MPW_BUG)
		delete[] fData;
#else
		// Work around for SCpp since it has problem with language support routine __vec_delete()
		delete static_cast<void*>(fData);
#endif

		fData = NULL;
		fSize = fHead = fTail = 0;
		fAllocatedSize = 0;
	}
}

//------------------------------------------------------------------------------------
// Array manipulation primitives
//-------------------------------------------------------------------------------------------


// Takes the CRect_AC you pass it, and pushes it on the queue.

void CRectQueue::PushRect(const CRect_AC& theRect)
{
	register long qLen = fSize + 1;
#if qTuneRectStack
	if (fHighWaterMark < qLen)
		fHighWaterMark = qLen;
#endif
	if (qLen > fAllocatedSize)
		TFracThread::ProgramBreak("\pCRectQueue overflow!");
	else
	{
		fSize = qLen;
		fData[fTail] = theRect;
		if (++fTail >= fAllocatedSize)
			fTail = 0;
	}
}

//-------------------------------------------------------------------------------------------


// Wait if the queue is full, then push the CRect_AC into it.

void CRectQueue::PushRectSync(const CRect_AC& theRect)
{
	fSpaceAvailable.Wait(kDurationForever);
	CWhileSynchronized entry(fLock);

	this->PushRect(theRect);
}

//-------------------------------------------------------------------------------------------


// Takes the CRect_AC you pass it, and pushes it on the queue.
// If possible, add the CRect_AC to the last one in the queue.

void CRectQueue::AddRect(const CRect_AC& theRect)
{
	bool skip = false;

	long qLen = fSize;
	if (qLen > 0)
	{
		// Try to consolidate with the last CRect_AC
		CRect_AC* last = (fTail > 0) ? &fData[fTail - 1] : &fData[fAllocatedSize - 1];
		if ((theRect.left == last->left) && (theRect.right == last->right))
		{
			if (theRect.top == last->bottom)
			{
				last->bottom = theRect.bottom;
				skip = true;
			}
			else if (last->top == theRect.bottom)
			{
				last->top = theRect.top;
				skip = true;
			}
		}
		else if ((theRect.top == last->top) && (theRect.bottom == last->bottom))
		{
			if (theRect.left == last->right)
			{
				last->right = theRect.right;
				skip = true;
			}
			else if (last->left == theRect.right)
			{
				last->left = theRect.left;
				skip = true;
			}
		}
	}

	if (!skip)
	{
		// Push a new CRect_AC
		++qLen;
#if qTuneRectStack
		if (fHighWaterMark < qLen)
			fHighWaterMark = qLen;
#endif
		if (qLen > fAllocatedSize)
			TFracThread::ProgramBreak("\pCRectQueue overflow!");
		else
		{
			fSize = qLen;
			fData[fTail] = theRect;
			if (++fTail >= fAllocatedSize)
				fTail = 0;
		}
	}
}

//-------------------------------------------------------------------------------------------


// Wait if the queue is full, then add the CRect_AC into it.

void CRectQueue::AddRectSync(const CRect_AC& theRect)
{
	fSpaceAvailable.Wait(kDurationForever);
	CWhileSynchronized entry(fLock);

	this->AddRect(theRect);
}

//-------------------------------------------------------------------------------------------


// Returns the first CRect_AC on the queue. That CRect_AC is then removed from the queue.

void CRectQueue::PopRect(CRect_AC& theRect)
{
	CWhileSynchronized entry(fLock);

	if (fSize <= 0)
		TFracThread::ProgramBreak("\pCRectQueue underflow!");
	else
	{
		--fSize;
		theRect = fData[fHead];
		if (++fHead >= fAllocatedSize)
			fHead = 0;
	}

	fSpaceAvailable.Signal();  // Clear when empty.
}

//-------------------------------------------------------------------------------------------
// End of URectStack.cpp