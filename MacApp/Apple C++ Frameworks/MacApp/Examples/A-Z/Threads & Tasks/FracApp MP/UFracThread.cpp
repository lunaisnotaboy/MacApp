//----------------------------------------------------------------------------------------
// UFracThread.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		07/23/01	Removing old features. 
		01/02/01	Update copyright.
		02/15/00	Finish debugging MP threads. 
					Use new synchronization classes. 
		02/01/00	Use CPreemptiveThread_AC. 
					Temporarily using CCooperativeThread_AC for debugging. 
					This is interim and will change again soon. 
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef __FRACRECORD__
#include "FracRecord.h"
#endif

#ifndef __ThreadUtilities_AC__
#include "ThreadUtilities_AC.h"
#endif

#ifndef _STDLIB
#include <stdlib.h>
#endif

#include "UFracThread.h"

#ifndef __UENGINE__
#include "UEngine.h"
#endif


TFracThread::TFracThread(CFracAppEngine* theEngine) :
	CPreemptiveThread_AC(),
	fEngine(theEngine)
{
}

TFracThread::~TFracThread()
{
}

void TFracThread::Run()
{
#if qDebugMsg && 0
	ProgramBreak("\pstarting");
#endif
	while (!ShutdownRequested() && !fEngine->CalcCity())
	{
	   Yield();
	}
	CWhileSynchronized(fEngine->fLock);
	if (--fEngine->fActiveThreadCounter == 0)
	{
		fEngine->fDocumentIsFinished = TRUE;
	}
#if qDebugMsg && 0
	if (ShutdownRequested())
		ProgramBreak("\pstopping");
	else
		ProgramBreak("\pfinished");
#endif
}


//----------------------------------------------------------------------------------------
// End of UFracThread.cpp
