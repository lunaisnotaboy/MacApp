//----------------------------------------------------------------------------------------
// UFracViews.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		07/23/01	Removing old features. 
		06/22/01	Remove support for palette animation because it only 
					works on indexed-color displays. 
					Rename kNumColors to kNumOurColors to avoid confusion with
					the toolbox constant. 
					Added zoom to selection command. 
		06/13/01	Call ClearForPutting before putting data in the scrap. 
		02/06/01	Carbon: Use accessors for QD data structures and clipboard. 
					TStaticText now uses CString_AC. 
		01/02/01	Update copyright.
		04/11/00	Can't cast CRGBColor_AC to RGBColor anymore. 
		01/31/00	Replace CExtended with CExtended80. 
		12/08/99	Use MA_DEFINE_CLASS instead of DefineClass.  Replace 
					catch(...) with catch(CException_AC&) in AnimateColors.
		03/24/99	Update copyright notice.
*/

#ifndef __UFRACVIEWS__
#include "UFracViews.h"
#endif

// FracApp

#ifndef __CEXTENDED__
#include "CExtended.h"
#endif

#ifndef __UAREASELECTOR__
#include "UAreaSelector.h"
#endif

#ifndef __FRACAPP__
#include "UFracApp.h"
#endif

#ifndef __UFRACDOC__
#include "UFracDoc.h"
#endif

#ifndef __UFRACGLOBALS__
#include "UFracGlobals.h"
#endif

#ifndef __UFRACVIEWS__
#include "UFracViews.h"
#endif

// MacApp

#ifndef __UCLIPBOARDMGR__
#include "UClipBoardMgr.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UNUMBERTEXT__
#include "UNumberText.h"
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

// ACS

#ifndef __CClipboard_AC__
#include "CClipboard_AC.h"
#endif

// Toolbox

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

#ifndef __FP__
#include <fp.h>
#endif

//-------------------------------------------------------------------------------------------
//---------------------------------TFracAppWindow Methods------------------------------------
//-------------------------------------------------------------------------------------------


// Initialize our window object. Overridden to set our instance variables to NULL.

#undef Inherited
#define Inherited TWindow

MA_DEFINE_CLASS(TFracAppWindow);

TFracAppWindow::TFracAppWindow()
{
	fCTimeLabelView = NULL;
	fCTimeView = NULL;
	fETimeLabelView = NULL;
	fETimeView = NULL;
	fFracAppView = NULL;
	fMethodNameView = NULL;
	fPercentView = NULL;
	fPercentLabelView = NULL;
	fSingleBarView = NULL;
}

//-------------------------------------------------------------------------------------------


/* Initialize a lot of the windows fields with references to its subviews. */

void TFracAppWindow::DoPostCreate(TDocument *itsDocument)
{
	Inherited::DoPostCreate(itsDocument);

	fFracAppView = (TFracAppView*)(FindSubView('FRAC'));
	fCTimeLabelView = (TStaticText*)(FindSubView('tCTL'));
	fCTimeView = (TStaticText*)(FindSubView('tCTm'));
	fETimeLabelView = (TStaticText*)(FindSubView('tETL'));
	fETimeView = (TStaticText*)(FindSubView('tETm'));
	fMethodNameView = (TStaticText*)(FindSubView('tTYP'));
	fPercentView = (TStaticText*)(FindSubView('tPCT'));
	fPercentLabelView = (TStaticText*)(FindSubView('tPCL'));
	fSingleBarView = (TControl*)(FindSubView('sBAR'));
}

//-------------------------------------------------------------------------------------------


/* Handy subroutine that takes a string and a style that it will be imaged with.
  It returns the width of that string in that style, adding in kStaticTextSlop. */

short GetTextWidth(const CStr255_AC& itsText, const TextStyle& itsTextStyle);
short GetTextWidth(const CStr255_AC& itsText, const TextStyle& itsTextStyle)
{
	const short kStaticTextSlop 	= 1;	/* Slop to add in GetTextWidth. The width of our
	TStaticText items canÕt just be the width of the string. We also have to add a 1 pixel
	slop. This is because imaging is done with TextEdit, which inserts a 1 pixel margin
	at the left so that it can put an insertion point there. We have to take this into account
	when sizing our fields. */

	GrafPtr			oldPort;

	::GetPort(&oldPort);
	::SetPort_AC(gWorkPort);
	SetPortTextStyle(itsTextStyle);
	short width = ::StringWidth(itsText) + kStaticTextSlop;
	::SetPort(oldPort);

	return width;
}

//-------------------------------------------------------------------------------------------


/* Called by TFracAppWindow::Show and Resize to make sure the items in the infobar and the
  percentage complete label are all in the right places. */

/* We define this record to keep track of the new locations of our fields. Each
  one needs a newLocation specification, as well as a horizontal size (we never
  change an itemÕs height). We also keep a newEnd field here, which is
  newLocation.h + newSize, for convenience. */

struct NewSpecs
{
	Point	newLocation;
	short	newEnd;
	short	newSize;
};
typedef struct NewSpecs NewSpecs;

// Subroutine that moves and sizes ÒtheViewÓ according to ÒtheSpecsÓ

static void MoveView(TView* theView, const NewSpecs& theSpecs, bool invalidate)
{
	//	theView->Locate(theSpecs.newLocation.h, theSpecs.newLocation.v, invalidate);
	//	theView->Resize(theSpecs.newSize, theView->GetSize().v, invalidate);
	CViewRect frame(theSpecs.newLocation.h, theSpecs.newLocation.v,
				theSpecs.newLocation.h + theSpecs.newSize, theSpecs.newLocation.v + theView->GetSize().v);
	theView->SetFrame(frame, invalidate);
}

void TFracAppWindow::AdjustInfoBar(ViewCoordinate width, ViewCoordinate height,
								   bool invalidate)
{
	const short kInfoBarMargin		= 5;		// Margin to use on the left and right sides of the infobar.
	const short kLabelMargin		= 5;		// Margin to use between a time display and its label.
	const short kMinimumSpacing 	= 15;		// Minimum space to maintain between fields.
	const short kTimeSlop			= 0;		// Slop to add to time elements.

	/* We donÕt want to do anything if none of our subviews exists yet. It is
	  possible for this routine to get called before the window is completely
	  built, in which case our subviews might not be created yet. Check to see if
	  they exists, and exit if they donÕt. */

	if (fCTimeLabelView == NULL)
		return;

	/* Do the leftmost item. This is the fields that says ÒCalculation Time:
	  xx/xx/xxÓ. It is in two parts: a TStaticText for the ÒCalculation Time: Ó
	  (the label) and another for the time itself. The label is positioned
	  kInfoBarMargin pixels from the left. The time field is positioned
	  kLabelMargin pixels past the label. */

	CStr255_AC itsText = fCTimeLabelView->GetText();
	TextStyle itsStyle = fCTimeLabelView->fTextStyle;

	NewSpecs specCTimeLabel;
	specCTimeLabel.newSize = GetTextWidth(itsText, itsStyle) + kLabelMargin;
	specCTimeLabel.newLocation.h = kInfoBarMargin;
	specCTimeLabel.newLocation.v = short(fCTimeLabelView->GetLocation().v);
	specCTimeLabel.newEnd = specCTimeLabel.newLocation.h + specCTimeLabel.newSize;

	itsText = gMaxWidthTimeString;
	itsStyle = fCTimeView->fTextStyle;

	NewSpecs specCTime;
	specCTime.newSize = GetTextWidth(itsText, itsStyle) + kTimeSlop;
	specCTime.newLocation.h = specCTimeLabel.newEnd;
	specCTime.newLocation.v = short(fCTimeView->GetLocation().v);
	specCTime.newEnd = specCTime.newLocation.h + specCTime.newSize;

	/* Do the rightmost item. This is the fields that says ÒElapsed Time: xx/xx/xxÓ.
	  It is in two parts: a TStaticText for the ÒElapsed Time: Ó (the label) and
	  another for the time itself.The time field is positioned kInfoBarMargin
	  pixels from the right edge of the window. The label is positioned
	  kLabelMargin pixels to the right of the time field. */

	NewSpecs specETime;
	specETime.newSize = specCTime.newSize;
	specETime.newEnd = short(width - kInfoBarMargin);
	specETime.newLocation.h = specETime.newEnd - specETime.newSize;
	specETime.newLocation.v = short(fETimeView->GetLocation().v);

	itsText = fETimeLabelView->GetText();
	itsStyle = fETimeLabelView->fTextStyle;

	NewSpecs specETimeLabel;
	specETimeLabel.newSize = GetTextWidth(itsText, itsStyle) + kLabelMargin;
	specETimeLabel.newEnd = specETime.newLocation.h;
	specETimeLabel.newLocation.h = specETimeLabel.newEnd - specETimeLabel.newSize;
	specETimeLabel.newLocation.v = short(fETimeLabelView->GetLocation().v);

	/* Center the middle item. This is the TStaticText item that holds the string
	  displaying what algorithms we are using. Its position is determined by
	  centering it between the  left and right edges of the window. */

	itsText = fMethodNameView->GetText();
	itsStyle = fMethodNameView->fTextStyle;

	NewSpecs specMethodName;
	specMethodName.newSize = GetTextWidth(itsText, itsStyle);
	specMethodName.newLocation.h = short((width - specMethodName.newSize) / 2);
	specMethodName.newLocation.v = short(fMethodNameView->GetLocation().v);
	specMethodName.newEnd = specMethodName.newLocation.h + specMethodName.newSize;

	/* Make sure we maintain minimum spacing. Examine the locations of the three
	  items weÕve just calculated. See if they are all at least kMinimumSpacing
	  pixels from each other. If not, then shift everything over to the right to
	  maintain this spacing. Note that this means that the Elapsed time field can
	  get shoved off the right edge of the window if the window is too small. */

	specMethodName.newLocation.h = short(Max_AC(specMethodName.newLocation.h,
											 specCTime.newEnd + kMinimumSpacing));
	specETimeLabel.newLocation.h = short(Max_AC(specETimeLabel.newLocation.h,
											 specMethodName.newLocation.h +
											 specMethodName.newSize + kMinimumSpacing));
	specETime.newLocation.h = specETimeLabel.newLocation.h + specETimeLabel.newSize;

	/* Do the percent complete item at the bottom. This guy is centered between the
	  left edge of the window, and the right edge of the bottom scrollbar. Note
	  that this is the only item here that I move around vertically as well. Moving
	  the Percent Complete item also means having to move the little line used to
	  seperate it from the fractal view above it. */

	TScrollBar*	bottomScrollBar = fFracAppView->GetScroller(false)->fScrollBars[hSel];
	short rightEdge = short(bottomScrollBar->GetLocation().h);
	short topEdge = short(height - bottomScrollBar->GetSize().v);

	NewSpecs specSingleBar;
	specSingleBar.newSize = rightEdge;
	specSingleBar.newLocation.h = 0;
	specSingleBar.newLocation.v = topEdge + 1;

	itsText = fPercentLabelView->GetText();
	itsStyle = fPercentLabelView->fTextStyle;

	NewSpecs specPercentLabel;
	specPercentLabel.newSize = GetTextWidth(itsText, itsStyle);

	itsText = "000";
	itsStyle = fPercentView->fTextStyle;

	NewSpecs specPercent;
	specPercent.newSize = GetTextWidth(itsText, itsStyle);
	specPercent.newLocation.h = (rightEdge - specPercent.newSize - specPercentLabel.newSize) / 2;
	specPercent.newLocation.v = topEdge + 2;
	specPercent.newEnd = specPercent.newLocation.h + specPercent.newSize;

	specPercentLabel.newLocation.h = specPercent.newEnd;
	specPercentLabel.newLocation.v = topEdge + 2;

	//--- Move them all into position ---

	MoveView(fCTimeLabelView, specCTimeLabel, invalidate);
	MoveView(fCTimeView, specCTime, invalidate);
	MoveView(fETimeLabelView, specETimeLabel, invalidate);
	MoveView(fETimeView, specETime, invalidate);
	MoveView(fMethodNameView, specMethodName, invalidate);
	MoveView(fPercentLabelView, specPercentLabel, invalidate);
	MoveView(fPercentView, specPercent, invalidate);
	MoveView(fSingleBarView, specSingleBar, invalidate);
}

//-------------------------------------------------------------------------------------------


/* Called by MacApp when it needs to open a window. We override it here so that we can also
  call AdjustInfoBar. */

void TFracAppWindow::Open()
{
	AdjustInfoBar(GetSize().h, GetSize().v, kDontInvalidate);
	Inherited::Open();
}

//-------------------------------------------------------------------------------------------


/* Called by MacApp when it needs to resize a window. We override it here so that we can also
  call AdjustInfoBar. */

void TFracAppWindow::SetFrame(const CViewRect& newFrame, bool invalidate)
{
	Inherited::SetFrame(newFrame, invalidate);
	AdjustInfoBar(GetSize().h, GetSize().v, invalidate);
}


//-------------------------------------------------------------------------------------------
//-------------------------------TNoFlashStaticText Methods----------------------------------
//-------------------------------------------------------------------------------------------
/* This object is used to display the elapsed time items, and the percentage complete item. I
  found that with a normal TStaticText item, I got too much flashing when I updated the
  strings. There was too much of a time gap between when the old string got erased, and the
  new one got drawn. IÕve tried to minimize that by having MATextbox (which is what
  ultimately draws the string) erase the old text when it draws the new. There is still SOME
  flicker, but not as much as there used to be. */
//-------------------------------------------------------------------------------------------


/* Called by TStaticText in its Draw method to do the actual imaging of text. Overridden so
  that it passes the kEraseText parameter to MATextbox. */

#undef Inherited
#define Inherited TStaticText

MA_DEFINE_CLASS(TNoFlashStaticText);

TNoFlashStaticText::TNoFlashStaticText()
{
	// fEraseFirst = kNoEraseFirst;
}

//-------------------------------------------------------------------------------------------


/* This method is called to set the text that the TStaticText item displays. It draws the
  text immediately, without invalidating the screen and simply responding to the update
  event. In doing this, it calls EraseRect, and then calls Draw. Overridden to inhibit
  erasing the old text before drawing the new, as we now do that in ImageText. */

void TNoFlashStaticText::SetText(const CString_AC& theText, bool redraw)
{
	fString = theText;
	if (IsDrawable())
	{
		if (redraw)
			DrawContents();
		else
			Invalidate(ControlQDArea());
	}
}

//-------------------------------------------------------------------------------------------
//----------------------------------TFracAppView Methods-------------------------------------
//-------------------------------------------------------------------------------------------
/* This is the object that displays the fractal. Besides having its .Draw method overridden
  so that it can copybits the offscreen image, this View also keeps track of the current
  selection rectangle. Because of this, it also handles the menu items that would only be
  enabled when there is a selection. This includes Copy, New From Selection, and New
  Multi-Page. */
//-------------------------------------------------------------------------------------------


/* Init our FracAppView. This sets the current selection to an empty rect. */

#undef Inherited
#define Inherited TView

MA_DEFINE_CLASS(TFracAppView);

TFracAppView::TFracAppView()
{
	fSelectionRect = gZeroRect;
	fFracAppDocument = NULL;
}

//-------------------------------------------------------------------------------------------


/* Init our FracAppView. This keeps a reference to our owning document. This is so we can
  call some methods in that document that return information about the picture we have to
  display. This reference is kept in addition to the fDocument field that TViews already
  have. Our own reference is stored as a TFracAppDocument, and not just a plain TDocument.
  This is because we need a reference to a TFracAppDocument in order to access the methods
  that it has that a normal TDocument doesnÕt. We could just coerce fDocument into a
  TFracAppDocument whenever we accessed it, but thatÕs a pain, and this is inexpensive. */

void TFracAppView::DoPostCreate(TDocument* itsDocument)
{
	fFracAppDocument = (TFracAppDocument*)(itsDocument);

	Inherited::DoPostCreate(itsDocument);
}

//-------------------------------------------------------------------------------------------


/* Called by MacAppÕs updating routines to highlight the current selection rectangle if there
  is one. This is drawn in srcCopy mode to make it stand out better when it is a final
  selection.  XOR is used for the rubberband, until mouseUp. */

void TFracAppView::DoHighlightSelection(HLState fromHL, HLState toHL)
{
	if (HasSelection())
	{		
		CRect_AC tempRect;
		GetSelection(tempRect);
		if ((fromHL == hlOff) && (toHL == hlOn))
		{

			PatHandle selPatHandle = ::GetPattern(kSelPattern); // get the pattern we use.
			if (selPatHandle)
			{
				// If pattern available, use it.
				Pattern thePat = **selPatHandle;
				::PenPat(&thePat); 		// set pen pattern to our selection kind.
			}
			::PenMode(srcCopy);			// copy mode on pattern selection.
			::FrameRect(tempRect);		// outline the frame of selection.
		} 								// highlight turned on.
		else if ((fromHL == hlOn) && (toHL == hlOff))
		{
			/* Turning off the highlight. We need to remove the traces of the selection.
			  To do this, redraw that rectangle. */
			CViewRect area;
			area = QDToView(tempRect);
			SetSelection(gZeroRect, kDontRedraw);
			Draw(area);			// Redraw it to clear selection.
			SetSelection(tempRect, kDontRedraw);
		}
	}
}

//-------------------------------------------------------------------------------------------


/* Called by MacApp when a menu item has been chosen. Handle the menu choices for ÒNew From
  SelectionÓ and ÒNew MultiPageÉÓ out of the File Menu. These make new Fractals based on the
  current selection. It does it by calling on the application object to make a new document.
  The communication to the DoInitialState is through the global variable gPageRecord */

void TFracAppView::DoMenuCommand(CommandNumber aCommandNumber)
{
	switch (aCommandNumber)
	{
		case cCopy:
			gClipboardMgr->ClearForPutting();
			WriteToDeskScrap();
			gClipboardMgr->CheckDeskScrap();		// Force MacApp to notice the change
			break;

		case cSelectAll:
			{
				CRect_AC qdExtent(GetQDExtent());
				SetSelection(qdExtent, kRedraw);
			}
			break;

		case cNewFromSelection:
			fFracAppDocument->StashSelectedRange();
			gApplication->OpenNew(cNewFromSelection);
			break;

		default:
			Inherited::DoMenuCommand(aCommandNumber);		// next guy in chain.

	}										// switch on aCommandNumber
	/* Assume that we have no command to return, since none of our commands currently
	  change the document. */
}

//-------------------------------------------------------------------------------------------


/* Called by MacApp to handle the mouse events in the view. This will pass back the command
  object to handle tracking the mouse and creating a new selection in preparation for making
  a new fractal. */

void TFracAppView::DoMouseCommand(CViewPoint& theMouse, TToolboxEvent* /*event*/,
										 CPoint_AC /*hysteresis*/)
{
	TAreaSelector* tracker = TH_new TAreaSelector(this, fFracAppDocument, theMouse);
													// make a new command object.
	::ThrowIfNULL_AC(tracker);						// no memory, trash out.
	PostCommand(tracker);						// post it for later execution.
}

//-------------------------------------------------------------------------------------------


/* Called by MacApp when the user clicks on the menu. Set up the New Fractal menus choice in
  Fractal Menu, based on selection. */

void TFracAppView::DoSetupMenus()
{
	Inherited::DoSetupMenus(); 					// Do mainline stuff first.

	/* If we have a non-zero selection, we can enable the menu item to use it as the
	  new fractal dimensions for this document. */

	bool hasSelection = HasSelection();
	Enable(cCopy, hasSelection);
	Enable(cSelectAll, true);
	Enable(cNewFromSelection, hasSelection);
	//Enable(cZoomToSelection, hasSelection);
}

//-------------------------------------------------------------------------------------------


/* Called by MacApp to draw the view seen in the window. Every nonblank view MUST override
  this method. This is the display routine to take the data out of the offscreen buffer and
  whip it up to the window, as the current view. The fractal is full page size, clips
  without scaling into the window. */

void TFracAppView::Draw(const CViewRect& area)
{
	/* Lock down our bits so that they donÕt move when we try to copy them to the
	  screen. */

	fFracAppDocument->LockThePixels(kLock);

	/* Set the fore and background colors. If we just leave them set to any old
	  values, Copybits will attempt to ÒcolorizeÓ the bitmap that we transfer. See
	  technote #163 for the gory details. */

	::RGBForeColor(gRGBBlack);
	::RGBBackColor(gRGBWhite);

	// Copy the bits to the screen, allowing CopyBits to sort out the colors.

	CRect_AC qdArea;
	qdArea = ViewToQD(area);
#if qCarbon
	::CopyBits(GetPortBitMapForCopyBits(fFracAppDocument->GetFracPort()),
			   GetPortBitMapForCopyBits(GetGrafPtr_AC()),
			   qdArea, qdArea, srcCopy, NULL);
#else
	::CopyBits(&GrafPtr(fFracAppDocument->GetFracPort())->portBits,
			   &(qd.thePort->portBits),
			   qdArea, qdArea, srcCopy, NULL);
#endif

	// WeÕre done with the pixels, so let Ôem float.
	fFracAppDocument->LockThePixels(kUnlock);

	if (HasSelection())
		DoHighlightSelection(hlOff, hlOn);
}

//-------------------------------------------------------------------------------------------


/* Overridden so that we can redefine the extent of the view when pasting to the scrap. One
  of the things that GetQDExtent is used for is by TView.WriteToDeskScrap. When this method
  is called, it is so that it will image the view into a PICT, and then put this PICT on the
  desk scrap. GetQDExtent is called to find out the boundaries of this PICT. We special case
  GetQDExtent here for when we are drawing to that PICT. We know this by the setting of the
  global variable, gDrawingPICTScrap. In that case, we only want to draw the current
  selection to the scrap. So we just return the fSelectionRect. */

// ¥¥¥  this function is no longer overrideable, revisit.

//void TFracAppView::GetQDExtent(CRect_AC& qdExtent)
//{
//	if (! gDrawingPictScrap) {
//		Inherited::GetQDExtent(qdExtent);
//	} else {
//		CRect_AC aRect;
//		GetSelection(aRect);
//		qdExtent = aRect;
//	}
//}

//-------------------------------------------------------------------------------------------


/* Sets and redraws the selection. Redraws the selection only if the redraw parameter is
  true, we can focus (which just means that we have a port to draw into), and if any part of
  our view is visible. If any of those assertions are false, then we just remember the
  selection in fSelectionRect. */

void TFracAppView::SetSelection(const CRect_AC& theSelectionRect, bool redraw)
{
	if (redraw && Focus() && IsVisible())
	{
		DoHighlightSelection(hlOn, hlOff);
		fSelectionRect = theSelectionRect;
		DoHighlightSelection(hlOff, hlOn);
	}
	else
		fSelectionRect = theSelectionRect;
}

//----------------------------------------------------------------------------------------
// End of UFracViews.cpp
