//----------------------------------------------------------------------------------------
// UMLApplication.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		06/05/01	Added floating window language controller and a DoInitialState
					to start up the floating window and a DoEvent to handle language
					changes.
		01/02/01	Update copyright.
		07/13/00	Stripped out MA_DEFINE_CLASS of TMLApplication.
		12/08/99	Fixed file name in banner.  Take out MA_DEFINE_CLASS of TMLApplication.
		03/24/99	Update copyright notice.
*/

// MultiLocal

#ifndef __UMLApplication__
#include "UMLApplication.h"
#endif

// MacApp

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

//----------------------------------------------------------------------------------------
// Constants:

enum
{
	cFloatingLanguageWindow = 1102
};

//========================================================================================
// CLASS TMLApplication
//========================================================================================

//----------------------------------------------------------------------------------------
// TMLApplication::DoMakeDocument
//----------------------------------------------------------------------------------------

TDocument* TMLApplication::DoMakeDocument(CommandNumber itsCommandNumber, TFile* itsFile)
{
	#pragma unused (itsCommandNumber, itsFile)
	TDocument*	newDocument = TH_new TDocument;

	return newDocument;
}

//----------------------------------------------------------------------------------------
// TMLApplication::DoInitialState
//----------------------------------------------------------------------------------------

void TMLApplication::DoInitialState()
{
	TApplication::DoInitialState();

	if (fLanguageWindow == NULL && CMultiLocale_AC::Initialized())
	{
		TWindow* aWindow = MakeLanguageWindow();
		aWindow->Open();
	}
	
}

//----------------------------------------------------------------------------------------
// TMLApplication::DoEvent
//----------------------------------------------------------------------------------------

void TMLApplication::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event)
{
	if (eventNumber == mPopupHit)
	{
		TPopup* aPopup = dynamic_cast_or_throw_AC(TPopup*, source);
		CMultiLocale_AC::SetDefaultRegionCode(fRegionTable[aPopup->GetCurrentItem() - 1]);
	}
	else
		TApplication::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TMLApplication::MakeLanguageWindow
//----------------------------------------------------------------------------------------

TWindow* TMLApplication::MakeLanguageWindow()
{
	TWindow* aWindow = gViewServer->NewTemplateWindow(cFloatingLanguageWindow, NULL);
	::ThrowIfNULL_AC(aWindow);

	TPopup* aPopup = dynamic_cast_or_throw_AC(TPopup*, aWindow->FindSubView('LPop'));
	aPopup->CreateMenu();

	RegionCode	currentRegion = CMultiLocale_AC::RunTimeRegionCode(CMultiLocale_AC::GetDefaultRegionCode());
	short		regionItem = 1;
	short		localeCount = 1;
	const CMultiLocale_AC::CLocaleList&	locales(CMultiLocale_AC::GetLocaleList());

	// We just build the popup here as we encounter each locale in the locale list but
	// you could sort it by locale name, region code, language code, script code,
	// whatever.

	for (CMultiLocale_AC::CLocaleList::const_iterator aLocale = locales.begin();
		 aLocale != locales.end();
		 ++aLocale, ++localeCount)
	{
		// Add the popup menu item.
		aPopup->AddItem((*aLocale)->GetLocaleName());
		
		// Build up the popup to region code translation table.
		RegionCode	localRegion = (*aLocale)->GetRegionCode();
		fRegionTable.push_back(localRegion);

		// Remember which popup item should be selected.
		if (localRegion == currentRegion)
			regionItem = localeCount;
	}

	// Select the current region.
	aPopup->SetCurrentItem(regionItem, kRedraw);
	
	return aWindow;
}

//----------------------------------------------------------------------------------------
// End of UMLApplication.cp

