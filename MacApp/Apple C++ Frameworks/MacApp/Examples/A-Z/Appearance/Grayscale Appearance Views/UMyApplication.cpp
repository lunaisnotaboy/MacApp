//--------------------------------------------------------------------------------------------------
// UMyApplication.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright © 1997 by Trygve Isaacson.
//--------------------------------------------------------------------------------------------------


/*
	Change History
		03/04/01	Clean up string casting. 
		01/19/01	Use CString_AC.
		01/02/01	Update copyright.
		11/04/00	Don't use CDialog_AC. 
		06/23/00	Removed GetRegionCode call.
		12/08/99	Fixed file name in banner.  Include UMenuMgr.h, UEditText.h,
					UViewServer.h and UMemory.h.
		11/04/99	Add GetDialogWindow() to type cast call into GetWRefCon.
		03/24/99	Update copyright notice.
*/

#ifndef __UMyApplication__
#include "UMyApplication.h"
#endif

#ifndef __UMYDOCUMENT__
#include "UMyDocument.h"
#endif

#ifndef __MYCONSTANTS__
#include "MyConstants.h"
#endif

#ifndef __CDialog_AC__
#include "CDialog_AC.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UEDITTEXT__
#include "UEditText.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

// ACS

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

//--------------------------------------------------------------------------------------------------
// TMyApplication
//--------------------------------------------------------------------------------------------------

#undef Inherited
#define Inherited TApplication

TMyApplication::TMyApplication() :
	TApplication(kFileType, kSignature)
{
}

//--------------------------------------------------------------------------------------------------
// TMyApplication
//--------------------------------------------------------------------------------------------------

TMyApplication::~TMyApplication()
{
}

//--------------------------------------------------------------------------------------------------
// TMyApplication
//--------------------------------------------------------------------------------------------------

TDocument* TMyApplication::DoMakeDocument(CommandNumber itsCommandNumber, TFile* itsFile)
{
	return TH_new TMyDocument(itsFile, itsCommandNumber == cNewEmulated);
}


//--------------------------------------------------------------------------------------------------
// TMyApplication
//--------------------------------------------------------------------------------------------------

void TMyApplication::DoSetupMenus()
{
	Inherited::DoSetupMenus();
	
	Enable(cNewEmulated, true); // See note in DoMenuCommand.
	
	Enable(kMADlgMenuCmdBase + phAboutApp, true);
	Enable(kMADlgMenuCmdBase + phRevert, true);
	Enable(kMADlgMenuCmdBase + phSaveChanges, true);
	Enable(kMADlgMenuCmdBase + phNewPublisherAlert, true);
	Enable(kMADlgMenuCmdBase + phMultPublisherWrn, true);
	Enable(kMADlgMenuCmdBase + phSavingMultPublisherWrn, true);
	Enable(kMADlgMenuCmdBase + phFileChanged, true);
	Enable(kMADlgMenuCmdBase + phPurgeOld, true);
	Enable(kMADlgMenuCmdBase + phInvalidValue, true);
}

//--------------------------------------------------------------------------------------------------
// TMyApplication
//--------------------------------------------------------------------------------------------------

void TMyApplication::DoMenuCommand(CommandNumber aCommand)
{
	// Note: we do not need to handle to cNewEmulated here because it's cNew + 1;
	// MacApp will automatically interpret it as a "new document" command.

	if (aCommand == kMADlgMenuCmdBase + phAboutApp)
		this->DoStdMAAboutBox();
	else if (aCommand > kMADlgMenuCmdBase)
	{
		::ParamText("\pParam1", "\pParam2", "\pParam3", "\pParam4");
		(void) MacAppAlert(aCommand - kMADlgMenuCmdBase, NULL);
	}
	else
		Inherited::DoMenuCommand(aCommand);
}

//--------------------------------------------------------------------------------------------------
// TMyApplication
//--------------------------------------------------------------------------------------------------

void TMyApplication::LaunchGridViewExample()
{
	const OSType gridViewAppSignature = 'SSgv';
	ProcessSerialNumber psn;
							
	::ThrowIfOSErr_AC(::LaunchBySignature(gridViewAppSignature, psn, NULL, NULL, true, launchContinue));
}

//--------------------------------------------------------------------------------------------------
// TMyApplication
//--------------------------------------------------------------------------------------------------

void TMyApplication::DoAboutBox()
{
	TWindow*		aWindow;

	::ThrowIfNULL_AC(aWindow = gViewServer->NewTemplateWindow(kAboutBoxViewID, NULL));
	
	(void) aWindow->PoseModally();
	
	aWindow->Close();
	delete aWindow;
}

//--------------------------------------------------------------------------------------------------
//
// To demonstrate the use of a more complex filter, I have swiped the
// method and filter for the MacApp scrolling credits about box,
// and tweaked the filter to comply with the AGA Dialog Manager
// needs.
//
// Changes to the filter (marked with ! n !).
//
// 1. Get the AGA dialog object pointer from the dialog refcon.
// 2 & 3. Use the AGA method call, rather than the raw Dialog Mgr call,
//	to install the new text.
//--------------------------------------------------------------------------------------------------

extern bool hadCreditsStringList;		// does the rsrc 'STR#' == kDefaultCredits exist ?
extern short lastCreditsStringIndex;		// the last CPascalStr_AC in the STR# to be displayed
extern long lastCreditsShownTicks;			// the tickcount when the last Credit was Shown
extern CPascalStrHandle_AC originalText;			// the about box's original text (prior to credits)
extern short waitTicks;					// how long to wait between credits 

static pascal Boolean DoShowAboutAppFilter(DialogRef theDialog,
										   EventRecord* theEvent,
										   short* itemHit);

void TMyApplication::DoStdMAAboutBox()
{
	FailSpaceIsLow();
	::ThrowIfOSErr_AC(MAInteractWithUser());

	ParamText(CStr255_AC(GetApplicationName()),	// Put Application name in the about box 
			  gEmptyString, gEmptyString, gEmptyString);

	if (CMultiLocale_AC::GetResource('STR#', kDefaultCredits))
	{
		lastCreditsStringIndex = 1;
		lastCreditsShownTicks = TickCount();
		waitTicks = 5 * 60;
		originalText = (CPascalStrHandle_AC)NewString(gEmptyString);
		::ThrowIfNULL_AC(originalText);
		MacAppAlert(phAboutApp, DoShowAboutAppFilter);
		originalText = (CPascalStrHandle_AC)::DisposeIfHandle_AC((Handle)originalText);
	}
	else
		StdAlert(phAboutApp);
}

#undef Inherited

//----------------------------------------------------------------------------------------
// DoShowAboutAppFilter: 
//----------------------------------------------------------------------------------------


pascal Boolean DoShowAboutAppFilter(DialogRef theDialog,
									EventRecord* theEvent,
									short* itemHit)
{
	//••• This whole method needs to be reworked for int't character support
	CStr255_AC originalStr;
	Handle item;
	bool returnValue = false;
	short itemType;
	CRect_AC box;

////	CDialog_AC*	theDialogObj = (CDialog_AC*) ::GetWRefCon(GetDialogWindow(theDialog));	// ! 1 !

	switch (theEvent->what)
	{
		case keyDown:
			switch (static_cast<unsigned char>(theEvent->message & charCodeMask))
			{
				case chEnter:
				case chReturn:
					DoAlertKeyDown(theDialog, ok);
					break;
			}
			break;

		case nullEvent:
			if ((TickCount() - lastCreditsShownTicks) > waitTicks)
			{
				short itemNo = 1;

				do
				{
					item = NULL;
					GetDialogItem(theDialog, itemNo, &itemType, &item, box);
					if (((itemType) & 0x7F) == statText)// we don't care if its enabled or not 
						break;
					else
						++itemNo;
				} while (item);

				CStr255_AC s(kDefaultCredits, lastCreditsStringIndex);

				if (!s.IsEmpty())
				{
					// save the original text 
					if ((lastCreditsStringIndex == 1) && ((*originalText)->IsEmpty() && item))
					{
						GetDialogItemText(item, originalStr);
						SetString((StringHandle)originalText, originalStr);
					}
					++lastCreditsStringIndex;
					lastCreditsShownTicks = TickCount();
					if (item)
						SetDialogItemText(item, s);
						//theDialogObj->SetDialogItemText(item, s);	// ! 2 !
					waitTicks = Min_AC(static_cast<short>(s.Length() * 6), 60);
				}
				else							// no more items 
					{
						lastCreditsStringIndex = 1;
						lastCreditsShownTicks = TickCount();
						if (item)
						{
							originalStr = **originalText;
							SetDialogItemText(item, originalStr);
							//theDialogObj->SetDialogItemText(item, originalStr);	// ! 3 !
						}
						waitTicks = 6 * 60;
					}
			}
			break;
	}

	// Forward on to the standard filter 
	if (gMacAppAlertFilter)
		returnValue = gMacAppAlertFilter(theDialog, theEvent, itemHit);

	return returnValue;
}