//--------------------------------------------------------------------------------------------------
// UMyDocument.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//--------------------------------------------------------------------------------------------------


/*
	Change History
		06/04/01	Set up tabs-in-tabs test in SetupExampleDialog.
		01/19/01	Use CString_AC.
		01/02/01	Update copyright.
		12/12/00	Changed a bunch of dynamic_cast_AC to dynamic_cast_or_throw_AC
					for safety.  Did some cleanup.  Added a case in DoEvent to
					handle the hide/show checkbox in the Locations tab.  Set
					window target after panels are installed.
		09/27/00	Delay installation of tab panels until they are needed. 
		12/08/99	Corrected file name in banner.  Include UCheckbox.h, UStaticText.h,
					UMenuMgr.h, UScrollBar.h, UNumberText.h and URadio.h.
		03/24/99	Update copyright notice.
*/

#ifndef __UMYDOCUMENT__
#include "UMyDocument.h"
#endif

#ifndef __MYCONSTANTS__
#include "MyConstants.h"
#endif

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __CDialog_AC__
#include "CDialog_AC.h"
#endif

#ifndef __UBEVELEDTARGETBORDERVIEW__
#include "UBeveledTargetBorderView.h"
#endif

#ifndef __UBACKGROUNDADORNER__
#include "UBackgroundAdorner.h"
#endif

#ifndef __UDISCLOSUREBEHAVIOR__
#include "UDisclosureBehavior.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UPICTURE__
#include "UPicture.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UBUTTON__
#include "UButton.h"
#endif

#ifndef __UPROGRESSINDICATOR__
#include "UProgressIndicator.h"
#endif

#ifndef __UTABBEDVIEW__
#include "UTabbedView.h"
#endif

#ifndef __UCHECKBOX__
#include "UCheckbox.h"
#endif

#ifndef __USTATICTEXT__
#include "UStaticText.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __USCROLLBAR__
#include "UScrollBar.h"
#endif

#ifndef __UNUMBERTEXT__
#include "UNumberText.h"
#endif

#ifndef __URADIO__
#include "URadio.h"
#endif

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// Compatibility Hacks

#if UNIVERSAL_INTERFACES_VERSION < 0x0300
enum {
	kControlCheckBoxMixedValue	= kControlCheckboxMixedValue
};
#endif // UNIVERSAL_INTERFACES_VERSION < 0x0300

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

TMyDocument::TMyDocument(TFile* itsFile, bool emulateControls)
	:	TFileBasedDocument(itsFile),
		fEmulateControls(emulateControls),
		// Init the pointers & stuff used during idling.
		fProgressIndicator2(NULL),
		fMainWindow(NULL)
{
	this->SetIdleFreq(2);
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

TMyDocument::~TMyDocument()
{
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::DoMakeViews(bool forPrinting)
{
	#pragma unused (forPrinting)
	if (fEmulateControls != EmulateControls_AC())
		SetEmulateControls_AC(!EmulateControls_AC());
		
	// Create our main window.
	this->SwapMainWindow();
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::SwapMainWindow()
{
	// Close existing window and toggle flags if window exists.
	
	if (fMainWindow != NULL)
	{
		fMainWindow->Close();
		delete fMainWindow;
		
		fEmulateControls = !fEmulateControls;
		SetEmulateControls_AC(fEmulateControls);
	}

	// Create our main window.
	
	::ThrowIfNULL_AC(fMainWindow = gViewServer->NewTemplateWindow(kMainWindowViewID, this));
	
	// Set the checkboxes that show/control the GC global flags.

	TCheckBox*	aCheckBox;
	
	aCheckBox = dynamic_cast_or_throw_AC(TCheckBox*,fMainWindow->FindSubView('StdX'));
	aCheckBox->SetState(EmulateControls_AC(), kDontRedraw);	// not yet visible so don't redraw yet

	CString_AC versionString("not available");
	long version = AppearanceMgrVersion_AC();
	if (version != 0)
	{
		if (version & 0x00F != 0) // if there is a minor rev
			stringprintf(versionString, "%d.%d.%d",
						 (version & 0xF00) >> 8, (version & 0x0F0) >> 4, (version & 0x00F));
		else
			stringprintf(versionString, "%d.%d", (version & 0xF00) >> 8, (version & 0x0F0) >> 4);
	}

	TStaticText* versionText = dynamic_cast_or_throw_AC(TStaticText*, fMainWindow->FindSubView('vers'));	
	versionText->SetText(versionString, kDontRedraw);	

	// Allow the window to be resized, but no smaller than
	// its initial size.
	CPoint_AC	maxWindowSize(kMaxCoord, kMaxCoord);
	CRect_AC	windowFrame(fMainWindow->GetQDExtent());
	CPoint_AC	minWindowSize(windowFrame[botRight] - windowFrame[topLeft]);

	fMainWindow->SetResizeLimits(minWindowSize, maxWindowSize);

	fMainWindow->Open();
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::DoSetupMenus()
{
	TFileBasedDocument::DoSetupMenus();
	
	// Enable all of the Test menu commands.
	for (UInt32 i = 0; i < kNumDialogs; ++i)
		Enable(kMyCommandBase + i, true);
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::DoMenuCommand(CommandNumber aCommand)
{
	// Handle the Test menu commands.

	if ((aCommand - kMyCommandBase >= 0) &&
		(aCommand - kMyCommandBase < kNumDialogs))
		this->PoseExampleDialog(aCommand - kMyCommandBase);
	else
		TFileBasedDocument::DoMenuCommand(aCommand);
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------
void TMyDocument::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event)
{
	IDType		sourceID = source->GetIdentifier();
	UInt32		buttonDialogIndex = sourceID;	// main window buttons are ID'd as kMyViewBase + dialogIndex

	if ((buttonDialogIndex >= kMyViewBase) && (buttonDialogIndex < (kMyViewBase + kNumDialogs)))
		this->PoseExampleDialog(buttonDialogIndex - kMyViewBase);
	else
	{
		switch (sourceID)
		{
			case 'StdX':
				{
					PostCommand(TH_new TToggleEmulationCommand(this));
				}
				break;
			
			case 'ENAB':
				{
					// Enable or disable everything in the button's dialog.

					TCheckBox*	aCheckBox = dynamic_cast_or_throw_AC(TCheckBox*,source);
					TWindow*	aWindow = aCheckBox->GetWindow();
					
					this->EnableDisableDialog(fCurrentDialogIndex, aWindow, aCheckBox->IsOn());
				}
				break;

			case 'SBAR':
				{
					// The scroll bar dialog's TScrollBar was hit.
					// Update the text that displays the TScrollBar value.

					TScrollBar*		aScrollBar = dynamic_cast_or_throw_AC(TScrollBar*,source);
					TWindow*		aWindow = aScrollBar->GetWindow();
					TStaticText*	valueText = dynamic_cast_or_throw_AC(TStaticText*,aWindow->FindSubView('SBTX'));
					SInt32			scrollBarValue = aScrollBar->GetValue();
					CString_AC		valueString;
					
					stringprintf(valueString, "%d", scrollBarValue);
					valueText->SetText(valueString, kRedraw);
				}
				break;

			case 'LIVE':
			case 'PROP':
				{
					// The scroll bar dialog had one of its checkboxes hit.
					// Toggle the appropriate attribute of the 3 scroll bars
					// in the dialog.
#if 0 	// This snippet is no longer used, since native Appearance controls determine these properties
		// at construction time (in DoMakeControl), rather than at runtime (here).
					if (EmulateControls_AC())
					{
						TScrollerScrollBarProportional*	aScrollerScrollBar;
						TWindow*	aWindow = dynamic_cast_or_throw_AC(TCheckBox*,source)->GetWindow();
						TCheckBox*	liveCheckBox = dynamic_cast_or_throw_AC(TCheckBox*,aWindow->FindSubView('LIVE'));
						TCheckBox*	propCheckBox = dynamic_cast_or_throw_AC(TCheckBox*,aWindow->FindSubView('PROP'));
		
						aScrollerScrollBar = dynamic_cast_or_throw_AC(TScrollerScrollBarProportional*,aWindow->FindSubView('HSBR'));
						aScrollerScrollBar->GetAGAScrollBar()->SetAttributes(CCustomControl_AC::kHorizontal, liveCheckBox->IsOn(), propCheckBox->IsOn());
						aScrollerScrollBar->UpdateScrollAmounts();
						
						if (sourceID == 'PROP')
							aScrollerScrollBar->ForceRedraw();
		
						aScrollerScrollBar = dynamic_cast_or_throw_AC(TScrollerScrollBarProportional*,aWindow->FindSubView('VSBR'));
						aScrollerScrollBar->GetAGAScrollBar()->SetAttributes(CCustomControl_AC::kVertical, liveCheckBox->IsOn(), propCheckBox->IsOn());
						aScrollerScrollBar->UpdateScrollAmounts();
						
						if (sourceID == 'PROP')
							aScrollerScrollBar->ForceRedraw();
		
						TScrollBarProportional*	aScrollBar = dynamic_cast_or_throw_AC(TScrollBarProportional*,aWindow->FindSubView('SBAR'));
						aScrollBar->GetAGAScrollBar()->SetAttributes(CCustomControl_AC::kHorizontal, liveCheckBox->IsOn(), propCheckBox->IsOn());
						
						if (sourceID == 'PROP')
							aScrollBar->ForceRedraw();
					}
#endif
				}
				break;

			case 'LVSL':
			case 'PRSL':
#if 0	// This snippet is no longer used, since native Appearance controls determine these properties
		// at construction time (in DoMakeControl), rather than at runtime (here).
				{
					// The slider dialog had one of its checkboxes hit.
					// Toggle the appropriate attribute of all sliders
					// in the dialog.

					TSlider*	aSlider;
					TWindow*		aWindow = dynamic_cast_or_throw_AC(TCheckBox*,source)->GetWindow();
					TCheckBox*		liveCheckBox = dynamic_cast_or_throw_AC(TCheckBox*,aWindow->FindSubView('LVSL'));
					TCheckBox*		propCheckBox = dynamic_cast_or_throw_AC(TCheckBox*,aWindow->FindSubView('PRSL'));

					aSlider = dynamic_cast_or_throw_AC(TSlider*,aWindow->FindSubView('VSPL'));
					aSlider->GetAGAControl()->SetAttributes(CCustomControl_AC::kVertical, liveCheckBox->IsOn(), propCheckBox->IsOn());
					if (sourceID == 'PRSL') aSlider->ForceRedraw();

					aSlider = dynamic_cast_or_throw_AC(TSlider*,aWindow->FindSubView('VSPR'));
					aSlider->GetAGAControl()->SetAttributes(CCustomControl_AC::kVertical, liveCheckBox->IsOn(), propCheckBox->IsOn());
					if (sourceID == 'PRSL') aSlider->ForceRedraw();

					aSlider = dynamic_cast_or_throw_AC(TSlider*,aWindow->FindSubView('VSRC'));
					aSlider->GetAGAControl()->SetAttributes(CCustomControl_AC::kVertical, liveCheckBox->IsOn(), propCheckBox->IsOn());
					if (sourceID == 'PRSL') aSlider->ForceRedraw();

					aSlider = dynamic_cast_or_throw_AC(TSlider*,aWindow->FindSubView('HSPL'));
					aSlider->GetAGAControl()->SetAttributes(CCustomControl_AC::kHorizontal, liveCheckBox->IsOn(), propCheckBox->IsOn());
					if (sourceID == 'PRSL') aSlider->ForceRedraw();

					aSlider = dynamic_cast_or_throw_AC(TSlider*,aWindow->FindSubView('HSPR'));
					aSlider->GetAGAControl()->SetAttributes(CCustomControl_AC::kHorizontal, liveCheckBox->IsOn(), propCheckBox->IsOn());
					if (sourceID == 'PRSL') aSlider->ForceRedraw();

					aSlider = dynamic_cast_or_throw_AC(TSlider*,aWindow->FindSubView('HSRC'));
					aSlider->GetAGAControl()->SetAttributes(CCustomControl_AC::kHorizontal, liveCheckBox->IsOn(), propCheckBox->IsOn());
					if (sourceID == 'PRSL') aSlider->ForceRedraw();
				}
#endif
				break;

			case 'BIGP':
			case 'LILP':
				{
					TPicture*	thePicture = dynamic_cast_or_throw_AC(TPicture*,dynamic_cast_or_throw_AC(TView*,source)->GetWindow()->FindSubView('PICT'));
					
					thePicture->SetPictureRsrcID((sourceID == 'BIGP') ? kBigPictureID : kLittlePictureID, kRedraw);

					CRect_AC	pictFrame = (**(thePicture->fDataHandle)).picFrame;
					CViewPoint	pictSize(pictFrame[botRight] - pictFrame[topLeft]);
					
					thePicture->Resize(pictSize, kInvalidate);
				}
				break;

			case 'LRGT':
			case 'SMLT':
				{
#if 0	// This code is no longer used by the example, but is left in with comments so that
		// developers can understand how migrate code to do the things illustrated here.
					TTabbedView*		tabPanel;
					bool				small = (sourceID == 'SMLT');
					
					tabPanel = dynamic_cast_or_throw_AC(TTabbedView*,dynamic_cast_or_throw_AC(TView*,source)->GetWindow()->FindSubView('TAB1'));
					if ((tabPanel != NULL) && (tabPanel->GetAGAControl() != NULL))
					{
						// Tab size is now determined by class (TTabbedView or TSmallTabbedView).
						// If you really need to have a tabbed view with switchable tab size, do the following:
						//		subclass TSmallTabbedView
						//		add a fIsSmallTab bool data member
						//		override DoMakeControl
						//			if (fIsSmallTab)
						// 			return TSmallTabbedView::DoMakeControl(...) 
						//			else return TTabbedView::DoMakeControl(...)
						//		add a SetTabSize(bool isSmallTab) method
						//			call DeleteControl
						//			set fIsSmallTab to isSmallTab
						//			call CreateControl

						//tabPanel->GetAGAControl()->SetTabSize(small ? CTabbedView_AC::kSmallTabs : CTabbedView_AC::kLargeTabs);
						//tabPanel->GetAGAControl()->SetLabelsStyle(small ? CTabbedView_AC::kSmallTabPanelStyle : gSystemStyle);
						tabPanel->InstallTextStyle(small ? CTabbedView_AC::kSmallTabPanelStyle : gSystemStyle);
						tabPanel->ForceRedraw();
						
						tabPanel = dynamic_cast_or_throw_AC(TTabbedView*,dynamic_cast_or_throw_AC(TView*,source)->GetWindow()->FindSubView('TAB2'));
						
						//tabPanel->GetAGAControl()->SetTabSize(small ? CTabbedView_AC::kSmallTabs : CTabbedView_AC::kLargeTabs);
						//tabPanel->GetAGAControl()->SetLabelsStyle(small ? CTabbedView_AC::kSmallTabPanelStyle : gSystemStyle);
						tabPanel->InstallTextStyle(small ? CTabbedView_AC::kSmallTabPanelStyle : gSystemStyle);
						tabPanel->ForceRedraw();
					}
#endif
				}
				break;

			case 'GO_1':
				{
					// Save the pointer to the indeterminate progress indicator,
					// so we'll increment it at idle. Swap the enable states
					// of its Go and Stop buttons.

					TButton*	buttonToDisable = dynamic_cast_or_throw_AC(TButton*,source);
					TWindow*	aWindow = buttonToDisable->GetWindow();
					TButton*	buttonToEnable = dynamic_cast_or_throw_AC(TButton*,aWindow->FindSubView('STP1'));
					
					this->ToggleButtons(buttonToDisable, buttonToEnable);
					
					TProgressIndicator* aProgressIndicator1 = dynamic_cast_or_throw_AC(TProgressIndicator*,aWindow->FindSubView('PRG1'));		
					aProgressIndicator1->StartAutoAnimate();
				}
				break;
			
			case 'GO_2':
				{
					// Null the pointer to the determinate progress indicator,
					// so we'll ignore it at idle. Swap the enable states
					// of its Go and Stop buttons.

					TButton*	buttonToDisable = dynamic_cast_or_throw_AC(TButton*,source);
					TWindow*	aWindow = buttonToDisable->GetWindow();
					TButton*	buttonToEnable = dynamic_cast_or_throw_AC(TButton*,aWindow->FindSubView('STP2'));
					
					this->ToggleButtons(buttonToDisable, buttonToEnable);
					
					fProgressIndicator2 = dynamic_cast_or_throw_AC(TProgressIndicator*,aWindow->FindSubView('PRG2'));
				}
				break;
			
			case 'STP1':
				{
					// Save the pointer to the indeterminate progress indicator,
					// so we'll increment it at idle. Swap the enable states
					// of its Go and Stop buttons.

					TButton*	buttonToDisable = dynamic_cast_or_throw_AC(TButton*,source);
					TWindow*	aWindow = buttonToDisable->GetWindow();
					TButton*	buttonToEnable = dynamic_cast_or_throw_AC(TButton*,aWindow->FindSubView('GO_1'));
					
					this->ToggleButtons(buttonToDisable, buttonToEnable);
					
					TProgressIndicator* aProgressIndicator1 = dynamic_cast_or_throw_AC(TProgressIndicator*,aWindow->FindSubView('PRG1'));
					aProgressIndicator1->StopAutoAnimate();
				}
				break;
			
			case 'STP2':
				{
					// Null the pointer to the indeterminate progress indicator,
					// so we'll ignore it at idle. Swap the enable states
					// of its Go and Stop buttons.

					TButton*	buttonToDisable = dynamic_cast_or_throw_AC(TButton*,source);
					TWindow*	aWindow = buttonToDisable->GetWindow();
					TButton*	buttonToEnable = dynamic_cast_or_throw_AC(TButton*,aWindow->FindSubView('GO_2'));
					
					this->ToggleButtons(buttonToDisable, buttonToEnable);
			
					fProgressIndicator2 = NULL;
				}
				break;
						
			case 'SETV':
				{
					// The "Set Values" button in the progress dialog was hit.
					// Poke the determinate progress indicator with the current
					// values that have been entered in the dialog.

					TWindow*		aWindow = dynamic_cast_or_throw_AC(TButton*,source)->GetWindow();
					TNumberText*	aNumberText;
					SInt32			newMin;
					SInt32			newMax;
					SInt32			newValue;

					TProgressIndicator*	indicator = dynamic_cast_or_throw_AC(TProgressIndicator*,aWindow->FindSubView('PRG2'));
					
					aNumberText = dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('NMIN'));
					newMin = aNumberText->GetValue();
					
					aNumberText = dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('NMAX'));
					newMax = aNumberText->GetValue();
									
					aNumberText = dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('NVAL'));
					newValue = aNumberText->GetValue();
					
					// !!! New: Inform the control directly.
					// indicator->GetAGAControl()->SetRange(newMin, newMax, kDontRedraw);
					// indicator->GetAGAControl()->SetValue(newValue, kDontRedraw);
					indicator->SetValues(newValue, newMin, newMax, kDontRedraw);

					indicator->ForceRedraw();
				}
				break;

			case 'EDCB':
				{
					// Enable or disable the first field of the edit text dialog.

					TCheckBox*	aCheckBox = dynamic_cast_or_throw_AC(TCheckBox*,source);
					TWindow*	aWindow = aCheckBox->GetWindow();
					bool		enabled = aCheckBox->IsOn();
					TEditText*	anEditText = dynamic_cast_or_throw_AC(TEditText*,aWindow->FindSubView('EDT1'));

					anEditText->StopEdit();
					anEditText->SetActiveState(enabled, kRedraw);
				}
				break;

			case 'AWAY':
				{
					// Enable or disable the first field of the edit text dialog.

					TCheckBox*	aCheckBox = dynamic_cast_or_throw_AC(TCheckBox*, source);
					TWindow*	aWindow = aCheckBox->GetWindow();
					bool		isOn = aCheckBox->IsOn();

					// Radio buttons toggled in the tabbed view.
					TRadio*		fRadio = dynamic_cast_or_throw_AC(TRadio*, aWindow->FindSubView('xxx5'));
					fRadio->Show(isOn, kRedraw);
					fRadio->DimState(!isOn, kRedraw);
					fRadio = dynamic_cast_or_throw_AC(TRadio*, aWindow->FindSubView('xxx6'));
					fRadio->Show(isOn, kRedraw);
					fRadio->DimState(!isOn, kRedraw);
					fRadio = dynamic_cast_or_throw_AC(TRadio*, aWindow->FindSubView('xxx7'));
					fRadio->Show(isOn, kRedraw);
					fRadio->DimState(!isOn, kRedraw);
				}
				break;
		}
	}
	
	TFileBasedDocument::DoEvent(eventNumber, source, event);
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::ToggleButtons(TButton* buttonToDisable, TButton* buttonToEnable)
{
	buttonToDisable->SetActiveState(false, kRedraw);

	buttonToEnable->SetActiveState(true, kRedraw);
}

bool TMyDocument::DoIdle(IdlePhase phase)
{
	#pragma unused (phase)

	// If we have a pointer to the determinate progress indicator,
	// increment its value.
	if (fProgressIndicator2 && fProgressIndicator2->Focus())
	{
		fProgressIndicator2->SetValue(fProgressIndicator2->GetValue() + 1, kRedraw);			
	}

	return false;	// did not free self
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::PoseExampleDialog(UInt32 dialogIndex)
{
	// synch up emulation state before posing dialog.
	if (fEmulateControls != EmulateControls_AC())
		SetEmulateControls_AC(fEmulateControls);

	TWindow* aWindow;

	::ThrowIfNULL_AC(aWindow = gViewServer->NewTemplateWindow(kMyViewBase + dialogIndex, this));
	
	fCurrentDialogIndex = dialogIndex;
	
	this->SetupExampleDialog(dialogIndex, aWindow);
	
	(void) aWindow->PoseModally();
	
	this->CleanupExampleDialog(dialogIndex, aWindow);
	
	aWindow->Close();
	delete aWindow;
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::SetupExampleDialog(UInt32 dialogIndex, TWindow* itsWindow)
{
	// Note that when we set CControl_AC states & values here, we tell it
	// not to redraw right now, because the dialog isn't visible yet.
	// If we *did* tell it to redraw, we would have to Focus() it first
	// so that the CControl_AC would be drawing into the correct GrafPort.

	switch (dialogIndex)
	{
		case kPushButtonDlgIndex:
			{
				TCheckBox*	mixedCheckBox;
				mixedCheckBox = dynamic_cast_or_throw_AC(TCheckBox*,itsWindow->FindSubView('BTN5'));
				mixedCheckBox->SetState(kControlCheckBoxMixedValue, kRedraw);

				TRadio*	mixedRadioButton;
				mixedRadioButton = dynamic_cast_or_throw_AC(TRadio*,itsWindow->FindSubView('BTN8'));
				mixedRadioButton->SetState(kControlRadioButtonMixedValue, kRedraw);
			}
			break;

		case kScrollBarDlgIndex:
			{
				// New: inform the scroll bar directly.
				// if (EmulateControls_AC()) ...
				//TScrollBarProportional	*aScrollBar = dynamic_cast_or_throw_AC(TScrollBarProportional*,itsWindow->FindSubView('SBAR'));
				//aScrollBar->GetAGAScrollBar()->SetPageSize(25, CControl_AC::kDontRedraw);
				//aScrollBar->GetAGAScrollBar()->SetStepSizes(1, 25);

				TScrollBar* aScrollBar = dynamic_cast_or_throw_AC(TScrollBar*, itsWindow->FindSubView('SBAR'));
				aScrollBar->SetViewSize(25, kDontRedraw);
			}
			break;

		case kSliderDlgIndex:
			break;

		case kDisclosureDlgIndex:
			{
				// Disclosure Behavior example.
				itsWindow->AddBehavior(TH_new TDisclosureBehavior('OKAY', 'DIS1', 20));
			}
			break;
		case kProgressDlgIndex:
			{	
				// Make a call to the Set Values button so the progress indicator values match the fields.
				DoEvent(mButtonHit, itsWindow->FindSubView('SETV'), NULL);
			}
			break;
		case kFolderTabsDlgIndex:
			{
				TTabbedView*	tabPanel;
				
				tabPanel = dynamic_cast_or_throw_AC(TTabbedView*, itsWindow->FindSubView('TAB1'));
				
				// ATTENTION Developers: InstallPanel changed from 0-based to 1-based,
				// because the native Appearance tabs control is 1-based.
				tabPanel->InstallPanel(1, 3000, NULL, false);
				tabPanel->InstallPanel(2, 3001, NULL, false);
				tabPanel->InstallPanel(3, 3002, NULL, false);
				tabPanel->InstallPanel(4, 3003, NULL);  // This tab must be installed immediately
														// to support installing of sub-tabs below.
				
				// NOTE: We set the window's target here because a target in a pane
				// cannot be accomplished in the normal manner since the panel hasn't
				// been attached by the time NewTemplateWindow is called.
				TEditText*	theTarget = dynamic_cast_or_throw_AC(TEditText*, itsWindow->FindSubView('EDIT'));
				itsWindow->SetWindowTarget(theTarget);

				// Now install the sub-tab panel (i.e. tabs in tabs).
				tabPanel = dynamic_cast_or_throw_AC(TTabbedView*, itsWindow->FindSubView('TAB3'));
				tabPanel->InstallPanel(1, 3010, NULL, false);
				tabPanel->InstallPanel(2, 3011, NULL, false);
				tabPanel->InstallPanel(3, 3012, NULL, false);
			}
			break;
		}
	}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::CleanupExampleDialog(UInt32 dialogIndex, TWindow* itsWindow)
{
	#pragma unused (itsWindow)

	switch (dialogIndex)
	{
		case kProgressDlgIndex:
			{
				// Null the pointers so we don't go haywire at next DoIdle !

				fProgressIndicator2 = NULL;
			}
			break;
	}
}

//--------------------------------------------------------------------------------------------------
// TMyDocument
//--------------------------------------------------------------------------------------------------

void TMyDocument::EnableDisableDialog(UInt32 dialogIndex, TWindow* itsWindow, bool enable)
	{
	// Find all of the appropriate items of the specified dialog,
	// and set their enable/disable/dim state as requested.

	TControl*	aControl;
	TView*		aView;
	
	switch (dialogIndex)
	{
		case kPushButtonDlgIndex:
			// Disable the clusters.
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('CLS1'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('CLS2'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('CLS3'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('CLS4'));
			aControl->SetActiveState(enable, kRedraw);
			break;

		case kIconButtonDlgIndex:			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN1'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN2'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN3'));
			aControl->SetActiveState(enable, kRedraw);
	
			// Icon Checkboxes
				
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN4'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN5'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN6'));
			aControl->SetActiveState(enable, kRedraw);

			// Icon Radio buttons
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN7'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN8'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('ICN9'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('IC10'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('IC11'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('IC12'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('IC13'));
			aControl->SetActiveState(enable, kRedraw);

			// Icon popups
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('POP1'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('POP2'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('POP3'));
			aControl->SetActiveState(enable, kRedraw);

			break;
			
		case kScrollBarDlgIndex:

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('SBAR'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('HSBR'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('VSBR'));
			aControl->SetActiveState(enable, kRedraw);

			break;

		case kSliderDlgIndex:

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('VSPL'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('VSPR'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('VSRC'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('HSPL'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('HSPR'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('HSRC'));
			aControl->SetActiveState(enable, kRedraw);

			break;

		case kPopupMenuDlgIndex:
			break;

		case kGroupBoxDlgIndex:

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('GRP1'));
			aControl->SetActiveState(enable, kRedraw);
			
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('GRP2'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('CBX1'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('GRP3'));
			aControl->SetActiveState(enable, kRedraw);
			break;

		case kFolderTabsDlgIndex:
			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('TAB1'));
			aControl->SetActiveState(enable, kRedraw);

			aControl = dynamic_cast_or_throw_AC(TControl*,itsWindow->FindSubView('TAB2'));
			aControl->SetActiveState(enable, kRedraw);
			break;

		case kFocusBorderDlgIndex:

			::ThrowIfNULL_AC(aView = itsWindow->FindSubView('BRD1'));
			aView->SetActiveState(enable, kRedraw);

			::ThrowIfNULL_AC(aView = itsWindow->FindSubView('BRD2'));
			aView->SetActiveState(enable, kRedraw);

			::ThrowIfNULL_AC(aView = itsWindow->FindSubView('BRD3'));
			aView->SetActiveState(enable, kRedraw);

			::ThrowIfNULL_AC(aView = itsWindow->FindSubView('TVW1'));
			aView->SetActiveState(enable, kRedraw);

			::ThrowIfNULL_AC(aView = itsWindow->FindSubView('TVW2'));
			aView->SetActiveState(enable, kRedraw);

			::ThrowIfNULL_AC(aView = itsWindow->FindSubView('TVW3'));
			aView->SetActiveState(enable, kRedraw);

			break;

	}
}

//--------------------------------------------------------------------------------------------------
// TToggleEmulationCommand
//--------------------------------------------------------------------------------------------------

TToggleEmulationCommand::TToggleEmulationCommand(TMyDocument* myDocument)
	:	TCommand(20000, myDocument, kCanUndo, kCausesChange, myDocument),
		fMyDocument(myDocument)
{
}

//--------------------------------------------------------------------------------------------------
// TToggleEmulationCommand
//--------------------------------------------------------------------------------------------------

void TToggleEmulationCommand::DoIt()
{
	fMyDocument->SwapMainWindow();
}

//--------------------------------------------------------------------------------------------------
// TToggleEmulationCommand
//--------------------------------------------------------------------------------------------------

void TToggleEmulationCommand::UndoIt()
{
	fMyDocument->SwapMainWindow();
}
