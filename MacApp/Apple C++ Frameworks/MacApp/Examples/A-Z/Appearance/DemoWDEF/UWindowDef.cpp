//----------------------------------------------------------------------------------------
// UWindowDef.cpp
// Copyright � 1999-2001 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/03/01	Delete the window before removing it from the lookup table. 
							For Carbon, because we can't call the inherited WDEF, install
							a window definition only if we've been subclassed. 
		12/29/00	CreateAppearanceWindow is PowerPC only. 
		12/27/00	CWindow_AC. 
		12/15/00	Moved support for CreateWindow method into TWindow. 
							Use InvokeWindowDefUPP instead of CallWindowDefProc. 
							Test qNeedsSystem7_5 only if it's defined. 
		08/30/00	Carbon: Use accessor functions. 
							Create a custom window. 
		06/23/00	Initial version. 
*/

#ifndef __UWindowDef__
#include "UWindowDef.h"
#endif

// MacApp

#ifndef __FLOATWINDOW__
#include "FloatWindow.h"
#endif

#if q68K
	#ifndef __UPATCH__
	#include "UPatch.h"
	#endif
#endif

// ACS

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

// Toolbox

// ANSI


//========================================================================================
// TWindowDef
//========================================================================================

MA_DEFINE_CLASS(TWindowDef);

//----------------------------------------------------------------------------------------
// Global Variables
//----------------------------------------------------------------------------------------

#if qCarbon
WindowDefUPP TWindowDef::fgWindowDefUPP;	// Cached UPP for our window definition
#else
Handle TWindowDef::fgWindowDef;				// Replaces the window's windowDefProc field
#endif

static TWindowDef* pCreatingWindow;

//----------------------------------------------------------------------------------------
// Register
//----------------------------------------------------------------------------------------

void TWindowDef::Register()
{
#if qTemplateViews
	static bool pRegistered;
	if (!pRegistered)
	{
		pRegistered = true;

		REGISTER_CLASS_AC(TWindowDef);
	}
#endif
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

TWindowDef::TWindowDef(WindowRef itsWMgrWindow,
					   bool canResize,
					   bool canClose,
					   bool inDispose) :
	TWindow(itsWMgrWindow, canResize, canClose, inDispose)
#if !qCarbon
	, fInheritedWDEF(NULL),
	fCallInherited(true)
#endif
{
#if !qCarbon
	InstallWDEF();
#endif
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

TWindowDef::TWindowDef(const TWindowDef& inWindowDef) :
	TWindow(inWindowDef)
#if !qCarbon
	, fInheritedWDEF(NULL),
	fCallInherited(inWindowDef.fCallInherited)
#endif
{
#if !qCarbon
	InstallWDEF();
#endif
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TWindowDef::~TWindowDef() // override
{
#if !qCarbon
	RemoveWDEF();
#else
	// This code makes sure the window isn't removed from the lookup table
	// until after the Window Manager Window is deleted. That way the clean
	// up message to the WDEF will work. 

	BeInPort(NULL);

	FreeIfWMgrWindow(fWMgrWindow, fDisposeOnFree);

	fgWindows.Delete(fWMgrWindow);		// Remove from the lookup table
	fWMgrWindow = NULL;
#endif
}

#if !qMSWindows

#if !qCarbon
//----------------------------------------------------------------------------------------
// CreateClassicWindow
//----------------------------------------------------------------------------------------

void TWindowDef::CreateClassicWindow()
{
	TWindow::CreateClassicWindow();

	InstallWDEF();
}
#endif


#if qPowerPC

//----------------------------------------------------------------------------------------
// CreateAppearanceWindow
//----------------------------------------------------------------------------------------

void TWindowDef::CreateAppearanceWindow()
{
#if qCarbon
	if (typeid(*this) == typeid(TWindowDef))
	{
		// Do not install a window definition unless we're subclassed. 
		TWindow::CreateAppearanceWindow();
	}
	else
	{
		// Building for Carbon, we must use CreateCustomWindow to associate our window
		// definition with the window. 
#if qDebug
		if (fProcID == 16)		// Not supported in Carbon
			::ProgramBreak_AC("A window procID of 16 isn't supported in Carbon.");
#endif

		// The toolbox is allocating the window storage for us, so we should
		// never try to delete it ourselves. 
		fDisposeOnFree = true;

		WindowClass windowClass = 0;
		WindowAttributes attributes = 0;
		GetCreateParameters(fProcID, windowClass, attributes);

		CRect_AC theBounds = GetFrame().ToRect();

		WindowDefSpec def;
		def.defType = kWindowDefProcPtr;
		def.u.defProc = GetWindowDefUPP();
		pCreatingWindow = this;
		fWMgrWindow = CWindow_AC::Create(def, windowClass, attributes, theBounds);
		pCreatingWindow = NULL;
		::ThrowIfNULL_AC(fWMgrWindow);

		// Set the window's title from the resource
		SetTitle(CStr255_AC(fStrListID, fIndex));
		
		// ���  May need to call SendBehind for sinking windows
	}
#else
	// Otherwise, create the window normally and install our window definition. 
	TWindow::CreateAppearanceWindow();
	InstallWDEF();
#endif // qCarbon
}

#endif // qPowerPC

#endif // !qMSWindows

#if !qCarbon

//----------------------------------------------------------------------------------------
// InstallWDEF
//----------------------------------------------------------------------------------------

void TWindowDef::InstallWDEF()
{
	fInheritedWDEF = NULL;

	if (fWMgrWindow && (fWMgrWindow.Peek()->windowDefProc != GetWDEF()))
	{
		fInheritedWDEF = fWMgrWindow.Peek()->windowDefProc;
		fWMgrWindow.Peek()->windowDefProc = GetWDEF();
	}
}

//----------------------------------------------------------------------------------------
// RemoveWDEF
//----------------------------------------------------------------------------------------

void TWindowDef::RemoveWDEF()
{
	if (fWMgrWindow && (fWMgrWindow.Peek()->windowDefProc == fgWindowDef))
		fWMgrWindow.Peek()->windowDefProc = fInheritedWDEF;

	fInheritedWDEF = NULL;
}

#endif // !qCarbon

#if qCarbon

//----------------------------------------------------------------------------------------
// GetWindowDefUPP
//----------------------------------------------------------------------------------------

WindowDefUPP TWindowDef::GetWindowDefUPP()
{
	if (!fgWindowDefUPP)
		fgWindowDefUPP = NewWindowDefUPP(WDEFEntry);

	return fgWindowDefUPP;
}

#else

//----------------------------------------------------------------------------------------
// GetWDEF
//----------------------------------------------------------------------------------------

Handle TWindowDef::GetWDEF()
{
	if (!fgWindowDef)
	{
#if qPowerPC
		fgWindowDef = NewPermHandle(sizeof(RoutineDescriptor));
		RoutineDescriptor windowDefRD = BUILD_ROUTINE_DESCRIPTOR(uppWindowDefProcInfo, WDEFEntry);
		BlockMove(&windowDefRD, *fgWindowDef, sizeof(RoutineDescriptor)); // leave BlockMove so cache flushes
#elif q68K
		fgWindowDef = NewPermHandle(sizeof(JmpInstructionTemplate));
		PatchJmpInstruction(*fgWindowDef, reinterpret_cast<void*>(StripLong(WDEFEntry)));
#endif
	}
	return fgWindowDef;
}

#endif // qCarbon

//----------------------------------------------------------------------------------------
// WDEFEntry
//----------------------------------------------------------------------------------------

pascal long TWindowDef::WDEFEntry(short varCode, WindowPtr window, short message, long param)
{
#pragma unused (varCode)

	long result = 0;

	long OldA5 = SetCurrentA5();				// ***** Called from trap patches *****
	
	try
	{
		TWindowDef* wDef = dynamic_cast<TWindowDef*>( WMgrToWindow(window) );
		if (wDef)
			result = wDef->WDEFMain(message, param);
		else if (pCreatingWindow)
		{
			pCreatingWindow->fWMgrWindow = window;
			result = pCreatingWindow->WDEFMain(message, param);
		}
#if qDebug
		else
			ProgramBreak_AC("DefProcEntry called with no CWindowDefinition object");
#endif
	}
	catch (...)
	{
		// Catch all exceptions and prevent them from propagating through the callback. 
	}
	
	SetA5(OldA5);

	return result;
}

//----------------------------------------------------------------------------------------
// WDEFMain
//----------------------------------------------------------------------------------------

long TWindowDef::WDEFMain(short message, long param)
{
	long result = 0;

	switch (message)
	{
		// Window Messages

		case kWindowMsgDraw:
			WDEFDraw(LoWord(param));
			break;

		case kWindowMsgHitTest:
			{
				Point where;
				where.v = HiWord(param);
				where.h = LoWord(param);
				result = WDEFHitTest(where);
			}
			break;

		case kWindowMsgCalculateShape:
			WDEFCalculateShape();
			break;

		case kWindowMsgInitialize:
			WDEFInitialize();			
			break;

		case kWindowMsgCleanUp:
			WDEFCleanUp();
			break;

		case kWindowMsgDrawGrowOutline:
			WDEFDrawGrowOutline(reinterpret_cast<Rect*>(param));
			break;

		case kWindowMsgDrawGrowBox:
			WDEFDrawGrowBox();
			break;

		// Messages available in Mac OS 8.0 and later

		case kWindowMsgGetFeatures:
			result = WDEFGetFeatures(reinterpret_cast<long*>(param));
			break;

		case kWindowMsgGetRegion:
			result = WDEFGetRegion(reinterpret_cast<GetWindowRegionPtr>(param));
			break;

		// Everything else

		default:
#if !qCarbon
			result = CallInheritedWDEF(message, param);
#endif
			break;
	}

	return result;
}

//----------------------------------------------------------------------------------------
// WDEFDraw
//----------------------------------------------------------------------------------------

void TWindowDef::WDEFDraw(short partCode)
{
#if qCarbon
#pragma unused (partCode)
#else
	CallInheritedWDEF(wDraw, partCode);
#endif
}

//----------------------------------------------------------------------------------------
// WDEFHitTest
//----------------------------------------------------------------------------------------

short TWindowDef::WDEFHitTest(Point where)
{
	WindowDefPartCode partCode = wNoHit;

#if qCarbon
#pragma unused (where)
#else
	if (fCallInherited && fInheritedWDEF)
	{
		long param = (where.v << 16) | where.h;
		partCode = CallInheritedWDEF(kWindowMsgHitTest, param);
	}
#endif

	return partCode;
}

//----------------------------------------------------------------------------------------
// WDEFCalculateShape
//----------------------------------------------------------------------------------------

void TWindowDef::WDEFCalculateShape()
{
#if !qCarbon
	CallInheritedWDEF(kWindowMsgCalculateShape);
#endif
}

//----------------------------------------------------------------------------------------
// WDEFInitialize
//----------------------------------------------------------------------------------------

void TWindowDef::WDEFInitialize()
{
#if !qCarbon
	CallInheritedWDEF(kWindowMsgInitialize);
#endif
}

//----------------------------------------------------------------------------------------
// WDEFCleanUp
//----------------------------------------------------------------------------------------

void TWindowDef::WDEFCleanUp()
{
#if !qCarbon
	CallInheritedWDEF(kWindowMsgCleanUp);
#endif
}

//----------------------------------------------------------------------------------------
// WDEFDrawGrowOutline
//----------------------------------------------------------------------------------------

void TWindowDef::WDEFDrawGrowOutline(const Rect* bounds)
{
#if qCarbon
#pragma unused (bounds)
#else
	CallInheritedWDEF(kWindowMsgDrawGrowOutline, reinterpret_cast<long>(bounds));
#endif
}

//----------------------------------------------------------------------------------------
// WDEFDrawGrowBox
//----------------------------------------------------------------------------------------

void TWindowDef::WDEFDrawGrowBox()
{
#if !qCarbon
	CallInheritedWDEF(kWindowMsgDrawGrowBox);
#endif
}

//----------------------------------------------------------------------------------------
// WDEFGetFeatures
//----------------------------------------------------------------------------------------

bool TWindowDef::WDEFGetFeatures(long *features)
{
	bool result = false;
	*features = 0;

#if !qCarbon
	if (fCallInherited && fInheritedWDEF)
		result = CallInheritedWDEF(kWindowMsgGetFeatures, reinterpret_cast<long>(features));
#endif

	return result;
}

//----------------------------------------------------------------------------------------
// WDEFGetRegion
//----------------------------------------------------------------------------------------

OSStatus TWindowDef::WDEFGetRegion(GetWindowRegionPtr windowRgnRec)
{
	OSStatus err = -1;

#if !qCarbon
	if (fCallInherited && fInheritedWDEF)
		err = CallInheritedWDEF(kWindowMsgGetRegion, reinterpret_cast<long>(windowRgnRec));
	else
#endif
	{
		switch (windowRgnRec->regionCode)
		{
			case kWindowStructureRgn:
			case kWindowContentRgn:
				{
					CGrafPtr windowPort = GetWindowPort(fWMgrWindow);
					CTempGrafPort_AC savePort(windowPort);

					CRegion_AC extent(windowRgnRec->winRgn);
					GetExtentRegion(extent);

					CPoint_AC offset(0, 0);
					::LocalToGlobal(&offset);

					extent += offset;
				}
				break;
		}
	}

	return err;
}

#if !qCarbon
//----------------------------------------------------------------------------------------
// CallInheritedWDEF
//----------------------------------------------------------------------------------------

long TWindowDef::CallInheritedWDEF(short message, long param)
{
	long result = 0;

	if (fCallInherited && fInheritedWDEF)
	{
		Handle wDefProc = CWindow_AC::LoadDefProc(fInheritedWDEF);
		if (wDefProc)
		{
			CTempHandleLock_AC tempHandleLock(wDefProc);
			result = InvokeWindowDefUPP(GetWVariant(fWMgrWindow), fWMgrWindow,
										message, param,
										*reinterpret_cast<WindowDefUPP*>(wDefProc));
		}
	}

	return result;
}
#endif


//----------------------------------------------------------------------------------------
// End of UWindowDef.cpp
