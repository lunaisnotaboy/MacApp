//----------------------------------------------------------------------------------------
// USimpleWindowDef.cpp
// Copyright © 1999-2000 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		12/27/00	CWindow_AC. 
		08/30/00	Carbon: Use accessor functions. 
		06/23/00	Initial version. 
*/

#ifndef __USimpleWindowDef__
#include "USimpleWindowDef.h"
#endif

// MacApp

#if q68K
	#ifndef __UPATCH__
	#include "UPatch.h"
	#endif
#endif

// ACS

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

// Toolbox

// ANSI


//----------------------------------------------------------------------------------------
// GetPortBounds
//----------------------------------------------------------------------------------------

inline Rect GetPortBounds(CGrafPtr port)
{
#if qCarbon
	Rect r;
	return *::GetPortBounds(port, &r);
#else
	return port->portRect;
#endif
}

//========================================================================================
// TSimpleWindowDef
//========================================================================================

MA_DEFINE_CLASS(TSimpleWindowDef);

//----------------------------------------------------------------------------------------
// Register
//----------------------------------------------------------------------------------------

void TSimpleWindowDef::Register()
{
#if qTemplateViews
	static bool pRegistered;
	if (!pRegistered)
	{
		pRegistered = true;

		REGISTER_CLASS_AC(TSimpleWindowDef);
	}
#endif
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

TSimpleWindowDef::TSimpleWindowDef(WindowRef itsWMgrWindow,
					   bool canResize,
					   bool canClose,
					   bool inDispose) :
	TWindowDef(itsWMgrWindow, canResize, canClose, inDispose)
{
#if !qCarbon
	fCallInherited = false;
#endif
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

TSimpleWindowDef::TSimpleWindowDef(const TSimpleWindowDef& inWindowDef) :
	TWindowDef(inWindowDef)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TSimpleWindowDef::~TSimpleWindowDef() // override
{
}

//----------------------------------------------------------------------------------------
// WDEFDraw
//----------------------------------------------------------------------------------------

void TSimpleWindowDef::WDEFDraw(short partCode)
{
#pragma unused (partCode)
}

//----------------------------------------------------------------------------------------
// FindSubViewHit
//----------------------------------------------------------------------------------------

static TView* FindSubViewHit(TView* inView, const CViewPoint& theMouse)
{
	TView* subViewHit = inView;

	for (CSubViewIterator iter(inView, kIterateBackward_AC); iter; ++iter)
	{
		CViewPoint subViewPt(iter->SuperViewToLocal(theMouse));

		if (iter->ContainsMouse(subViewPt))
		{
			subViewHit = FindSubViewHit(iter, subViewPt);
			break;
		}
	}

	return subViewHit;
}

//----------------------------------------------------------------------------------------
// WDEFHitTest
//----------------------------------------------------------------------------------------

short TSimpleWindowDef::WDEFHitTest(Point where)
{
	WindowDefPartCode partCode = wNoHit;

	CGrafPtr windowPort = GetWindowPort(fWMgrWindow);
	CTempGrafPort_AC savePort(windowPort);

	CPoint_AC localWhere(where);
	GlobalToLocal(&localWhere);

	CRect_AC content = GetPortBounds(windowPort);
	if (content.Contains(localWhere))
	{
		TView* subViewHit = FindSubViewHit(this, CViewPoint(localWhere));
		if (subViewHit != this)
			partCode = wInContent;
		else
			partCode = wInDrag;
	}

	return partCode;
}

#if !qCarbon
//----------------------------------------------------------------------------------------
// WDEFCalculateShape
//----------------------------------------------------------------------------------------

void TSimpleWindowDef::WDEFCalculateShape()
{
	WindowPeek window = fWMgrWindow.Peek();

	if (window->contRgn)
		GetContentRegion(window->contRgn);

	if (window->strucRgn)
		GetStructureRegion(window->strucRgn);
}
#endif

//----------------------------------------------------------------------------------------
// WDEFInitialize
//----------------------------------------------------------------------------------------

void TSimpleWindowDef::WDEFInitialize()
{
}

//----------------------------------------------------------------------------------------
// WDEFCleanUp
//----------------------------------------------------------------------------------------

void TSimpleWindowDef::WDEFCleanUp()
{
}

//----------------------------------------------------------------------------------------
// WDEFDrawGrowOutline
//----------------------------------------------------------------------------------------

void TSimpleWindowDef::WDEFDrawGrowOutline(const Rect* bounds)
{
	FrameRect(bounds);
}

//----------------------------------------------------------------------------------------
// WDEFDrawGrowBox
//----------------------------------------------------------------------------------------

void TSimpleWindowDef::WDEFDrawGrowBox()
{
}

//----------------------------------------------------------------------------------------
// WDEFGetFeatures
//----------------------------------------------------------------------------------------

bool TSimpleWindowDef::WDEFGetFeatures(long *features)
{
	*features = 0;
	return true;
}

//----------------------------------------------------------------------------------------
// WDEFGetRegion
//----------------------------------------------------------------------------------------

OSStatus TSimpleWindowDef::WDEFGetRegion(GetWindowRegionPtr windowRgnRec)
{
	OSStatus err = -1;

	switch (windowRgnRec->regionCode)
	{
		case kWindowStructureRgn:
			err = GetStructureRegion(windowRgnRec->winRgn);
			break;

		case kWindowContentRgn:
			err = GetContentRegion(windowRgnRec->winRgn);
			break;
	}

	return err;
}

//----------------------------------------------------------------------------------------
// GetStructureRegion
//----------------------------------------------------------------------------------------

OSStatus TSimpleWindowDef::GetStructureRegion(RgnHandle winRgn)
{
	OSErr err = noErr;

	CGrafPtr windowPort = GetWindowPort(fWMgrWindow);
	CTempGrafPort_AC savePort(windowPort);

	CRect_AC content = GetPortBounds(windowPort);

	CPoint_AC offset(0, 0);
	::LocalToGlobal(&offset);
	content += offset;

	if (winRgn)
	{
		RectRgn(winRgn, &content);
		err = MemError();
	}
	else
		err = paramErr;

	return err;
}

//----------------------------------------------------------------------------------------
// GetContentRegion
//----------------------------------------------------------------------------------------

OSStatus TSimpleWindowDef::GetContentRegion(RgnHandle winRgn)
{
	return GetStructureRegion(winRgn);
}


//----------------------------------------------------------------------------------------
// End of USimpleWindowDef.cpp
