//----------------------------------------------------------------------------------------
// URegionPicture.cpp
// Copyright © 1999-2001 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		06/23/00	Initial version. 
*/

#ifndef __URegionPicture__
#include "URegionPicture.h"
#endif

// DemoWDEF

#ifndef __CGraphicsWorld__
#include "CGraphicsWorld.h"
#endif

#ifndef __CTempPicture__
#include "CTempPicture.h"
#endif

// MacApp

// ACS

// Toolbox

// ANSI


//========================================================================================
// TRegionPicture
//========================================================================================

MA_DEFINE_CLASS(TRegionPicture);

//----------------------------------------------------------------------------------------
// Register
//----------------------------------------------------------------------------------------

void TRegionPicture::Register()
{
#if qTemplateViews
	static bool pRegistered;
	if (!pRegistered)
	{
		pRegistered = true;

		REGISTER_CLASS_AC(TRegionPicture);
	}
#endif
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

TRegionPicture::TRegionPicture(const CViewPoint& itsLocation,
							   const CViewPoint& itsSize,
							   SizeDeterminer itsHSizeDet,
							   SizeDeterminer itsVSizeDet,
							   ResNumber itsRsrcID) :
	TPicture(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsRsrcID)
{
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

TRegionPicture::TRegionPicture(const TRegionPicture& inPicture) :
	TPicture(inPicture)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TRegionPicture::~TRegionPicture() // override
{
}

//----------------------------------------------------------------------------------------
// ReadFields
//----------------------------------------------------------------------------------------

void TRegionPicture::ReadFields(CStream_AC* aStream)
{
	TPicture::ReadFields(aStream);

	SetShape(static_cast<ResNumber>(fUserArea));
}

//----------------------------------------------------------------------------------------
// SetShape
//----------------------------------------------------------------------------------------

void TRegionPicture::SetShape(ResNumber itsRsrcID)
{
	CTempPictureResource maskPict;
	if (itsRsrcID)
	{
		maskPict = GetPicture(CMultiLocale_AC::GetExistingResourceID('PICT', itsRsrcID));
		ThrowIfNULLResource_AC(maskPict.AsHandle());
	}
	SetShape(maskPict);
}

void TRegionPicture::SetShape(PicHandle maskPict)
{
	CTempRegion_AC theShape;
	if (maskPict)
	{
		CRect_AC maskRect = (**maskPict).picFrame;
		maskRect -= maskRect[topLeft];

		CTempGWorld maskGWorld(1, &maskRect, NULL, NULL, 0);
		CLockPixMap maskPixMap(maskGWorld);
		if (maskPixMap.IsLocked())
		{
			EraseRect(maskRect);
			DrawPicture(maskPict, &maskRect);
			maskGWorld.BitsAsRegion(theShape);
		}
	}
	SetShape(theShape);
}

void TRegionPicture::SetShape(RgnHandle theShape)
{
	fShape.Set(theShape);
}

//----------------------------------------------------------------------------------------
// GetExtentRegion
//----------------------------------------------------------------------------------------

void TRegionPicture::GetExtentRegion(RgnHandle itsExtentRgn) const
{
	if (!fShape.IsEmpty())
		MacCopyRgn(fShape, itsExtentRgn);
	else
		TPicture::GetExtentRegion(itsExtentRgn);
}


//----------------------------------------------------------------------------------------
// End of URegionPicture.cpp