//----------------------------------------------------------------------------------------
// URegionWindowDef.cpp
// Copyright � 1999-2000 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		12/27/00	CWindow_AC. 
		08/30/00	Carbon: Use accessor functions. 
		06/23/00	Initial version. 
*/

#ifndef __URegionWindowDef__
#include "URegionWindowDef.h"
#endif

// MacApp

#if q68K
	#ifndef __UPATCH__
	#include "UPatch.h"
	#endif
#endif

// ACS

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

// Toolbox

// ANSI


//----------------------------------------------------------------------------------------
// GetPortBounds
//----------------------------------------------------------------------------------------

inline Rect GetPortBounds(CGrafPtr port)
{
#if qCarbon
	Rect r;
	return *::GetPortBounds(port, &r);
#else
	return port->portRect;
#endif
}

//========================================================================================
// TRegionWindowDef
//========================================================================================

MA_DEFINE_CLASS(TRegionWindowDef);

//----------------------------------------------------------------------------------------
// Register
//----------------------------------------------------------------------------------------

void TRegionWindowDef::Register()
{
#if qTemplateViews
	static bool pRegistered;
	if (!pRegistered)
	{
		pRegistered = true;

		REGISTER_CLASS_AC(TRegionWindowDef);
	}
#endif
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

TRegionWindowDef::TRegionWindowDef(WindowRef itsWMgrWindow,
					   bool canResize,
					   bool canClose,
					   bool inDispose) :
	TWindowDef(itsWMgrWindow, canResize, canClose, inDispose)
{
#if !qCarbon
	fCallInherited = false;
#endif
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

TRegionWindowDef::TRegionWindowDef(const TRegionWindowDef& inWindowDef) :
	TWindowDef(inWindowDef)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TRegionWindowDef::~TRegionWindowDef() // override
{
}

//----------------------------------------------------------------------------------------
// GetExtentRegion
//----------------------------------------------------------------------------------------

void TRegionWindowDef::GetExtentRegion(RgnHandle itsExtentRgn) const
{
	if (fSubView)
	{
		SetEmptyRgn(itsExtentRgn);
		CTempRegion_AC subViewExtent;
		for (CSubViewIterator iter(this); iter; ++iter)
		{
			iter->GetExtentRegion(subViewExtent);
			UnionRgn(itsExtentRgn, subViewExtent, itsExtentRgn);
			ThrowIfMemError_AC();
		}
	}
	else
		TWindow::GetExtentRegion(itsExtentRgn);
}

//----------------------------------------------------------------------------------------
// WDEFDraw
//----------------------------------------------------------------------------------------

void TRegionWindowDef::WDEFDraw(short partCode)
{
#pragma unused (partCode)
}

//----------------------------------------------------------------------------------------
// FindSubViewHit
//----------------------------------------------------------------------------------------

static TView* FindSubViewHit(TView* inView, const CViewPoint& theMouse)
{
	TView* subViewHit = inView;

	for (CSubViewIterator iter(inView, kIterateBackward_AC); iter; ++iter)
	{
		CViewPoint subViewPt(iter->SuperViewToLocal(theMouse));

		if (iter->ContainsMouse(subViewPt))
		{
			subViewHit = FindSubViewHit(iter, subViewPt);
			break;
		}
	}

	return subViewHit;
}

//----------------------------------------------------------------------------------------
// WDEFHitTest
//----------------------------------------------------------------------------------------

short TRegionWindowDef::WDEFHitTest(Point where)
{
	WindowDefPartCode partCode = wNoHit;

	CGrafPtr windowPort = GetWindowPort(fWMgrWindow);
	CTempGrafPort_AC savePort(windowPort);

#if qCarbon
	CTempRegion_AC testRegion;
	GetContentRegion(testRegion);
	if (PtInRgn(where, testRegion))
	{
		CPoint_AC localWhere(where);
		GlobalToLocal(&localWhere);

		TView* subViewHit = FindSubViewHit(this, CViewPoint(localWhere));
		if (subViewHit && (subViewHit != this) && subViewHit->IsEnabled())
			partCode = wInContent;
		else
			partCode = wInDrag;
	}
	else
	{
		GetStructureRegion(testRegion);
		if (PtInRgn(where, testRegion))
		{
			partCode = wInDrag;
		}
	}
#else
	WindowPeek window = fWMgrWindow.Peek();
	if (PtInRgn(where, window->contRgn))
	{
		CPoint_AC localWhere(where);
		GlobalToLocal(&localWhere);

		TView* subViewHit = FindSubViewHit(this, CViewPoint(localWhere));
		if (subViewHit && (subViewHit != this) && subViewHit->IsEnabled())
			partCode = wInContent;
		else
			partCode = wInDrag;
	}
	else if (PtInRgn(where, window->strucRgn))
	{
		partCode = wInDrag;
	}
#endif

	return partCode;
}

//----------------------------------------------------------------------------------------
// WDEFCalculateShape
//----------------------------------------------------------------------------------------

void TRegionWindowDef::WDEFCalculateShape()
{
#if !qCarbon
	WindowPeek window = fWMgrWindow.Peek();

	if (window->strucRgn)
		GetStructureRegion(window->strucRgn);

	if (window->contRgn)
		GetContentRegion(window->contRgn);
#endif
}

//----------------------------------------------------------------------------------------
// WDEFInitialize
//----------------------------------------------------------------------------------------

void TRegionWindowDef::WDEFInitialize()
{
}

//----------------------------------------------------------------------------------------
// WDEFCleanUp
//----------------------------------------------------------------------------------------

void TRegionWindowDef::WDEFCleanUp()
{
}

//----------------------------------------------------------------------------------------
// WDEFDrawGrowOutline
//----------------------------------------------------------------------------------------

void TRegionWindowDef::WDEFDrawGrowOutline(const Rect* bounds)
{
	FrameRect(bounds);
}

//----------------------------------------------------------------------------------------
// WDEFDrawGrowBox
//----------------------------------------------------------------------------------------

void TRegionWindowDef::WDEFDrawGrowBox()
{
}

//----------------------------------------------------------------------------------------
// WDEFGetFeatures
//----------------------------------------------------------------------------------------

bool TRegionWindowDef::WDEFGetFeatures(long *features)
{
	*features = kWindowCanGetWindowRegion | kWindowCanCollapse;
	return true;
}

//----------------------------------------------------------------------------------------
// WDEFGetRegion
//----------------------------------------------------------------------------------------

OSStatus TRegionWindowDef::WDEFGetRegion(GetWindowRegionPtr windowRgnRec)
{
	OSStatus err = -1;

	switch (windowRgnRec->regionCode)
	{
		case kWindowTitleBarRgn:
		case kWindowTitleTextRgn:
		case kWindowCloseBoxRgn:
		case kWindowZoomBoxRgn:
			break;

		case kWindowDragRgn:
#if qCarbon
#else
			{
				WindowPeek window = fWMgrWindow.Peek();
				DiffRgn(window->strucRgn, window->contRgn, windowRgnRec->winRgn);
				// Subtract out the close box if the window is hilited.
				if (window->hilited)
				{
					// ���
				}
				err = MemError();
			}
#endif
			break;

		case kWindowGrowRgn:
		case kWindowCollapseBoxRgn:
		case kWindowTitleProxyIconRgn:
			break;

		case kWindowStructureRgn:
			err = GetStructureRegion(windowRgnRec->winRgn);
			break;

		case kWindowContentRgn:
			err = GetContentRegion(windowRgnRec->winRgn);
			break;

		case kWindowUpdateRgn:
		case kWindowGlobalPortRgn:
		default:
//			EmptyRgn(windowRgnRec->winRgn);
			break;		
	}

	return err;
}

//----------------------------------------------------------------------------------------
// GetStructureRegion
//----------------------------------------------------------------------------------------

OSStatus TRegionWindowDef::GetStructureRegion(RgnHandle winRgn)
{
	OSErr err = noErr;

	CGrafPtr windowPort = GetWindowPort(fWMgrWindow);
	CTempGrafPort_AC savePort(windowPort);

	CRegion_AC extent(winRgn);
	GetExtentRegion(extent);

	CPoint_AC offset(0, 0);
	::LocalToGlobal(&offset);

	extent += offset;

	return err;
}

//----------------------------------------------------------------------------------------
// GetContentRegion
//----------------------------------------------------------------------------------------

OSStatus TRegionWindowDef::GetContentRegion(RgnHandle winRgn)
{
	return GetStructureRegion(winRgn);
}


//----------------------------------------------------------------------------------------
// End of URegionWindowDef.cpp
