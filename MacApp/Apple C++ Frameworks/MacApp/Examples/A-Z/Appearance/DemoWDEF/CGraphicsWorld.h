// CGraphicsWorld.h
// Copyright © 1996-2001 by Apple Computer, Inc. All rights reserved. 

/*
	Change History:
		03/01/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		08/30/00	Carbon: CreateGrafPort and DisposeIfGrafPort are not supported
					for Carbon. 
		09/03/98	Allow specifying a NULL matteRect. 
		09/03/98	Add release, reset, get and AsGrafPort. Add CTempGWorld. 
					Add constructors that make a new graphics world. 
					Add Draw method. 
		08/04/98	QTClassLib. 
		06/20/98	Add CopyTo. 
					CLockPixMap now works on a CGWorld. 
		05/08/98	Added CopyWorldToWorld
		03/09/98	Add Exists method. 
		12/08/97	Uninlined GWorld constructors for debugging purposes
*/

#ifndef __CGraphicsWorld__
#define __CGraphicsWorld__

// ACS

#ifndef __Types_AC__
#include "Types_AC.h"
#endif

// Toolbox

#ifndef __IMAGECOMPRESSION__
#include <ImageCompression.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __QUICKDRAW__
#include <QuickDraw.h>
#endif

#ifndef __QDOFFSCREEN__
#include <QDOffscreen.h>
#endif

//----------------------------------------------------------------------------------------
// Forward and external classes
//----------------------------------------------------------------------------------------

//========================================================================================
// Global Functions
//========================================================================================

#if !OPAQUE_TOOLBOX_STRUCTS

GrafPtr CreateGrafPort(const CRect_AC& bounds);
GrafPtr DisposeIfGrafPort(GrafPtr port);

#endif

//========================================================================================
// CPixMap
//========================================================================================

class CPixMap
{
protected:
	PixMapHandle	fPixMap;
	
public:
	CPixMap()					{ }
	CPixMap(PixMapHandle pm)	{ fPixMap = pm; }
	
	~CPixMap()					{ }

	bool Exists() const			{ return (fPixMap != NULL); }
		// Check if the PixMap exists. It's ok if it doesn't. 

#if qRangeCheck
	bool Valid() const;
#else
	bool Valid() const			{ return true; }
#endif
		// Check if the PixMap exists. Print a warning if it doesn't. 

	operator PixMapHandle()		{ return Valid() ? fPixMap : NULL; }
	PixMapHandle operator=(PixMapHandle pm)	{ return (fPixMap = pm); }

	// From <QuickDraw.h>

	void New()					{ fPixMap = NewPixMap(); }
	void Dispose()				{ if (Exists()) { if (Valid()) DisposePixMap(fPixMap); fPixMap = NULL; } }

	// From <QDOffscreen.h>

	bool Lock()					{ return Valid() ? LockPixels(fPixMap) : false; }
	void Unlock()				{ if (Valid()) UnlockPixels(fPixMap); }

	void AllowPurge()			{ if (Valid()) AllowPurgePixels(fPixMap); }
	void NoPurge()				{ if (Valid()) NoPurgePixels(fPixMap); }

	GWorldFlags GetState() const		{ return Valid() ? GetPixelsState(fPixMap) : 0; }
	void SetState(GWorldFlags state)	{ if (Valid()) SetPixelsState(fPixMap, state); }

	Rect GetBounds() const		{ return Valid() ? (**fPixMap).bounds : Rect(CRect_AC::kZeroRect); }
	Ptr GetBaseAddr() const		{ return Valid() ? GetPixBaseAddr(fPixMap) : NULL; }
	bool Is32Bit() const		{ return Valid() ? PixMap32Bit(fPixMap) : false; }

	short GetDepth() const		{ return Valid() ? (**fPixMap).pixelSize : 0; }
	CTabHandle GetCTable() const	{ return Valid() ? (**fPixMap).pmTable : NULL; }

	BitMap* AsBitMap()			{ return Valid() ? reinterpret_cast<BitMap*>(*fPixMap) : NULL; }
	const BitMap* AsBitMap() const	{ return Valid() ? reinterpret_cast<BitMap*>(*fPixMap) : NULL; }
};


//========================================================================================
// CGWorld
//========================================================================================

class CGWorld
{
protected:
	GWorldPtr	fWorld;
	
public:
	CGWorld() : fWorld(NULL)	{ }
	CGWorld(GWorldPtr world) : fWorld(world)	{ }
	CGWorld(short pixelDepth, const Rect *boundsRect, CTabHandle colorTable,
		    GDHandle aGDevice, GWorldFlags flags);
	CGWorld(const Rect *boundsRect, GWorldFlags flags);
	
	~CGWorld()					{ }
	
	bool Exists() const			{ return (fWorld != NULL); }
		// Check if the GWorld exists. It's ok if it doesn't. 

#if qRangeCheck
	bool Valid() const;
#else
	bool Valid() const			{ return true; }
#endif
		// Check if the GWorld exists. Print a warning if it doesn't. 

	GWorldPtr release() const				{ GWorldPtr old = fWorld; const_cast<CGWorld*>(this)->fWorld = NULL; return old; }
	void reset()							{ Dispose(); }

	GWorldPtr get()							{ return Valid() ? fWorld : NULL; }
	const GWorldPtr get() const				{ return Valid() ? fWorld : NULL; }

	operator GWorldPtr()					{ return Valid() ? fWorld : NULL; }
	operator const GWorldPtr() const		{ return Valid() ? fWorld : NULL; }

	GWorldPtr operator ->()					{ return Valid() ? fWorld : NULL; }
	const GWorldPtr operator ->() const		{ return Valid() ? fWorld : NULL; }

	CGWorld& operator=(GWorldPtr world)		{ fWorld = world; return *this; }
	
	GrafPtr AsGrafPort()					{ return Valid() ? reinterpret_cast<GrafPtr>(fWorld) : NULL; }
	const GrafPtr AsGrafPort() const		{ return Valid() ? reinterpret_cast<GrafPtr>(fWorld) : NULL; }

	// From <QDOffscreen.h>

	QDErr New(short pixelDepth, const Rect *boundsRect, CTabHandle colorTable, GDHandle aGDevice, GWorldFlags flags);
	QDErr New(const Rect *boundsRect, GWorldFlags flags);
	
	GWorldFlags Update(short pixelDepth, const Rect *boundsRect, CTabHandle colorTable, GDHandle aGDevice, GWorldFlags flags);
	GWorldFlags Update(const Rect *boundsRect, GDHandle aGDevice, GWorldFlags flags);
	
	void Dispose();
		
	void Set()					{ if (Valid()) SetGWorld(fWorld, NULL); }
	
	GDHandle GetDevice() const	{ return Valid() ? GetGWorldDevice(fWorld) : NULL; }
	
	bool Done() const			{ return Valid() ? QDDone((GrafPtr) fWorld) : false; }
	
	PixMapHandle GetPixMap() const	{ return Valid() ? GetGWorldPixMap(fWorld) : NULL; }

	Rect GetBounds() const;
		
	void BitsAsRegion(RgnHandle rgn) const;
	PicHandle BitsAsPict(const RgnHandle pointsRgn) const;
	PicHandle BitsAsPict() const;

	short GetDepth() const;
	
	CTabHandle GetCTable() const;

	// Initialization for graphics operations
	void ClearPixMap();

	// Graphics operations
	void CopyWorldToPort(GrafPtr toPort, const CRect_AC& area) const;
	void CopyWorldToWorld(CGWorld toWorld, const CRect_AC& area) const;

	void CopyTo(GrafPtr toPort, const CRect_AC& srcRect, const CRect_AC& dstRect,
				short mode, const RgnHandle maskRgn) const;
	void CopyTo(CGWorld toWorld, const CRect_AC& srcRect, const CRect_AC& dstRect,
				short mode, const RgnHandle maskRgn) const;
	void CopyTo(BitMap *dstBits, const CRect_AC& srcRect, const CRect_AC& dstRect,
				short mode, const RgnHandle maskRgn) const;

	void Draw(const CRect_AC& srcRect, const MatrixRecord* matrix, short mode, 
			  RgnHandle mask, PixMapPtr matte, const Rect* matteRect, short flags) const;
};


//========================================================================================
// CTempGWorld
//========================================================================================

class CTempGWorld : public CGWorld
{
public:
	CTempGWorld() : CGWorld()	{ }
	CTempGWorld(GWorldPtr world) : CGWorld(world)	{ }
	CTempGWorld(CGWorld& world);
	CTempGWorld(short pixelDepth, const Rect *boundsRect, CTabHandle colorTable,
			    GDHandle aGDevice, GWorldFlags flags);
	CTempGWorld(const Rect *boundsRect, GWorldFlags flags);

	~CTempGWorld();

	CTempGWorld& operator=(GWorldPtr world);
	CTempGWorld& operator=(CGWorld& world);
};


//========================================================================================
// CSaveGWorld
//========================================================================================

class CSaveGWorld
{
protected:
	CGrafPtr		fSavedPort;
	GDHandle		fSavedDevice;

public:
	CSaveGWorld();
	CSaveGWorld(CGrafPtr port, GDHandle device);
	virtual ~CSaveGWorld();
};


//========================================================================================
// CQDContext
//========================================================================================

class CQDContext
{
protected:
	CGrafPtr		fSavePort;
	GDHandle		fSaveGD;
	CGWorld			fGWorld;
	bool			fUsingGWorld;

public:
	CQDContext(CGWorld itsWorld);
	CQDContext(GrafPtr itsPort);
	virtual ~CQDContext();
};


//========================================================================================
// CLockPixMap
//========================================================================================

class CLockPixMap : public CPixMap
{
protected:
	CGrafPtr		fSavedPort;
	GDHandle		fSavedDevice;

public:
	CLockPixMap(PixMapHandle pixMap);
	CLockPixMap(CGrafPtr port, GDHandle device);
	CLockPixMap(CGWorld world);

	virtual ~CLockPixMap();

	bool IsLocked() const	{ return (fPixMap != NULL); }
};


#endif // __CGraphicsWorld__