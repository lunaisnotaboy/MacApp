//----------------------------------------------------------------------------------------
// CTempPicture.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/15/00	CW Pro 6: Change CResourceReleaser to CPictureDeleter and the
							parameter from void** to PicHandle. 
		08/27/00	Initial version. 
*/

#ifndef __CTempPicture__
#include "CTempPicture.h"
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// Toolbox

// ANSI


//========================================================================================
// CPictureDeleter
//========================================================================================

//----------------------------------------------------------------------------------------
// DeleteRef
//----------------------------------------------------------------------------------------

void CPictureDeleter::DeleteRef(PicHandle thePicture)
{
	if (thePicture)
	{
#if qCoreDebug
		if (!IsHandle_AC(reinterpret_cast<Handle>(thePicture)))				// Test handlehood 
		{
			VerboseIsHandle_AC(reinterpret_cast<Handle>(thePicture));		// Get the diagnosis printed 
			::ProgramReport_AC("Trying to dispose an invalid picture handle %p\n", thePicture);
		}
		else
		{
			HGetState(reinterpret_cast<Handle>(thePicture));				// force subsequent MemError, if any
			if (IsHandlePurged_AC(reinterpret_cast<Handle>(thePicture)))	// h might have been purged 
				KillPicture(thePicture);
			else if (MemError() != noErr)
			{
				::ProgramReport_AC("Picture handle was so bad I couldn't even get the handle bits! %p\n", thePicture);
			}
			else if (IsAResource_AC(reinterpret_cast<Handle>(thePicture)))
			{
				::ProgramReport_AC("Trying to dispose a resource picture handle %p\n", thePicture);
			}
			else
				KillPicture(thePicture);
		}
#else
		KillPicture(thePicture);
#endif
	}
}

//========================================================================================
// CTempPicture
//========================================================================================


//========================================================================================
// CPictureReleaser
//========================================================================================

//----------------------------------------------------------------------------------------
// DeleteRef
//----------------------------------------------------------------------------------------

void CPictureReleaser::DeleteRef(PicHandle theResource)
{
	if (theResource)
	{
#if qCoreDebug
		if (!IsAResource_AC(reinterpret_cast<Handle>(theResource)))
		{
			::ProgramReport_AC("Trying to release a non-resource handle %p\n", theResource);
		}
		else
		{
			HGetState(reinterpret_cast<Handle>(theResource));				// force subsequent MemError, if any
			if (IsHandlePurged_AC(reinterpret_cast<Handle>(theResource)))	// h might have been purged 
				ReleaseResource(reinterpret_cast<Handle>(theResource));
			else if (MemError() != noErr)
			{
				::ProgramReport_AC("Resource handle was so bad I couldn't even get the handle bits! %p\n", theResource);
			}
			else
				ReleaseResource(reinterpret_cast<Handle>(theResource));
		}
#else
		ReleaseResource(reinterpret_cast<Handle>(theResource));
#endif
	}
}


//========================================================================================
// CTempPicture
//========================================================================================


//----------------------------------------------------------------------------------------
// End of CTempPicture.cpp
