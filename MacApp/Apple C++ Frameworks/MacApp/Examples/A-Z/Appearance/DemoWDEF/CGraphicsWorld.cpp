//----------------------------------------------------------------------------------------
// CGraphicsWorld.cpp
// Copyright � 1996-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		08/30/00	Carbon: CreateGrafPort and DisposeIfGrafPort are not supported
					for Carbon. Use accessor functions. 
		09/03/98	Allow specifying a NULL matteRect. 
		09/03/98	Add CTempGWorld. Add constructors that make a new graphics world. 
					Add Draw method. 
		08/04/98	QTClassLib. 
		06/20/98	Add CopyTo. Lock pixmaps before copying. 
					CLockPixMap now works on a CGWorld. 
		05/08/98	Added CopyWorldToWorld
		03/09/98	Use ProgramReport_AC instead of fprintf. 
					Add Exists method. 
		12/08/97	Uninlined constructors for debugging 
		11/26/97	Debugged region usage 
		11/20/97	Changed tools to use CTempRegion_AC 
*/

#ifndef __CGraphicsWorld__
#include "CGraphicsWorld.h"
#endif

// QTClassLib

#ifndef __CMatrix__
#include "CMatrix.h"
#endif

// ACS

// Toolbox

//----------------------------------------------------------------------------------------
// Constants:
//----------------------------------------------------------------------------------------

//========================================================================================
// Global Functions
//========================================================================================

#if !OPAQUE_TOOLBOX_STRUCTS
//----------------------------------------------------------------------------------------
// CreateGrafPort 
//----------------------------------------------------------------------------------------

GrafPtr CreateGrafPort(const CRect_AC& bounds)
// Create basic B/W port
{
	// Allocate a new GrafPort.
	GrafPtr newPort = reinterpret_cast<GrafPtr>(NewPtrClear(sizeof(GrafPort)));
	ThrowIfNULL_AC(newPort);
	
	// Set the top-left corner of bounds to (0,0).
	CRect_AC localBounds(CPoint_AC::kZeroPt, bounds.GetSize());

	// Initialize and allocate the bitmap.
	short rowBytes = ((localBounds.right + 15) >> 4) << 1;
	Ptr baseAddr = NewPtrClear(rowBytes * localBounds.bottom);
	if (!baseAddr)
	{
		// Allocation failed; deallocate the port.
		newPort = reinterpret_cast<GrafPtr>(DisposeIfPtr_AC(reinterpret_cast<Ptr>(newPort)));
		ThrowIfNULL_AC(baseAddr);
	}
	else
	{
		GrafPtr	savedPort;
		GetPort(&savedPort);
	
		// Initialize the new port and make the current port.
		OpenPort(newPort);

		// Clean up the new port.
		newPort->portBits.bounds = localBounds;
		newPort->portBits.rowBytes = rowBytes;
		newPort->portBits.baseAddr = baseAddr;
		newPort->portRect = localBounds;
		ClipRect(localBounds);
		RectRgn(newPort->visRgn, localBounds);
		EraseRect(localBounds);
		
		SetPort(savedPort);
	}
	
	return newPort;
}

//----------------------------------------------------------------------------------------
// DisposeIfGrafPort
//----------------------------------------------------------------------------------------

GrafPtr DisposeIfGrafPort(GrafPtr port)
{
	if (port)
	{
		ClosePort(port);
		port->portBits.baseAddr = DisposeIfPtr_AC(port->portBits.baseAddr);
		port = reinterpret_cast<GrafPtr>(DisposeIfPtr_AC(reinterpret_cast<Ptr>(port)));
	}
	return port;
}
#endif // !OPAQUE_TOOLBOX_STRUCTS

//----------------------------------------------------------------------------------------
// GetRegionBounds
//----------------------------------------------------------------------------------------

inline Rect GetRegionBounds(RgnHandle region)
{
#if OPAQUE_TOOLBOX_STRUCTS
	Rect bounds;
	::GetRegionBounds(region, &bounds);
	return bounds;
#else
	return (**region).rgnBBox;
#endif
}

#if !ACCESSOR_CALLS_ARE_FUNCTIONS
//----------------------------------------------------------------------------------------
// GetPortBitMap
//----------------------------------------------------------------------------------------

inline BitMap* GetPortBitMap(CGrafPtr port)
{
	return &reinterpret_cast<GrafPtr>(port)->portBits;
}

inline BitMap* GetPortBitMap(GrafPtr port)
{
	return &port->portBits;
}

#else

inline BitMap* GetPortBitMap(CGrafPtr port)
{
	return const_cast<BitMap*>(GetPortBitMapForCopyBits(port));
}

#endif // !ACCESSOR_CALLS_ARE_FUNCTIONS

//========================================================================================
// CPixMap
//========================================================================================

#if qRangeCheck
//----------------------------------------------------------------------------------------
// Valid
//----------------------------------------------------------------------------------------

bool CPixMap::Valid() const
{
	bool valid = Exists();

	// ����Could do more validity checking here ���

	if (!valid)
	{
#if qDebugMsg
		ProgramReport_AC(false, "PixMap @ %x is invalid\n", this);
#endif
	}
	return valid;
}
#endif // qRangeCheck


//========================================================================================
// CGWorld
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CGWorld::CGWorld(short pixelDepth, const Rect *boundsRect, CTabHandle colorTable,
				 GDHandle aGDevice, GWorldFlags flags) :
	fWorld(NULL)
{
	ThrowIfOSErr_AC( New(pixelDepth, boundsRect, colorTable, aGDevice, flags) );
}

CGWorld::CGWorld(const Rect *boundsRect, GWorldFlags flags) :
	fWorld(NULL)
{
	ThrowIfOSErr_AC( New(boundsRect, flags) );
}

//----------------------------------------------------------------------------------------
// New
//----------------------------------------------------------------------------------------

QDErr CGWorld::New(short pixelDepth, const Rect *boundsRect, CTabHandle colorTable, GDHandle aGDevice, GWorldFlags flags)
{
	return NewGWorld(&fWorld, pixelDepth, boundsRect, colorTable, aGDevice, flags);
}

QDErr CGWorld::New(const Rect *boundsRect, GWorldFlags flags)
{
	return NewGWorld(&fWorld, 0, boundsRect, NULL, NULL, flags);
}

GWorldFlags CGWorld::Update(short pixelDepth, const Rect *boundsRect, CTabHandle colorTable, GDHandle aGDevice, GWorldFlags flags)
{
	return Valid() ? UpdateGWorld(&fWorld, pixelDepth, boundsRect, colorTable, aGDevice, flags) : 0;
}

GWorldFlags CGWorld::Update(const Rect *boundsRect, GDHandle aGDevice, GWorldFlags flags)
{
	return Valid() ? UpdateGWorld(&fWorld, 0, boundsRect, NULL, aGDevice, flags) : 0;
}

//----------------------------------------------------------------------------------------
// Dispose
//----------------------------------------------------------------------------------------

void CGWorld::Dispose()
{
	if (Exists())
	{
		if (Valid())
			DisposeGWorld(fWorld);

		fWorld = NULL;
	}
}

#if qRangeCheck
//----------------------------------------------------------------------------------------
// Valid
//----------------------------------------------------------------------------------------

bool CGWorld::Valid() const
{
	bool valid = Exists();

	// ����Could do more validity checking here ���

	if (!valid)
	{
#if qDebugMsg
		ProgramReport_AC(false, "GWorld @ %x is invalid\n", this);
#endif
	}
	return valid;
}
#endif // qRangeCheck

//----------------------------------------------------------------------------------------
// ClearPixMap
//----------------------------------------------------------------------------------------

void CGWorld::ClearPixMap()
{
	if (Valid())
	{
		CLockPixMap pixMap(*this);
		if (pixMap.IsLocked())
		{
			RGBBackColor(CRGBColor_AC::kRGBWhite);
			RGBForeColor(CRGBColor_AC::kRGBBlack);
			CRect_AC sourceRect(pixMap.GetBounds());
			EraseRect(sourceRect);
		}
	}
}

//----------------------------------------------------------------------------------------
// GetBounds
//----------------------------------------------------------------------------------------

Rect CGWorld::GetBounds() const
{
	return Valid() ? CPixMap(GetPixMap()).GetBounds() : Rect(CRect_AC::kZeroRect);
}


//----------------------------------------------------------------------------------------
// BitsAsRegion 
//----------------------------------------------------------------------------------------

void CGWorld::BitsAsRegion(RgnHandle rgn) const
{
	BitMapToRegion(rgn, CPixMap(GetPixMap()).AsBitMap());
}

//----------------------------------------------------------------------------------------
// BitsAsPict 
//----------------------------------------------------------------------------------------

PicHandle CGWorld::BitsAsPict(const RgnHandle pointsRgn) const
{
	PicHandle pictData = NULL;
	if (Valid())
	{
		const Fixed kFixed72 = 0x00480000;
		CRect_AC pointsRect = GetRegionBounds(pointsRgn);
		
		CTempRegion_AC saveClip;
		GetClip(saveClip);
		ClipRect(&pointsRect);
		
		OpenCPicParams newHeader;
		newHeader.srcRect = pointsRect;
		newHeader.hRes = kFixed72;
		newHeader.vRes = kFixed72;
		newHeader.version = -2;
		newHeader.reserved1 = 0;
		newHeader.reserved2 = 0;
		pictData = OpenCPicture(&newHeader);
		{
			GrafPtr port;
			GetPort(&port);
			CopyTo(GetPortBitMap(port), pointsRect, pointsRect, srcCopy, pointsRgn);
		}

		ClosePicture();

		SetClip(saveClip);
	}
	return pictData;
}

//----------------------------------------------------------------------------------------
// BitsAsPict
//----------------------------------------------------------------------------------------

PicHandle CGWorld::BitsAsPict() const
{
	PicHandle pictData = NULL;
	if (Valid())
	{
		CTempRegion_AC frameRgn(GetBounds());
		pictData = BitsAsPict(frameRgn);
	}
	return pictData;
}

//----------------------------------------------------------------------------------------
// GetDepth
//----------------------------------------------------------------------------------------

short CGWorld::GetDepth() const
{
	return Valid() ? CPixMap(GetPixMap()).GetDepth() : 0;
}

//----------------------------------------------------------------------------------------
// GetCTable
//----------------------------------------------------------------------------------------

CTabHandle CGWorld::GetCTable() const
{
	return Valid() ? CPixMap(GetPixMap()).GetCTable() : NULL;
}

//----------------------------------------------------------------------------------------
// CopyWorldToPort
//----------------------------------------------------------------------------------------

void CGWorld::CopyWorldToPort(GrafPtr toPort, const CRect_AC& area) const
{
	CopyTo(toPort, area, area, srcCopy, nil);
}

//----------------------------------------------------------------------------------------
// CopyWorldToWorld
//----------------------------------------------------------------------------------------

void CGWorld::CopyWorldToWorld(CGWorld toWorld, const CRect_AC& area) const
{
	CopyTo(toWorld, area, area, srcCopy, nil);
}

//----------------------------------------------------------------------------------------
// CopyTo
//----------------------------------------------------------------------------------------

void CGWorld::CopyTo(GrafPtr toPort, const CRect_AC& srcRect, const CRect_AC& dstRect,
					 short mode, const RgnHandle maskRgn) const
{
	BitMap* dstBits = GetPortBitMap(toPort);
	CopyTo(dstBits, srcRect, dstRect, mode, maskRgn);
}

//----------------------------------------------------------------------------------------
// CopyTo
//----------------------------------------------------------------------------------------

void CGWorld::CopyTo(CGWorld toWorld, const CRect_AC& srcRect, const CRect_AC& dstRect,
					 short mode, const RgnHandle maskRgn) const
{
	CLockPixMap toPMap(toWorld);
	CopyTo(toPMap.AsBitMap(), srcRect, dstRect, mode, maskRgn);
}

//----------------------------------------------------------------------------------------
// CopyTo
//----------------------------------------------------------------------------------------

void CGWorld::CopyTo(BitMap *dstBits, const CRect_AC& srcRect, const CRect_AC& dstRect,
					 short mode, const RgnHandle maskRgn) const
{
	RGBForeColor(CRGBColor_AC::kRGBBlack);
	RGBBackColor(CRGBColor_AC::kRGBWhite);
	PenNormal();
	CLockPixMap fromPMap(GetPixMap());
	CopyBits(fromPMap.AsBitMap(), dstBits, srcRect, dstRect, mode, maskRgn);
}

//----------------------------------------------------------------------------------------
// Draw
//----------------------------------------------------------------------------------------

void CGWorld::Draw(const CRect_AC& srcRect, const MatrixRecord* matrix, short mode, 
				   RgnHandle mask, PixMapPtr matte, const Rect* matteRect, short flags) const
{
	CLockPixMap fromPMap(GetPixMap());
	CMatrix safeMatrix(*matrix);	// StdPix matrix param is not const, so don't trust it
	StdPix(*fromPMap, srcRect, safeMatrix, mode, mask, matte, matteRect, flags);
}


//========================================================================================
// CTempGWorld
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CTempGWorld::CTempGWorld(CGWorld& world) :
	CGWorld(world.release())
{
}

CTempGWorld::CTempGWorld(short pixelDepth, const Rect *boundsRect, CTabHandle colorTable,
						 GDHandle aGDevice, GWorldFlags flags) :
	CGWorld(pixelDepth, boundsRect, colorTable, aGDevice, flags)
{
}

CTempGWorld::CTempGWorld(const Rect *boundsRect, GWorldFlags flags) :
	CGWorld(boundsRect, flags)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CTempGWorld::~CTempGWorld()
{
	reset();
}

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

CTempGWorld& CTempGWorld::operator=(GWorldPtr world)
{
	if (fWorld != world)
	{
		reset();
		fWorld = world;
	}
	
	return *this;
}

CTempGWorld& CTempGWorld::operator=(CGWorld& world)
{
	reset();
	fWorld = world.release();
	return *this;
}


//========================================================================================
// CSaveGWorld
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

CSaveGWorld::CSaveGWorld()
{
	GetGWorld(&fSavedPort, &fSavedDevice);
}

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

CSaveGWorld::CSaveGWorld(CGrafPtr port, GDHandle device)
{
	GetGWorld(&fSavedPort, &fSavedDevice);
	SetGWorld(port, device);
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CSaveGWorld::~CSaveGWorld()
{
	SetGWorld(fSavedPort, fSavedDevice);
}


//========================================================================================
// CQDContext
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

CQDContext::CQDContext(CGWorld itsWorld)
{
	fSavePort = NULL;
	fSaveGD = NULL;
	fGWorld = itsWorld;
	fUsingGWorld = true;
	
	CPixMap pMap = fGWorld.GetPixMap();
	GetGWorld(&fSavePort, &fSaveGD);
	fGWorld.Set();
	if (pMap.Lock())
	{
		return; 
	}
	else
	{
		pMap.Unlock();
		ThrowIfOSErr_AC(editingNotAllowed);
	}
	
}

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

CQDContext::CQDContext(GrafPtr itsPort)
{
	fSavePort = NULL;
	fSaveGD = NULL;
	fUsingGWorld = false;
	
	GetGWorld(&fSavePort, &fSaveGD);
	SetPort(itsPort);		
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CQDContext::~CQDContext()
{
	if (fUsingGWorld)
	{
		CPixMap(fGWorld.GetPixMap()).Unlock();
		fGWorld = NULL;
		SetGWorld(fSavePort, fSaveGD);
	}
	else
	{
		SetGWorld(fSavePort, fSaveGD);
	}
}


//========================================================================================
// CLockPixMap
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

CLockPixMap::CLockPixMap(PixMapHandle pixMap) :
	CPixMap(pixMap),
	fSavedPort(NULL),
	fSavedDevice(NULL)
{
	if (!Lock())
		fPixMap = NULL;
}

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

CLockPixMap::CLockPixMap(CGrafPtr port, GDHandle device) :
	CPixMap(NULL),
	fSavedPort(NULL),
	fSavedDevice(NULL)
{
	GetGWorld(&fSavedPort, &fSavedDevice);
	SetGWorld(port, device);
	fPixMap = CGWorld(port).GetPixMap();
	if (!Lock())
		fPixMap = NULL;
}

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

CLockPixMap::CLockPixMap(CGWorld world) :
	CPixMap(world.GetPixMap()),
	fSavedPort(NULL),
	fSavedDevice(NULL)
{
	GetGWorld(&fSavedPort, &fSavedDevice);
	world.Set();
	if (!Lock())
		fPixMap = NULL;
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CLockPixMap::~CLockPixMap()
{
	if (fPixMap)
		Unlock();

	if (fSavedPort)
		SetGWorld(fSavedPort, fSavedDevice);
}


//----------------------------------------------------------------------------------------
// End of CGraphicsWorld.cpp
