//----------------------------------------------------------------------------------------
// UCardDocument.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		03/27/01	Fix read code for fCardName. 
		01/02/01	Update copyright.
		12/21/00	Use string instead of CStr255_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __UCARDDOCUMENT__
#include "UCardDocument.h"
#endif

// Card

#ifndef __CARD__
#include "Card.r.h"
#endif

#ifndef __UCARDCOMMAND__
#include "UCardCommand.h"
#endif

#ifndef __UCARDVIEW__
#include "UCardView.h"
#endif

#ifndef __UDATABASEFILE__
#include "UDatabaseFile.h"
#endif

#ifndef __UMOREDEBUG__
#include "UMoreDebug.h"
#endif

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDIALOG__
#include "UDialog.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UNUMBERTEXT__
#include "UNumberText.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif


//========================================================================================
// GLOBAL Functions
//========================================================================================
#undef Inherited

void StuffTextAndSynch(TTEView* textView, Handle text);

//----------------------------------------------------------------------------------------
// InitUCardDocument: 
//----------------------------------------------------------------------------------------
#pragma segment AInit
		
void InitUCardDocument()
{
	InitUDialog();
	InitUCardView();
}

//----------------------------------------------------------------------------------------
// StuffTextAndSynch: 
//----------------------------------------------------------------------------------------
#pragma segment MASelCommand

void StuffTextAndSynch(TTEView* textView, Handle text)
{
	ThrowIfNonObject_AC(textView);

	textView->StuffText(text);
	textView->SetSelection(0, 0, kRedraw);
	textView->SynchView(kDontRedraw);
	textView->ViewEnable(true, kDontRedraw);
	//textView->SetDraggable(true);
	textView->ForceRedraw();
}

//========================================================================================
// CLASS TCardDocument
//========================================================================================
#undef Inherited
#define Inherited TDatabaseDocument

//----------------------------------------------------------------------------------------
// TCardDocument constructor 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

TCardDocument::TCardDocument(TFile* itsFile, OSType itsScrapType) :
	TDatabaseDocument(itsFile, itsScrapType, kFileType),
	fCardIndex(0),
	fNumberOfCards(0),
	fCardWindow(NULL),
	fCardID(0),
	fResponsibilities(NULL),
	fCollaborators(NULL),
	fOwnText(true)
{
}

//----------------------------------------------------------------------------------------
// TCardDocument destructor
//----------------------------------------------------------------------------------------
#pragma segment AClose

TCardDocument::~TCardDocument()
{
	if (fOwnText)
	{
		fResponsibilities = DisposeIfHandle_AC(fResponsibilities);
		fCollaborators = DisposeIfHandle_AC(fCollaborators);
	}
}

//----------------------------------------------------------------------------------------
// TCardDocument::FreeData: 
//----------------------------------------------------------------------------------------
#pragma segment AClose

void TCardDocument::FreeData()
{
	fCardID = 0;
	fCardName.empty();
	if (fOwnText)
	{
		fResponsibilities = DisposeIfHandle_AC(fResponsibilities);
		fCollaborators = DisposeIfHandle_AC(fCollaborators);
	}
	else
	{
		fResponsibilities = NULL;
		fCollaborators = NULL;
	}

	Inherited::FreeData();
}

//----------------------------------------------------------------------------------------
// TCardDocument::DoMakeViews: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TCardDocument::DoMakeViews(bool forPrinting)
{
#pragma unused (forPrinting)

	fCardWindow = gViewServer->NewTemplateWindow(kCardWindowID, this);
	ThrowIfNULL_AC(fCardWindow);

	TStdPrintHandler* aHandler = TH_new TStdPrintHandler(this, fCardWindow, kFixedSize, kFixedSize);

	StuffViews();
}

//----------------------------------------------------------------------------------------
// TCardDocument::StuffViews: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TCardDocument::StuffViews()
{
	if (fCardWindow)
	{
		TNumberText* cardNumber = static_cast_AC(TNumberText*, fCardWindow->FindSubView('card'));
		if (cardNumber)
			cardNumber->SetValue(fCardID, kDontRedraw);

		TEditText* cardName = static_cast_AC(TEditText*, fCardWindow->FindSubView('clas'));
		if (cardName)
			cardName->SetText(fCardName, kDontRedraw);

		TTEView* responsibilities = static_cast_AC(TTEView*, fCardWindow->FindSubView('resp'));
		if (responsibilities)
		{
			StuffTextAndSynch(responsibilities, fResponsibilities);
			fOwnText = false;
		}

		TTEView* collaborators = static_cast_AC(TTEView*, fCardWindow->FindSubView('cola'));
		if (collaborators)
		{
			StuffTextAndSynch(collaborators, fCollaborators);
			fOwnText = false;
		}
	}
}

//----------------------------------------------------------------------------------------
// TCardDocument::ExtractViews: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TCardDocument::ExtractViews()
{
	if (fCardWindow)
	{
		TEditText* cardName = static_cast_AC(TEditText*, fCardWindow->FindSubView('clas'));
		if (cardName)
			cardName->GetText(fCardName);
	}
}

//----------------------------------------------------------------------------------------
// TCardDocument::DeleteWindow: 
//----------------------------------------------------------------------------------------
#pragma segment AClose

void TCardDocument::DeleteWindow(TWindow* windowToDelete)
{
	if (windowToDelete == fCardWindow)
		fCardWindow = NULL;

	Inherited::DeleteWindow(windowToDelete);
}

//----------------------------------------------------------------------------------------
// TCardDocument::CloseWindow
//----------------------------------------------------------------------------------------
#pragma segment ASelCommand

void TCardDocument::CloseWindow(TWindow* aWindow)
{
	// Work around a bug in MacApp where it is not looking at fClosesDocument. 
	// I suspect the bug is there because if a document has multiple windows open,
	// closing the document without first closing all the other windows may cause
	// some problem -- hopefully it's just with recording. 

	if (aWindow && (aWindow->GetDocument() == this) && aWindow->GetClosesDocument())
	{
		enum { kDontUseAppleEvent = false };
		DoClose(cClose, kDontUseAppleEvent);	// The window will be closed and freed as a side effect
	}
	else
		Inherited::CloseWindow(aWindow);
}

//----------------------------------------------------------------------------------------
// TCardDocument::DoRead: 
//----------------------------------------------------------------------------------------
#pragma segment AReadFile

void TCardDocument::DoReadDatabase(TDatabaseFile* database, bool forPrinting)
{
#pragma unused (forPrinting)

	// Read the first card, if there is one
	fNumberOfCards = CountCards(database);
	GoCard(1);
}

//----------------------------------------------------------------------------------------
// TCardDocument::CountCards: 
//----------------------------------------------------------------------------------------
#pragma segment AReadFile

long TCardDocument::CountCards(TDatabaseFile* database)
{
	ThrowIfNonObject_AC(database);
	return database->CountItems('clas');
}

//----------------------------------------------------------------------------------------
// TCardDocument::ReadCard: 
//----------------------------------------------------------------------------------------
#pragma segment AReadFile

void TCardDocument::ReadCard(TDatabaseFile* database, long cardID)
{
	ThrowIfNonObject_AC(database);

	FreeData();

	if (cardID)
	{
#if 0
		database->ReadItem('clas', cardID, &fCardName, sizeof(fCardName), NULL);
#else
		{
			CTempHandle_AC cardName = database->ReadItem('clas', cardID);
			HLock(cardName);
			CString_AC::size_type n = GetHandleSize(cardName);
			fCardName.assign(*cardName, n);
		}
#endif

		if (database->FindItem('resp', cardID))
			fResponsibilities = database->ReadItem('resp', cardID);

		if (database->FindItem('cola', cardID))
			fCollaborators = database->ReadItem('cola', cardID);
		
		fCardID = cardID;
	}

	if (!fResponsibilities)
	{
		fResponsibilities = NewPermHandle(0);
		ThrowIfNULL_AC(fResponsibilities);
	}
	
	if (!fCollaborators)
	{
		fCollaborators = NewPermHandle(0);
		ThrowIfNULL_AC(fCollaborators);
	}
	
	fOwnText = true;
}

//----------------------------------------------------------------------------------------
// TCardDocument::DoSaveData: 
//----------------------------------------------------------------------------------------
#pragma segment AWriteFile

void TCardDocument::DoSaveData(TDatabaseFile* database, bool makingCopy)
{
	if (/*IsChanged() && */ fCardID)
	{
		ExtractViews();
		WriteCard(database, fCardID);

		if (!makingCopy)
		{
			// Update the count because we may have just added a new card to the database
			fNumberOfCards = CountCards(database);
		}
	}
}

//----------------------------------------------------------------------------------------
// TCardDocument::WriteCard: 
//----------------------------------------------------------------------------------------
#pragma segment AWriteFile

void TCardDocument::WriteCard(TDatabaseFile* database, long cardID)
{
	ThrowIfNonObject_AC(database);
	DebugAssert(cardID != 0, "");

	database->WriteItem('clas', cardID, fCardName.c_str(), fCardName.size() + 1);
	database->WriteItem('resp', cardID, fResponsibilities);
	database->WriteItem('cola', cardID, fCollaborators);
	database->WriteDirectory();
}

//----------------------------------------------------------------------------------------
// TCardDocument::DoSetupMenus: This method is overridden to enable menu items which
// should be enabled when this object is in the target chain. MacApp initially disables
// all menu items, then lets the objects in the target chain enable those items they
// handle.
//
// A document object is in the target chain when its window is the active window.
//
// The inherited method is called so that TDocument can enable document-level menu items
// like "Save ". This also ensures that objects further up the target chain (the
// application) can set up THEIR menus.
//----------------------------------------------------------------------------------------
#pragma segment ARes

void TCardDocument::DoSetupMenus()
{
	Inherited::DoSetupMenus();
	
	Enable(cNewCard, (fCardIndex > 0) && (fCardIndex <= fNumberOfCards));
	Enable(cDeleteCard, (fCardIndex > 0) && (fCardIndex <= fNumberOfCards));
	Enable(cGoFirstCard, (fCardIndex > 1));
	Enable(cGoPreviousCard, (fCardIndex > 1));
	Enable(cGoNextCard, (fCardIndex < fNumberOfCards));
	Enable(cGoLastCard, (fCardIndex < fNumberOfCards));
}

//----------------------------------------------------------------------------------------
// TCardDocument::DoMenuCommand: This method is overridden to handle menu items which
// are enabled when this document is in the target chain. In this example, this is true
// when the document is open and its window is the active window. The inherited method
// should always be called so that MacApp can allow successor objects in the target chain
// (i.e. the application) to handle THEIR menu items.
//----------------------------------------------------------------------------------------
#pragma segment ASelCommand

void TCardDocument::DoMenuCommand(CommandNumber aCommandNumber)
{
	switch (aCommandNumber) 
	{
		case cNewCard:
			PostCommand(TH_new TNewCardCommand(aCommandNumber, this));
			break;

		case cDeleteCard:
			PostCommand(TH_new TDeleteCardCommand(aCommandNumber, this));
			break;

		case cGoFirstCard:
			PostCommand(TH_new TGoCardCommand(aCommandNumber, this, 1));
			break;

		case cGoPreviousCard:
			PostCommand(TH_new TGoCardCommand(aCommandNumber, this, fCardIndex - 1));
			break;

		case cGoNextCard:
			PostCommand(TH_new TGoCardCommand(aCommandNumber, this, fCardIndex + 1));
			break;

		case cGoLastCard:
			PostCommand(TH_new TGoCardCommand(aCommandNumber, this, fNumberOfCards));
			break;

		default:
			Inherited::DoMenuCommand(aCommandNumber);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TCardDocument::NewCard: 
//----------------------------------------------------------------------------------------
#pragma segment ADoCommand

void TCardDocument::NewCard()
{
	if (IsChanged())
		SaveDocument(cSave);
	
	FreeData();
	
	if (!fResponsibilities)
	{
		fResponsibilities = NewPermHandle(0);
		ThrowIfNULL_AC(fResponsibilities);
	}
	
	if (!fCollaborators)
	{
		fCollaborators = NewPermHandle(0);
		ThrowIfNULL_AC(fCollaborators);
	}
	
	fOwnText = true;

	TDatabaseFile* database = dynamic_cast_AC(TDatabaseFile*, fFile.get());
	ThrowIfNonObject_AC(database);

	fCardID = database->UniqueItemID('clas');
	fCardIndex = fNumberOfCards + 1;

	StuffViews();
}

//----------------------------------------------------------------------------------------
// TCardDocument::DeleteCard: 
//----------------------------------------------------------------------------------------
#pragma segment ADoCommand

void TCardDocument::DeleteCard()
{
	TDatabaseFile* database = dynamic_cast_AC(TDatabaseFile*, fFile.get());
	ThrowIfNonObject_AC(database);

	DebugAssert(fCardID != 0, "");

	database->DeleteItem('clas', fCardID);
	database->DeleteItem('resp', fCardID);
	database->DeleteItem('cola', fCardID);
	database->WriteDirectory();

	fNumberOfCards = database->CountItems('clas');
	long index = (fCardIndex <= fNumberOfCards) ? fCardIndex : 1;
	GoCard(index);
}

//----------------------------------------------------------------------------------------
// TCardDocument::GoCard: 
//----------------------------------------------------------------------------------------
#pragma segment ADoCommand

void TCardDocument::GoCard(long index)
{
	if (IsChanged())
		SaveDocument(cSave);
	
	TDatabaseFile* database = dynamic_cast_AC(TDatabaseFile*, fFile.get());
	ThrowIfNonObject_AC(database);

	long cardID = 0;
	if ((index > 0) && (index <= fNumberOfCards))
		cardID = database->GetIndItemID('clas', index);

	ReadCard(database, cardID);

	if (fCardID)
	{
		fCardIndex = index;
	}
	else
	{
		// No card to go to, make a blank new one
		fCardID = database->UniqueItemID('clas');
		fCardIndex = fNumberOfCards + 1;
	}

	StuffViews();
}


//----------------------------------------------------------------------------------------
// End of UCardDocument.cpp

#pragma segment Inline
