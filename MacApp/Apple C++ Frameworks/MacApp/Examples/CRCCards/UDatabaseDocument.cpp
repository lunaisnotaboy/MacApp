//----------------------------------------------------------------------------------------
// UDatabaseDocument.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/17/01	DoNeedDiskSpace, GetDatabaseFile are now const.  Cosmetic
					cleanup.
		01/02/01	Update copyright.
		12/08/99	Catch and handle exception in CreateDatabase.
		09/20/99	Use dynamic_cast_AC instead of MA_MEMBER. 
		04/05/99	Renamed DeleteFile and CreateFile to DeleteCFile and CreateCFile.
		03/24/99	Update copyright notice.
*/

#ifndef __UDATABASEDOCUMENT__
#include "UDatabaseDocument.h"
#endif

// Database

#ifndef __UDATABASEFILE__
#include "UDatabaseFile.h"
#endif

#ifndef __UMOREDEBUG__
#include "UMoreDebug.h"
#endif

// MacApp

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif


//========================================================================================
// GLOBAL Functions
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// InitUDatabaseDocument: 
//----------------------------------------------------------------------------------------
#pragma segment AInit
		
void InitUDatabaseDocument()
{
}

//========================================================================================
// CLASS TDatabaseDocument
//========================================================================================
#undef Inherited
#define Inherited TFileBasedDocument

//----------------------------------------------------------------------------------------
// TDatabaseDocument constructor 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

TDatabaseDocument::TDatabaseDocument(TFile* itsFile, OSType itsScrapType,
									 OSType itsFileType) :
	TFileBasedDocument(itsFile, itsScrapType),
	fFileType(itsFileType)
{
	// Fix up superclass settings more to our liking
	
	fAskOnClose = FALSE;		// always save without asking the user
	fHowToSave = sipAlways;		// always save in place
	
	// TDatabaseDocument stuff goes here
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument destructor
//----------------------------------------------------------------------------------------
#pragma segment AClose

TDatabaseDocument::~TDatabaseDocument()
{
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoInitialState: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TDatabaseDocument::DoInitialState()
{
	// Create a disk file whenever we create a new document
	DebugFailNonObject(fFile.get());	// fFile was created for us by IFileBasedDocument
	DebugFailNonMember(fFile.get(), TDatabaseFile);
	DebugAssert(!fFileExists, "");	// New document shouldn't already have a disk file
	DebugAssert(fFile->GetRsrcRefNum() == kNoFileRefNum_AC, "");	// Shouldn't be already open

	CreateDatabase();
	
	// Flush the volume buffer so the database modification date will be updated
	// on disk now, before ReadDocument calls Modified. This gets rid of an annoying
	// "changed since the last time you opened" alert. 
	OSErr flushErr = fFile->FlushVolume();

	// Use the normal path to open and read in the database
	ReadDocument(kForDisplay);
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoNeedDiskSpace: 
//----------------------------------------------------------------------------------------
#pragma segment AWriteFile

void TDatabaseDocument::DoNeedDiskSpace(TFile* itsFile, long& dataForkBytes,
										long& rsrcForkBytes) const
{
	Inherited::DoNeedDiskSpace(itsFile, dataForkBytes, rsrcForkBytes);

	// Add the existing file size (not the size of the file we're saving to). 
	if (fFile)
	{
		TDatabaseFile* database = GetDatabaseFile();
		ThrowIfNonObject_AC(database);
		dataForkBytes += database->DoNeedDiskSpace();
	}
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::SaveOver: 
//----------------------------------------------------------------------------------------

void TDatabaseDocument::SaveOver()
{
	// Don't set position or truncate. 

	fFile->SetPermissions(fsRdWrPerm, fsRdWrPerm);// Since we intend to write to it 
	ThrowIfOSErr_AC(fFile->OpenFile());

	DoWrite(fFile, false);	// we're clearly not making a copy

	ThrowIfOSErr_AC(fFile->CloseFileIfNotKeptOpen());
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoRead: 
//----------------------------------------------------------------------------------------
#pragma segment AReadFile

void TDatabaseDocument::DoRead(TFile* aFile, bool forPrinting)
{
	Inherited::DoRead(aFile, forPrinting);

	TDatabaseFile* database = dynamic_cast_AC(TDatabaseFile*, aFile);
	ThrowIfNonObject_AC(database);
	DoReadDatabase(database, forPrinting);
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoReadPrintInfo: 
//----------------------------------------------------------------------------------------
#pragma segment AReadFile

void TDatabaseDocument::DoReadPrintInfo(TFile* aFile, bool forPrinting)
{
	if (FileExists())
	{
		if (aFile->HasRsrcFork())
		{
			// The print handler can read print info from resources
			Inherited::DoReadPrintInfo(aFile, forPrinting);
		}
		else
		{
			// Read the print info from the database
		}
	}
}

#if qAttachable
//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoReadScript: 
//----------------------------------------------------------------------------------------
#pragma segment AReadFile

void TDatabaseDocument::DoReadScript(TFile* aFile, bool forPrinting)
{
	if (HasAppleScript_AC() && FileExists())
	{
		if (aFile->HasRsrcFork())
		{
			// The document can read the script from a resource
			Inherited::DoReadScript(aFile, forPrinting);
		}
		else
		{
			// Read the script from the database
		}
	}
}
#endif

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoWrite: 
//----------------------------------------------------------------------------------------
#pragma segment AWriteFile

void TDatabaseDocument::DoWrite(TFile* aFile, bool makingCopy)
{
	Inherited::DoWrite(aFile, makingCopy);

	TDatabaseFile* aDatabase = dynamic_cast_AC(TDatabaseFile*, aFile);
	ThrowIfNonObject_AC(aDatabase);

	if (!aFile->IsSameFile(fFile))
	{
		TDatabaseFile* fromDatabase = GetDatabaseFile();
		ThrowIfNonObject_AC(fromDatabase);

		aDatabase->CopyDatabase(fromDatabase);
		aDatabase->WriteDirectory();
	}

	DoSaveData(aDatabase, makingCopy);
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoWritePrintInfo: 
//----------------------------------------------------------------------------------------
#pragma segment AWriteFile

void TDatabaseDocument::DoWritePrintInfo(TFile* aFile, bool makingCopy)
{
	if (aFile->HasRsrcFork())
	{
		// The print handler can write print info to resources
		Inherited::DoWritePrintInfo(aFile, makingCopy);
	}
	else
	{
		// Write the print info to the database
	}
}

#if qAttachable
//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoWriteScript: 
//----------------------------------------------------------------------------------------
#pragma segment AWriteFile

void TDatabaseDocument::DoWriteScript(TFile* aFile, bool makingCopy)
{
	if (HasOSAScript() && FileExists())
	{
		if (aFile->HasRsrcFork())
		{
			// The document can write the script to a resource
			Inherited::DoWriteScript(aFile, makingCopy);
		}
		else
		{
			// Write the script to the database
		}
	}
}
#endif

//----------------------------------------------------------------------------------------
// TDatabaseDocument::CreateDatabase: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TDatabaseDocument::CreateDatabase()
{
	try
	{
		CreateFile();
		InitializeDatabase();
	}
	catch (CException_AC& ex)
	{
		DoCatchMessage_AC(ex);
		CloseFile();
		throw;
	}
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::InitializeDatabase: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TDatabaseDocument::InitializeDatabase()
{
	TDatabaseFile* database = GetDatabaseFile();
	ThrowIfNonObject_AC(database);

	database->WriteDirectory();
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoReadDatabase: 
//----------------------------------------------------------------------------------------
#pragma segment AWriteFile

void TDatabaseDocument::DoReadDatabase(TDatabaseFile* database, bool forPrinting)
{
#pragma unused (database, forPrinting)

	// Override to read your data. 
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoSaveData: 
//----------------------------------------------------------------------------------------
#pragma segment AWriteFile

void TDatabaseDocument::DoSaveData(TDatabaseFile* database, bool makingCopy)
{
#pragma unused (database, makingCopy)

	// Override to save your data. 
}

//----------------------------------------------------------------------------------------
// Files
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseDocument::GetDatabaseFile: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

TDatabaseFile* TDatabaseDocument::GetDatabaseFile() const
{
	return dynamic_cast_AC(TDatabaseFile*, fFile.get());
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::DoMakeFile: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

TFile* TDatabaseDocument::DoMakeFile(CommandNumber itsCommandNumber)
{
#pragma unused (itsCommandNumber)

	enum { kBlockIncrement = 256 };
	return TH_new TDatabaseFile(fFileType, gDispatcher->GetCreator(), noResourceFork,
								kDataOpen, !kRsrcOpen, kBlockIncrement);
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::SetFile: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TDatabaseDocument::SetFile(TFile* itsNewFile)
{
	CloseFile();
	
	// Instead of using the file given to us, we're going to
	// make our own TDatabaseFile and copy the specification. 
	
	// Make a TDatabaseFile if we don't already have one. 
	// If we already have one, we'll just reuse it. 
	
	if (!fFile.IsNULL() && !dynamic_cast_AC(TDatabaseFile*, fFile.get()))
		fFile = NULL;	// auto ptr will delete

	if (fFile.IsNULL())
		fFile = DoMakeFile(cNew);
	
	// Now fix the TDatabaseFile so it has the same specification
	// as the TFile that was given to us. 
	
	if (itsNewFile)
	{
		if (!itsNewFile->IsSameFile(fFile))
			fFile->SpecifyWithFile(itsNewFile);
		
		// The caller thinks we own itsFile, so we have to free it
		delete itsNewFile;
		itsNewFile = nil;
	}
	
	fFileExists = FALSE;			// Until we are shown otherwise
}

//----------------------------------------------------------------------------------------
// TDatabaseDocument::CreateFile: 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

void TDatabaseDocument::CreateFile()
{
	DebugFailNonObject(fFile);

	enum { kNotMakingCopy = FALSE };
	CSaveOptions* options;
	RequestFileName(cSave, kNotMakingCopy, fFile, options);
	
	// Save the file conversion parms since we're not going through the normal
	// save process as found in TFileBasedDocument::SaveFile.
	fConversionParams = options;

	fFile->SetPermissions(fsRdWrPerm, fsRdWrPerm);

	OSErr err = fFile->DeleteCFile();
	if ((err != noErr) && (err != fnfErr))
		ThrowError_AC(err);

	ThrowIfOSErr_AC(fFile->CreateCFile());

	ThrowIfOSErr_AC(fFile->OpenFile());
}


//----------------------------------------------------------------------------------------
// End of UDatabaseDocument.cpp

#pragma segment Inline