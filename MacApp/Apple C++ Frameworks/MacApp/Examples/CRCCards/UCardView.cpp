//----------------------------------------------------------------------------------------
// UCardView.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		08/17/99	Change obsoleted macros to ACS versions. 
		03/24/99	Update copyright notice.
*/


#ifndef __UCARDVIEW__
#include "UCardView.h"
#endif

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

//========================================================================================
// Global Initialization Procedure
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// InitUCardView: 
//----------------------------------------------------------------------------------------
#pragma segment DlgInit

void InitUCardView()
{
	InitUTEView();

	// So the linker doesn't dead strip class info 
	REGISTER_CLASS_AC(TCardView);
}


//========================================================================================
// CLASS TCardView
//========================================================================================
#undef Inherited
#define Inherited TTEView

#pragma segment AOpen
DEFINE_REGISTERED_AC(TCardView);

//----------------------------------------------------------------------------------------
// TCardView constructor 
//----------------------------------------------------------------------------------------
#pragma segment AOpen

TCardView::TCardView()
{
}

//----------------------------------------------------------------------------------------
// TCardView destructor
//----------------------------------------------------------------------------------------
#pragma segment MADestructorRes

TCardView::~TCardView()
{
}
	
//----------------------------------------------------------------------------------------
// TCardView::CalcMinFrame
//----------------------------------------------------------------------------------------
#pragma segment ARes

CViewRect TCardView::CalcMinFrame() // override
{
	CViewRect newFrame = Inherited::CalcMinFrame();

	// Make sure the TEView is never smaller than the scroller
	// so drag in has a reasonable target
	TScroller* scroller = GetScroller(kImmediateSuperView);
	if (scroller)
	{
		CViewPoint minSize = scroller->GetSize() - newFrame[topLeft];
		
		if (newFrame.bottom - newFrame.top < minSize.v)
			newFrame.bottom = newFrame.top + minSize.v;

		if (newFrame.right - newFrame.left < minSize.h)
			newFrame.right = newFrame.left + minSize.h;
	}

	return newFrame;
}

//----------------------------------------------------------------------------------------
// TCardView::StuffText: 
//----------------------------------------------------------------------------------------
#pragma segment TENonRes

void TCardView::StuffText(Handle theText) // override
{
	if (fHTE)									// If we're replacing text, styles are kaput
	{
		if (GetHandleSize(theText) > fMaxChars)
		{
#if qDebug
			::ProgramBreak_AC("Text size exceeds maximum for this view");
#endif

			::ThrowError_AC(minErr);
		}

		short textLength = static_cast_AC(short, GetHandleSize(theText));// Check size of new text 

		// Remember where the selection range was & try to keep it
		// in the same state when the new text is added.  Usually, the
		// selection range should be in one of three states:  at the
		// beginning of the text, at the end of the text, or covering
		// all of the text (everything selected).  This isn't enforced,
		// though.

		short oldStart = (*fHTE)->selStart;
		short oldEnd = (*fHTE)->selEnd;
		if ((oldStart >= textLength) || (oldStart >= (*fHTE)->teLength))
			oldStart = textLength;
		if ((oldEnd >= textLength) || (oldEnd >= (*fHTE)->teLength))
			oldEnd = textLength;

		// Set the selection range to cover the entire text,
		// then call TESetStyle to fix up the style table.
		// It is _very important_ to reduce the number of style runs
		// down to one _before_ changing (*fHTE)->hText because
		// TESetStyle is not smart enough to fix up the style
		// run table if its length differs from (*fHTE)->teLength.

		SetSelect(0, SHRT_MAX, fHTE);
		TESetStyle(doAll, &fTextStyle, false, fHTE);

		if ((fSavedTEHandle != theText) && ((*fHTE)->hText != theText))
		{
			if (fFreeText)	// •••  7/8/97 •••
				fSavedTEHandle = ::DisposeIfHandle_AC(fSavedTEHandle);// …we have no choice but to dispose it

			fSavedTEHandle = (*fHTE)->hText;	// Save existing handle 
			(*fHTE)->hText = theText;			// Install new handle 
		}

		fText = theText;						// Make a local copy, too 
		(*fHTE)->teLength = textLength;	// Tell TE how long we are

		// At this point we are back to one plain-text
		// style, but TECalText is not smart enough to change
		// the total length of the style run table, so we
		// must do it manually here.

		TEStyleHandle styles = TEGetStyleHandle(fHTE);
		TEStyleRec & aTEStyleRec = **styles;

		// This next line sets the "dummy record" at the end of the table. See IM V-261.
		aTEStyleRec.runs[1].startChar = (*fHTE)->teLength + 1;

		RecalcText();							// Recalculate the line breaks and line-height tables
		SetSelect(oldStart, oldEnd, fHTE);		// Restore the old selection
	}
}


//----------------------------------------------------------------------------------------
// End of UCardView.cpp

#pragma segment Inline
