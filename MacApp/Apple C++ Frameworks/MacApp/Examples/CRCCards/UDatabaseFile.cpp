//----------------------------------------------------------------------------------------
// UDatabaseFile.cpp
// Copyright � 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/17/01	DoNeedDiskSpace is now const.
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		10/24/00	Use ProgramReport_AC instead of fprintf in ValidBlock.
		12/08/99	Used enum name Chunky for kMaxChunkSize.
		03/24/99	Update copyright notice.
*/

#ifndef __UDATABASEFILE__
#include "UDatabaseFile.h"
#endif

// Card

#ifndef __UMOREDEBUG__
#include "UMoreDebug.h"
#endif

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __CListIterator_AC__
#include "CListIterator_AC.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// ANSI

#ifndef __STDIO__
#include <stdio.h>
#endif


//========================================================================================
// CONSTANTS
//========================================================================================

enum
{
	kDataBaseHeaderKind = 0x62617365,		// 'base'
	kDataBaseHeaderID = 0x100				// version 1.0.0
};

//========================================================================================
// struct DatabaseBlockHeader
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// DatabaseBlockHeader::Compare
//----------------------------------------------------------------------------------------
#pragma segment ListRes

CompareResult_AC DatabaseBlockHeader::Compare(const DatabaseBlockHeader& other) const
{
	CompareResult_AC returnVal;

	if (kind > other.kind)
		returnVal = kItem1GreaterThanItem2_AC;
	else if (kind < other.kind)
		returnVal = kItem1LessThanItem2_AC;
	else if (id > other.id)
		returnVal = kItem1GreaterThanItem2_AC;
	else if (id < other.id)
		returnVal = kItem1LessThanItem2_AC;
	else
		returnVal = kItem1EqualItem2_AC;

	return returnVal;
}


//========================================================================================
// CLASS TDatabaseDirectory
//========================================================================================
#undef Inherited
#define Inherited TSortedDynamicArray

//----------------------------------------------------------------------------------------
// TDatabaseDirectory destructor
//----------------------------------------------------------------------------------------
#pragma segment MADestructorRes

TDatabaseDirectory::~TDatabaseDirectory()
{
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::At: Return the index'th element of the list.
//----------------------------------------------------------------------------------------
#if qRangeCheck
#pragma segment ListRes

DatabaseBlockHeader TDatabaseDirectory::At(ArrayIndex_AC index) const
{
	ThrowIfRangeCheck(index, "Range Check in TDatabaseDirectory::At");

	return *((DatabaseBlockHeader*)ComputeAddress(index));
}
#endif

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::AtDelete: Deletes via an index.
//----------------------------------------------------------------------------------------
#if qRangeCheck
#pragma segment ListRes

void TDatabaseDirectory::AtDelete(ArrayIndex_AC index)
{
	ThrowIfRangeCheck(index, "Range Check in TDatabaseDirectory::AtDelete");
}
#endif

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::First
//----------------------------------------------------------------------------------------
#pragma segment ListRes

DatabaseBlockHeader TDatabaseDirectory::First() const
{
	return fSize ? At(1) : DatabaseBlockHeader();
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::Last
//----------------------------------------------------------------------------------------
#pragma segment ListRes

DatabaseBlockHeader TDatabaseDirectory::Last() const
{
	return fSize ? At(fSize) : DatabaseBlockHeader();
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::Delete
//----------------------------------------------------------------------------------------
#pragma segment ListRes

void TDatabaseDirectory::Delete(const DatabaseBlockHeader& item)
{
	ArrayIndex_AC index = GetIdentityItemNo(item);
	if (index != kEmptyIndex_AC)
		AtDelete(index);
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::GetIdentityItemNo: Find the first reference to the IDENTITY item in
// the list. If item does not occur, return 0.
//----------------------------------------------------------------------------------------
#pragma segment ListRes

ArrayIndex_AC TDatabaseDirectory::GetIdentityItemNo(const DatabaseBlockHeader& item) const
{
	ArrayIndex_AC returnVal = 0;
	
	for (CArrayIterator_AC iter(this); iter.Current(); ++iter)
	{
		if (At(iter.Current()) == item)
		{
			returnVal = iter.Current();
			break;
		}
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::Compare
//----------------------------------------------------------------------------------------
#pragma segment ListRes

CompareResult_AC TDatabaseDirectory::Compare(const DatabaseBlockHeader& item1,
											 const DatabaseBlockHeader& item2) const
{
	return item1.Compare(item2);
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::CompareElements
//----------------------------------------------------------------------------------------
#pragma segment ListRes

CompareResult_AC TDatabaseDirectory::CompareElements(const void* element1, const void* element2) const
{
	return Compare(*((DatabaseBlockHeader*)element1), *((DatabaseBlockHeader*)element2));
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::DoSearch: DON'T use exit to get out of this routine from your
// TestItem function or you will be really sad! (our debugger will check for you).
//----------------------------------------------------------------------------------------
#pragma segment ListRes

Boolean TDatabaseDirectory::DoSearch(CompareBlockHeaderProc TestItem, void* yourDataPtr,
									 ArrayIndex_AC& index) const
{
	DatabaseBlockHeader aDatabaseDirectory;
	CSearch searchInfo(TestItem, yourDataPtr, aDatabaseDirectory, this);

	return DoSearchElement(CSearch::TestElement, &searchInfo, index);
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::GetEqualItemNo
//----------------------------------------------------------------------------------------
#pragma segment ListRes

ArrayIndex_AC TDatabaseDirectory::GetEqualItemNo(const DatabaseBlockHeader& item) const
{
	ArrayIndex_AC returnVal = kEmptyIndex_AC;
	CCompare comparisonInfo(item, this);

	// Find the first reference to item in the list.
	// If item does not occur, return kEmptyIndex_AC (0).
	ArrayIndex_AC index;
	if (DoSearch(CCompare::CompareItems, &comparisonInfo, index))
		returnVal = index;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::Insert
//----------------------------------------------------------------------------------------
#pragma segment ListRes

void TDatabaseDirectory::Insert(const DatabaseBlockHeader& item)
{
	InsertElementInOrder(& const_cast_AC(DatabaseBlockHeader&, item));
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::Search
//----------------------------------------------------------------------------------------
#pragma segment ListRes

ArrayIndex_AC TDatabaseDirectory::Search(CompareBlockHeaderProc TestItem, void* yourDataPtr) const
{
	ArrayIndex_AC returnVal = kEmptyIndex_AC;

	ArrayIndex_AC index;
	if (DoSearch(TestItem, yourDataPtr, index))
		returnVal = index;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::FindItem
//----------------------------------------------------------------------------------------
#pragma segment ListRes

ArrayIndex_AC TDatabaseDirectory::FindItem(OSType kind, long id)
{
	DatabaseBlockHeader block;
	block.Clear();
	block.kind = kind;
	block.id = id;

	return GetEqualItemNo(block);
}

//----------------------------------------------------------------------------------------
// I/O Support
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::BytesToCount
//----------------------------------------------------------------------------------------
#pragma segment ListRes

ArrayIndex_AC TDatabaseDirectory::BytesToCount(long size) const
{
	return ((size - 1) >> fElementSizeShift) + 1;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::ElementBytes
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseDirectory::ElementBytes() const
{
	return (1 << fElementSizeShift);
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::SetSize
//----------------------------------------------------------------------------------------
#pragma segment ListRes

void TDatabaseDirectory::SetSize(ArrayIndex_AC count)
{
	fSize = count;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::GetSizeInBytes
//----------------------------------------------------------------------------------------
#pragma segment ListRes

ArrayIndex_AC TDatabaseDirectory::GetSizeInBytes()
{
	return (fSize << fElementSizeShift);
}

//----------------------------------------------------------------------------------------
// Indexed Access
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::CountKinds
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseDirectory::CountKinds() const
{
	long count = 0;

	// Assumes the blocks are sorted by kind. 
	OSType lastKind = 0;
	for (ArrayIndex_AC iter = 1; iter <= GetSize(); ++iter)
	{
		DatabaseBlockHeader block = At(iter);
		if ((block.kind != 0) && (block.kind != lastKind))
		{
			lastKind = block.kind;
			++count;
		}
	}

	return count;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::GetIndKind
//----------------------------------------------------------------------------------------
#pragma segment ListRes

OSType TDatabaseDirectory::GetIndKind(long index) const
{
	OSType kind = 0;

	// Assumes the blocks are sorted by kind. 
	long count = 0;
	OSType lastKind = 0;
	for (ArrayIndex_AC iter = 1; iter <= GetSize(); ++iter)
	{
		DatabaseBlockHeader block = At(iter);
		if ((block.kind != 0) && (block.kind != lastKind))
		{
			lastKind = block.kind;
			if (++count == index)
			{
				kind = lastKind;
				break;
			}
		}
	}

	return kind;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::CountItems
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseDirectory::CountItems(OSType kind) const
{
	long count = 0;
	
	for (ArrayIndex_AC iter = 1; iter <= GetSize(); ++iter)
	{
		DatabaseBlockHeader block = At(iter);
		if (block.kind == kind)
		{
			++count;
		}
	}

	return count;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::GetIndItemID
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseDirectory::GetIndItemID(OSType kind, long index) const
{
	long id = 0;

	long count = 0;
	for (ArrayIndex_AC iter = 1; iter <= GetSize(); ++iter)
	{
		DatabaseBlockHeader block = At(iter);
		if (block.kind == kind)
		{
			if (++count == index)
			{
				id = block.id;
				break;
			}
		}
	}

	return id;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::UniqueItemID
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseDirectory::UniqueItemID(OSType kind) const
{
	long id = 1;

	// Assumes the blocks for a kind are sorted in ascending order by id. 
	for (ArrayIndex_AC iter = 1; iter <= GetSize(); ++iter)
	{
		DatabaseBlockHeader block = At(iter);
		if (block.kind == kind)
		{
			if (id == block.id)
				id = block.id + 1;
		}
	}

	return id;
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::CSearch::TestElement
//----------------------------------------------------------------------------------------
#pragma segment ListRes

CompareResult_AC TDatabaseDirectory::CSearch::TestElement(ArrayIndex_AC anItem, void* yourDataPtr)
{
#if 0
	TDatabaseDirectory::CSearch* searchInfo = static_cast_AC(TDatabaseDirectory::CSearch*, yourDataPtr);
#else
	CSearch* searchInfo = static_cast_AC(CSearch*, yourDataPtr);
#endif
	searchInfo->fItem = searchInfo->fList->At(anItem);
	return searchInfo->fTestItemProc(searchInfo->fItem, searchInfo->fStaticLink);
}

//----------------------------------------------------------------------------------------
// TDatabaseDirectory::CCompare::CompareItems
//----------------------------------------------------------------------------------------
#pragma segment ListRes

CompareResult_AC TDatabaseDirectory::CCompare::CompareItems(const DatabaseBlockHeader& anItem, void* yourDataPtr)
{
#if 0
	TDatabaseDirectory::CCompare* comparisonInfo = static_cast_AC(TDatabaseDirectory::CCompare*, yourDataPtr);
#else
	CCompare* comparisonInfo = static_cast_AC(CCompare*, yourDataPtr);
#endif
	return comparisonInfo->fList->Compare(comparisonInfo->fCompareWith, anItem);
}

//========================================================================================
// CLASS TDatabaseFile
//========================================================================================
#undef Inherited
#define Inherited TFile

//----------------------------------------------------------------------------------------
// TDatabaseFile constructor
//----------------------------------------------------------------------------------------
#pragma segment AOpen
		
TDatabaseFile::TDatabaseFile(OSType itsFileType, OSType itsCreator,
							 ResourceUsage usesRsrcFork,
							 Boolean keepsDataOpen, Boolean keepsRsrcOpen,
							 long blockIncrement) :
	TFile(itsFileType, itsCreator, kUsesDataFork, usesRsrcFork, keepsDataOpen, keepsRsrcOpen),
	fDirectory(NULL),
	fBlockIncrement(512),
	fChangedDirectory(false),
	fChangedHeader(false)
{
	fHeader.Clear();

	fBlockIncrement = blockIncrement;

	// We need write access to files that are kept open,
	// so we can save to them without closing and reopening. 
	if (keepsDataOpen)
		fDataPermission = fsRdWrPerm;
	if (keepsRsrcOpen)
		fRsrcPermission = fsRdWrPerm;

	// Default database header
	fHeader.kind = kDataBaseHeaderKind;
	fHeader.id = kDataBaseHeaderID;
	fChangedHeader = true;
}


//----------------------------------------------------------------------------------------
// TDatabaseFile destructor
//----------------------------------------------------------------------------------------
#pragma segment AOpen
		
TDatabaseFile::~TDatabaseFile()
{
	delete fDirectory;
	fDirectory = nil;
}

//----------------------------------------------------------------------------------------
// Closing
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseFile::CloseDataFork
//----------------------------------------------------------------------------------------
#pragma segment MAFileClose

OSErr TDatabaseFile::CloseDataFork()
{
	// Make sure any changes to the directory or file header are saved before
	// we close it. 
	if (IsDataForkOpen())
		WriteDirectory();

	// We don't want the directory hanging around for a closed file. We don't need it,
	// and it could become invalid if someone else changes the file. 

	delete fDirectory;
	fDirectory = nil;

	return Inherited::CloseDataFork();
}

//----------------------------------------------------------------------------------------
// Header
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseFile::ReadHeader
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::ReadHeader()
{
	OSErr err = noErr;

	ThrowIfOSErr_AC( SetDataMark(0, fsFromStart) );

	long count = sizeof(fHeader);
	ThrowIfOSErr_AC( ReadData(&fHeader, count) );

	fChangedHeader = false;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::WriteHeader
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::WriteHeader()
{
	if (fChangedHeader)
	{
		ThrowIfOSErr_AC( SetDataMark(0, fsFromStart) );

		long count = sizeof(fHeader);
		ThrowIfOSErr_AC( WriteData(&fHeader, count) );

		fChangedHeader = false;
	}
}

//----------------------------------------------------------------------------------------
// Directory
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseFile::ReadDirectory
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::ReadDirectory()
{
	ReadHeader();

	if (fHeader.used > 0)
	{
		if (!fDirectory)
			fDirectory = TH_new TDatabaseDirectory();

		long maxBytes = Max_AC(fHeader.allocated, fHeader.used);
		long maxCount = fDirectory->BytesToCount(maxBytes);
		fDirectory->SetArraySize(maxCount);

		void *arraySpace = fDirectory->ComputeAddress(1);
		ReadBlock(fHeader, arraySpace, fHeader.used, NULL);

		long count = fDirectory->BytesToCount(fHeader.used);
		fDirectory->SetSize(count);

		fChangedDirectory = false;
	}
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::WriteDirectory
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::WriteDirectory()
{
	if (fChangedDirectory)
	{
		// If the directory has grown, reallocate storage for it. 
		// By waiting as long as possible before reallocating, we avoid
		// creating holes in the database as the directory is repeatedly
		// expanded. 
		if (fHeader.used > fHeader.allocated)
		{
			FreeBlock(fHeader);
			AllocateBlock(fHeader);
		}

		// Get the directory data to write. If there is no directory or
		// it is empty, a NULL data pointer is ok. 
		void *arraySpace = NULL;
		if (fHeader.used > 0)
		{
			ThrowIfNonObject_AC(fDirectory);
			arraySpace = fDirectory->ComputeAddress(1);
		}

		// Write out the directory. 
		WriteBlock(fHeader, arraySpace);

		fChangedDirectory = false;
	}

	// Update the header, if it has changed. 
	WriteHeader();
}

//----------------------------------------------------------------------------------------
// Block
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseFile::ValidateBlock
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

Boolean TDatabaseFile::ValidBlock(const DatabaseBlockHeader& block)
{
	long offset = block.position - sizeof(DatabaseBlockHeader);
	ThrowIfOSErr_AC( SetDataMark(offset, fsFromStart) );

	DatabaseBlockHeader checkBlock;
	checkBlock.Clear();
	long count = sizeof(DatabaseBlockHeader);
	ThrowIfOSErr_AC( ReadData(&checkBlock, count) );

	Boolean isValid = ( (checkBlock.kind == block.kind) &&
						(checkBlock.id == block.id) &&
						(checkBlock.position == block.position) &&
						(checkBlock.allocated == block.allocated) &&
						(checkBlock.used == block.used) );

#if qDebugMsg
	if (!isValid)
	{
		::ProgramReport_AC("TDatabaseFile::ValidBlock: Detected a bad block.\n");
	}
#endif

	return isValid;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::ReadBlock
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

Handle TDatabaseFile::ReadBlock(const DatabaseBlockHeader& block)
{
	CTempHandle_AC data = NewPermHandleClear(block.used);
	ThrowIfNULL_AC(data);
	{
		CTempHandleLock_AC dataLock(data);
		ReadBlock(block, *data, block.used, NULL);
	}
	return data.release();
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::ReadBlock
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::ReadBlock(const DatabaseBlockHeader& block, void *data, long size,
							  long *actualSize)
{
	if (actualSize)
		*actualSize = 0;

	FailIf(!ValidBlock(block), minErr, 0);		// ゥナneed a unique error code !!!
	
	ThrowIfOSErr_AC( SetDataMark(block.position, fsFromStart) );

	long count = block.used;
	if (count > size)
		count = size;

	ThrowIfOSErr_AC( ReadData(data, count) );
	
	if (actualSize)
		*actualSize = count;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::WriteBlockHeader
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::WriteBlockHeader(const DatabaseBlockHeader& block)
{
	long offset = block.position - sizeof(DatabaseBlockHeader);
	ThrowIfOSErr_AC( SetDataMark(offset, fsFromStart) );

	long count = sizeof(DatabaseBlockHeader);
	ThrowIfOSErr_AC( WriteData(&block, count) );
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::WriteBlock
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::WriteBlock(const DatabaseBlockHeader& block, const Handle data)
{
	if (data)
	{
		CTempHandleLock_AC lockData(const_cast_AC(Handle, data));
		WriteBlock(block, *data);
	}
	else
	{
		WriteBlock(block, (void*) NULL);
	}
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::WriteBlock
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::WriteBlock(const DatabaseBlockHeader& block, const void *data)
{
	WriteBlockHeader(block);
	
	ThrowIfOSErr_AC( SetDataMark(block.position, fsFromStart) );

	long count = block.used;
	if (count > 0)
		ThrowIfOSErr_AC( WriteData(data, count) );
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::AllocateBlock
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::AllocateBlock(DatabaseBlockHeader& block)
{
	long eof = 0;
	ThrowIfOSErr_AC( GetDataLength(eof) );
	block.position = eof + sizeof(block);

	block.allocated = AllocationSize(block.used);

	eof = block.position + block.allocated;
	ThrowIfOSErr_AC( SetDataLength(eof) );

	EraseBlock(block);
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::AllocationSize
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

long TDatabaseFile::AllocationSize(long used) const
{
	return ((used - 1) / fBlockIncrement + 1) * fBlockIncrement;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::FreeBlock
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::FreeBlock(const DatabaseBlockHeader& block)
{
	if (block.position)
	{
		// Mark the old block as free
		DatabaseBlockHeader freeBlock = block;
		freeBlock.kind = 0;
		freeBlock.id = 0;
		freeBlock.used = 0;

		WriteBlockHeader(freeBlock);

		// Remove the block from the directory and add it to the free list
		// (which doesn't exist)
	}
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::EraseBlock
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::EraseBlock(const DatabaseBlockHeader& block)
{
	if (block.allocated > 0)
	{
		ThrowIfOSErr_AC( SetDataMark(block.position, fsFromStart) );
		ThrowIfOSErr_AC( EraseData(block.allocated) );
	}
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::EraseData
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

OSErr TDatabaseFile::EraseData(unsigned long count)
{
	OSErr err = noErr;

	if (count > 0)
	{
		enum Chunky { kMaxChunkSize = 4096 };
			// Gave this enum a dummy name because kMaxChunkSize is supplied to
			// the template function Min_AC and the standard requires that
			// "an unnamed type shall not be used as a template-argument for
			// a template type-parameter." See (section 14.3.1 para. 2.)
		long chunkSize = Min_AC(count, kMaxChunkSize);
		CTempHandle_AC chunk(NewHandleClear(chunkSize));
		ThrowIfNULL_AC(chunk);
		HLock(chunk);
		while (count > 0)
		{
			chunkSize = Min_AC(count, kMaxChunkSize);
			count -= chunkSize;
			err = WriteData(*chunk, chunkSize);
			if (err != noErr)
				break;
		}
	}

	return err;
}

//----------------------------------------------------------------------------------------
// Items
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseFile::FindItem
//----------------------------------------------------------------------------------------
#pragma segment ListRes

ArrayIndex_AC TDatabaseFile::FindItem(OSType kind, long id)
{
	ArrayIndex_AC index = kEmptyIndex_AC;

	if (!fDirectory)
		ReadDirectory();

	if (fDirectory)
		index = fDirectory->FindItem(kind, id);

	return index;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::ReadItem
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

Handle TDatabaseFile::ReadItem(OSType kind, long id)
{
	ArrayIndex_AC index = FindItem(kind, id);
	FailIf(index == kEmptyIndex_AC, resNotFound, 0);

	ThrowIfNonObject_AC(fDirectory);
	DatabaseBlockHeader block = fDirectory->At(index);

	return ReadBlock(block);
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::ReadItem
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::ReadItem(OSType kind, long id, void *data, long size,
							 long *actualSize)
{
	if (actualSize)
		*actualSize = 0;

	ArrayIndex_AC index = FindItem(kind, id);
	FailIf(index == kEmptyIndex_AC, resNotFound, 0);

	ThrowIfNonObject_AC(fDirectory);
	DatabaseBlockHeader block = fDirectory->At(index);

	ReadBlock(block, data, size, actualSize);
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::WriteItem
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::WriteItem(OSType kind, long id, const Handle data)
{
	long size = GetHandleSize(data);
	DatabaseBlockHeader block;

	AllocateItem(kind, id, size, block);
	
	WriteBlock(block, data);
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::WriteItem
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::WriteItem(OSType kind, long id, const void *data, long size)
{
	DatabaseBlockHeader block;

	AllocateItem(kind, id, size, block);
	
	WriteBlock(block, data);
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::AllocateItem
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::AllocateItem(OSType kind, long id, long size,
								 DatabaseBlockHeader& block)
{
	block.Clear();

	ArrayIndex_AC index = FindItem(kind, id);
	if (index == kEmptyIndex_AC)
	{
		// Add a new item

		block.kind = kind;
		block.id = id;
		block.used = size;

		AllocateBlock(block);

		if (!fDirectory)
			fDirectory = TH_new TDatabaseDirectory();
		
		fChangedDirectory = true;
		fDirectory->Insert(block);

		fChangedHeader = true;
		fHeader.used += fDirectory->ElementBytes();
	}
	else
	{
		// Update an existing item
		
		ThrowIfNonObject_AC(fDirectory);
		block = fDirectory->At(index);
		if (block.used != size)
		{
			block.used = size;
			if (block.used > block.allocated)
			{
				// Mark the old block as free
				FreeBlock(block);
				
				// Reallocate the storage
				AllocateBlock(block);
			}

			// Update the directory
			fChangedDirectory = true;
			fDirectory->ReplaceElementsAt(index, &block, 1);
		}

	}
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::DeleteItem
//----------------------------------------------------------------------------------------
#pragma segment MAWriteFile

void TDatabaseFile::DeleteItem(OSType kind, long id)
{
	ArrayIndex_AC index = FindItem(kind, id);
	if (index != kEmptyIndex_AC)
	{
		// Delete an existing item
		ThrowIfNonObject_AC(fDirectory);
		DatabaseBlockHeader block = fDirectory->At(index);

		// Mark the old block as free
		FreeBlock(block);

		// Update the directory
		fChangedDirectory = true;
		fDirectory->AtDelete(index);

		// Update the file header
		fChangedHeader = true;
		fHeader.used -= fDirectory->ElementBytes();
	}
}

//----------------------------------------------------------------------------------------
// Copying
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseFile::CopyDatabase
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

void TDatabaseFile::CopyDatabase(TDatabaseFile* fromDatabase)
{
	CTempHandle_AC data;

	// Make sure we have a header before adding anything. 
	// Otherwise blocks could be allocated where the header is supposed to go. 
	WriteHeader();

	TDatabaseDirectory* fromDirectory = fromDatabase->fDirectory;
	ThrowIfNonObject_AC(fromDirectory);
	for (CArrayIterator_AC iter(fromDirectory); iter.Current(); ++iter)
	{
		// Get a block from the "from" database. 
		DatabaseBlockHeader block = fromDirectory->At(iter.Current());
		if (block.kind && block.id)
		{
			// Get its data. 
			data = fromDatabase->ReadBlock(block);

			// Allocate the block in this database. 
			block.position = 0;
			block.allocated = 0;
			AllocateBlock(block);
			
			// Save the data here. 
			WriteBlock(block, data);
			
			// Add it to this directory. 
			if (!fDirectory)
				fDirectory = TH_new TDatabaseDirectory();

			fChangedDirectory = true;
			fDirectory->Insert(block);

			fChangedHeader = true;
			fHeader.used = fDirectory->GetSizeInBytes();
		}
	}
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::DoNeedDiskSpace
//----------------------------------------------------------------------------------------
#pragma segment MAReadFile

long TDatabaseFile::DoNeedDiskSpace() const
{
	long dataBytes = AllocationSize(fHeader.used);

	for (CArrayIterator_AC iter(fDirectory); iter.Current(); ++iter)
	{
		DatabaseBlockHeader block = fDirectory->At(iter.Current());
		if (block.kind && block.id)
			dataBytes += AllocationSize(block.used);
	}

	return dataBytes;
}

//----------------------------------------------------------------------------------------
// Indexed Access
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDatabaseFile::CountKinds
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseFile::CountKinds()
{
	long count = 0;

	if (!fDirectory)
		ReadDirectory();

	if (fDirectory)
		count = fDirectory->CountKinds();

	return count;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::GetIndKind
//----------------------------------------------------------------------------------------
#pragma segment ListRes

OSType TDatabaseFile::GetIndKind(long index)
{
	OSType kind = 0;

	if (!fDirectory)
		ReadDirectory();

	if (fDirectory)
		kind = fDirectory->GetIndKind(index);

	return kind;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::CountItems
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseFile::CountItems(OSType kind)
{
	long count = 0;
	
	if (!fDirectory)
		ReadDirectory();

	if (fDirectory)
		count = fDirectory->CountItems(kind);

	return count;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::GetIndItemID
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseFile::GetIndItemID(OSType kind, long index)
{
	long id = 0;

	if (!fDirectory)
		ReadDirectory();

	if (fDirectory)
		id = fDirectory->GetIndItemID(kind, index);

	return id;
}

//----------------------------------------------------------------------------------------
// TDatabaseFile::UniqueItemID
//----------------------------------------------------------------------------------------
#pragma segment ListRes

long TDatabaseFile::UniqueItemID(OSType kind)
{
	long id = 1;

	if (!fDirectory)
		ReadDirectory();

	if (fDirectory)
		id = fDirectory->UniqueItemID(kind);

	return id;
}


//----------------------------------------------------------------------------------------
// End of UDatabaseFile.cpp

#pragma segment Inline
