//----------------------------------------------------------------------------------------
// UDemoDialogs.More.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/14/01	Added TShowErrorBehavior::DoEvent.  Include Utils_AC.h,
					UCoreGlobals.h, UStdPrintHandler.h, UEditionDocument.h and
					UPopup.h.
		01/16/01	Using CString_AC and stringprintf in SetValue.  Include
					StdStringUtils_AC.h.  Reworked Truncate to take a CString_AC.
					NewDigit also uses CString_AC.  Check for 0 in SetValue before
					worrying about the exponent.
		01/02/01	Update copyright.
		12/26/00	[W] Reenable SetValue.
		11/14/00	Include ImagingUtils_AC.h.  Call GetPictureFrame_AC in
					THomeBrewSlider::DoPostCreate.
		07/31/00	[W] Use MacOffsetRect instead of OffsetRect in TrackMouse.
					Conditionalized implementation of TCalcDialog::SetValue.
					Include fp.h.
		07/24/00	CW Pro 6: namespacing. 
		12/08/99	Fixed file name in banner.
		09/30/99	LoadResource now MacLoadResource. InsetRect now MacInsetRect.
					PaintRgn now MacPaintRgn.  FrameRect now MacFrameRect.
		03/24/99	Update copyright notice.
		03/18/99	Removed '&' on parms to a variety of Toolbox calls.
*/

#ifndef __UDEMODIALOGS__
#include "UDemoDialogs.h"
#endif

// ACS

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif 

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

// MacApp

#ifndef __UCHECKBOX__
#include "UCheckbox.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UDRAWINGENVIRONMENT__
#include "UDrawingEnvironment.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UNUMBERTEXT__
#include "UNumberText.h"
#endif

#ifndef __UPOPUP__
#include "UPopup.h"
#endif

#ifndef __UStdPrintHandler__
#include "UStdPrintHandler.h"
#endif

#ifndef __UTEVIEW__
#include "UTEView.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// Toolbox

#ifndef __FP__
#include <fp.h>
#endif

#ifndef __MENUS__
#include <Menus.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __SOUND__
#include <Sound.h>
#endif

// ANSI

#ifndef __LIMITS__
#include <limits.h>
#endif

#ifndef __STDIO__
#include <stdio.h>
#endif

#ifndef __STDLIB__
#include <stdlib.h>
#endif

#if AlanDail
#include <fp.h>
#endif

//----------------------------------------------------------------------------------------
// Usings

using std::fabs;
using std::log2;

//----------------------------------------------------------------------------------------
// Constants

const short kMaxPlaces = 13;

const short mUpArrow = 100;
const short mDownArrow = 101;
const short mTemperatureChanged = 102;

//========================================================================================
// CLASS TSwallowBehavior
//========================================================================================
#undef Inherited
#define Inherited TBehavior


MA_DEFINE_CLASS(TSwallowBehavior);

//----------------------------------------------------------------------------------------
// TSwallowBehavior destructor
//----------------------------------------------------------------------------------------


TSwallowBehavior::~TSwallowBehavior()
{
}

//----------------------------------------------------------------------------------------
// TSwallowBehavior::DoToolboxEvent: 
//----------------------------------------------------------------------------------------


bool TSwallowBehavior::DoToolboxEvent(TToolboxEvent* event)
{
	if (event && (event->GetIdentifier() == mouseDown) && event->IsOptionKeyPressed())
	{
		gApplication->Beep(1);
		return true;				// consume the event
	}
	else
		return Inherited::DoToolboxEvent(event);
}




//========================================================================================
// CLASS TChangeBehavior
//========================================================================================
#undef Inherited
#define Inherited TBehavior


MA_DEFINE_CLASS(TChangeBehavior);

//----------------------------------------------------------------------------------------
// TChangeBehavior destructor
//----------------------------------------------------------------------------------------


TChangeBehavior::~TChangeBehavior()
{
}

//----------------------------------------------------------------------------------------
// TChangeBehavior::DoEvent: 
//----------------------------------------------------------------------------------------


void TChangeBehavior::DoEvent(EventNumber eventNumber,
							  TEventHandler* source,
							  TEvent* event)
{
	fOwner->Changed(eventNumber, event);

	Inherited::DoEvent(eventNumber, source, event);
}



//========================================================================================
// CLASS TUpdateBehavior
//========================================================================================
#undef Inherited


MA_DEFINE_CLASS(TUpdateBehavior);

//----------------------------------------------------------------------------------------
// TUpdateBehavior destructor
//----------------------------------------------------------------------------------------


TUpdateBehavior::~TUpdateBehavior()
{
}

//----------------------------------------------------------------------------------------
// TUpdateBehavior::DoBehaviorUpdate: 
//----------------------------------------------------------------------------------------


void TUpdateBehavior::DoUpdate(ChangeID_AC theChange,
								MDependable_AC* changedObject,
								void* changeData,
								CDependencySpace_AC* dependencySpace)
{
	if (((theChange == mVScrollBarHit) || (theChange == mHScrollBarHit)))
		dynamic_cast_AC(TScrollBar*,(fOwner))->SetValue(-dynamic_cast_AC(TScrollBar*,(changedObject))->GetValue(), kRedraw);
	else
		MDependable_AC::DoUpdate(theChange, changedObject, changeData, dependencySpace);
}


//========================================================================================
// CLASS TArrowsControl
//========================================================================================
#undef Inherited
#define Inherited TPicture


MA_DEFINE_CLASS(TArrowsControl);

//----------------------------------------------------------------------------------------
// TArrowsControl constructor 
//----------------------------------------------------------------------------------------


TArrowsControl::TArrowsControl() :	 
	fLastChange(0)
{
}

//----------------------------------------------------------------------------------------
// TArrowsControl destructor
//----------------------------------------------------------------------------------------


TArrowsControl::~TArrowsControl()
{
}

//----------------------------------------------------------------------------------------
// TArrowsControl::TrackMouse: 
//----------------------------------------------------------------------------------------


void TArrowsControl::TrackMouse(TrackPhase	aTrackPhase,
								CViewPoint&		/*anchorPoint*/,
								CViewPoint&		/*previousPoint*/,
								CViewPoint&		nextPoint,
								bool			/*mouseDidMove*/)
{
	if (TickCount() >= fLastChange + 5)
	{
		fLastChange = TickCount();
		if (aTrackPhase == trackBegin)
			fLastChange = fLastChange + 10;

		if (ContainsMouse(nextPoint))
			if (nextPoint.v <= fSize.v / 2)
				HandleEvent(mUpArrow, this, NULL);
			else
				HandleEvent(mDownArrow, this, NULL);
	}
}


//========================================================================================
// CLASS TTemperatureCluster
//========================================================================================
#undef Inherited
#define Inherited TCluster


MA_DEFINE_CLASS(TTemperatureCluster);

//----------------------------------------------------------------------------------------
// TTemperatureCluster destructor
//----------------------------------------------------------------------------------------


TTemperatureCluster::~TTemperatureCluster()
{
}

//----------------------------------------------------------------------------------------
// TTemperatureCluster::DoEvent: 
//----------------------------------------------------------------------------------------


void TTemperatureCluster::DoEvent(EventNumber eventNumber,
								  TEventHandler* source,
								  TEvent* event)
{
	TNumberText*	theNumberText;
	long			theNumber;


	switch (eventNumber)
	{
		case mUpArrow:
		case mDownArrow:
			{
				theNumberText = dynamic_cast_AC(TNumberText*,(FindSubView('Numb')));
				theNumber = theNumberText->GetValue();
				if (eventNumber == mUpArrow)
					theNumber = theNumber + 1;
				else
					theNumber = theNumber - 1;
				theNumberText->SetValue(theNumber, kRedraw);

				HandleEvent(mTemperatureChanged, this, NULL);
				break;
			}
		default:
			Inherited::DoEvent(eventNumber, source, event);
	}
}

//----------------------------------------------------------------------------------------
// TTemperatureCluster::GetValue: 
//----------------------------------------------------------------------------------------


long TTemperatureCluster::GetValue() const
{
	TNumberText * numberText;

	numberText = dynamic_cast_AC(TNumberText*,FindSubView('Numb'));
	return (numberText->GetValue());
}

//----------------------------------------------------------------------------------------
// TTemperatureCluster::SetValue: 
//----------------------------------------------------------------------------------------


void TTemperatureCluster::SetValue(long		newValue,
										  bool	redraw)
{
	TNumberText * numberText;

	numberText = dynamic_cast_AC(TNumberText*,FindSubView('Numb'));
	numberText->SetValue(newValue, redraw);
}


//========================================================================================
// CLASS TTemperatureConversionCluster
//========================================================================================
#undef Inherited
#define Inherited TCluster


MA_DEFINE_CLASS(TTemperatureConversionCluster);

//----------------------------------------------------------------------------------------
// TTemperatureConversionCluster destructor
//----------------------------------------------------------------------------------------


TTemperatureConversionCluster::~TTemperatureConversionCluster()
{
}

//----------------------------------------------------------------------------------------
// TTemperatureConversionCluster::DoEvent: 
//----------------------------------------------------------------------------------------


void TTemperatureConversionCluster::DoEvent(EventNumber eventNumber,
											TEventHandler* source,
											TEvent* event)
{
	TTemperatureCluster * Celsius;
	TTemperatureCluster * Fahrenheit;

	if (eventNumber == mTemperatureChanged)
	{
		Celsius = dynamic_cast_AC(TTemperatureCluster*,(FindSubView('Cels')));
		Fahrenheit = dynamic_cast_AC(TTemperatureCluster*,(FindSubView('Fahr')));
		if (source == Celsius)
		{
			Fahrenheit->SetValue(Celsius->GetValue() * 1.8 + 32, kRedraw);
		}
		else if (source == Fahrenheit)
		{
			Celsius->SetValue((Fahrenheit->GetValue() - 32) / 1.8, kRedraw);
		}
	}
	else
		Inherited::DoEvent(eventNumber, source, event);
}


//========================================================================================
// CLASS THomeBrewSlider
//========================================================================================
#undef Inherited
#define Inherited TPicture


MA_DEFINE_CLASS(THomeBrewSlider);

//----------------------------------------------------------------------------------------
// THomeBrewSlider constructor 
//----------------------------------------------------------------------------------------


THomeBrewSlider::THomeBrewSlider() :			
	fValue(0),
	fKnobPicture(NULL),
	fMinTop(0),
	fMaxTop(0)
{
}

//----------------------------------------------------------------------------------------
// THomeBrewSlider destructor
//----------------------------------------------------------------------------------------


THomeBrewSlider::~THomeBrewSlider()
{
}

//----------------------------------------------------------------------------------------
// THomeBrewSlider::DoPostCreate: 
//----------------------------------------------------------------------------------------


void THomeBrewSlider::DoPostCreate(TDocument* itsDocument)
{
	PicHandle	knobPicture;
	CViewRect	knobRect;
	CRect_AC	tmpR;


	Inherited::DoPostCreate(itsDocument);

	knobPicture = GetPicture(1002);
	fKnobPicture = knobPicture;
	tmpR = GetPictureFrame_AC(knobPicture);
	knobRect.left = fSize.h - (tmpR.right - tmpR.left);
	knobRect.top = fSize.v - 16;
	knobRect.right = knobRect.left + tmpR.right - tmpR.left;
	knobRect.bottom = knobRect.top + tmpR.bottom - tmpR.top;

	fKnobRect = knobRect.ToRect();
	fMinTop = fKnobRect.top - 84;
	fMaxTop = fKnobRect.top;
}

//----------------------------------------------------------------------------------------
// THomeBrewSlider::ContainsMouse: 
//----------------------------------------------------------------------------------------


bool THomeBrewSlider::ContainsMouse(const CViewPoint& theMouse)
{
	return GetKnobRect().Contains(ViewToQD(theMouse));
}

//----------------------------------------------------------------------------------------
// THomeBrewSlider::Draw: 
//----------------------------------------------------------------------------------------


void THomeBrewSlider::Draw(const CViewRect& area)
{
	Inherited::Draw(area);						// This draws everything but the knob
	DrawKnob();
}

//----------------------------------------------------------------------------------------
// THomeBrewSlider::DrawKnob: 
//----------------------------------------------------------------------------------------


void THomeBrewSlider::DrawKnob()
{
	MacLoadResource(Handle(fKnobPicture));			// In case it was purged from memory 
	DrawPicture(fKnobPicture, GetKnobRect());
}

//----------------------------------------------------------------------------------------
// THomeBrewSlider::GetKnobRect: 
//----------------------------------------------------------------------------------------


CRect_AC THomeBrewSlider::GetKnobRect()
{
	return fKnobRect + CPoint_AC(0, -(fValue * 12));
}

//----------------------------------------------------------------------------------------
// THomeBrewSlider::TrackMouse: 
//----------------------------------------------------------------------------------------

void THomeBrewSlider::TrackMouse(TrackPhase	aTrackPhase,
								 CViewPoint& anchorPoint,
								 CViewPoint& previousPoint,
								 CViewPoint& nextPoint,
								 bool /*mouseDidMove*/)
{
	CRect_AC oldRect(GetKnobRect());
	CRect_AC newRect(oldRect);

	// Compute rectangle of knob's current position 
	short offset = static_cast<short>(MinMax_AC(fMinTop - newRect.top, previousPoint.v - anchorPoint.v, fMaxTop - newRect.top));
	oldRect.Offset(0, offset);

	// Compute rectangle of knob's new position 
	offset = static_cast<short>(MinMax_AC(fMinTop - newRect.top, nextPoint.v - anchorPoint.v, fMaxTop - newRect.top));
	newRect.Offset(0, offset);

	// If the mouse was released, pin the knob to a value and set slider's value 
	if (aTrackPhase == trackEnd)
	{
		short base = static_cast<short>(fSize.v - 16 - newRect.top);
		offset = base - ((base + 6) / 12 * 12);
		::MacOffsetRect(newRect, 0, offset);
		fValue = static_cast<short>(fSize.v - 16 - newRect.top) / 12;
	}

	// To redraw minimal amount, compute difference between old and new positions 
	CRect_AC difference(oldRect);
	if (oldRect.top > newRect.top)
		difference.top = Max_AC(oldRect.top, newRect.bottom);
	else
		difference.bottom = Min_AC(oldRect.bottom, newRect.top);

	CTempRegion_AC savedClip;
	GetClip(savedClip);

	ClipRect(difference);
	Inherited::Draw(QDToView(difference));

	SetClip(savedClip);

	MacLoadResource(Handle(fKnobPicture));			// In case it was purged from memory 
	DrawPicture(fKnobPicture, newRect);
}



//========================================================================================
// CLASS TSumStaticText
//========================================================================================
#undef Inherited
#define Inherited TStaticText


MA_DEFINE_CLASS(TSumStaticText);

//----------------------------------------------------------------------------------------
// TSumStaticText destructor
//----------------------------------------------------------------------------------------


TSumStaticText::~TSumStaticText()
{
}

//----------------------------------------------------------------------------------------
// TSumStaticText::Draw: 
//----------------------------------------------------------------------------------------


void TSumStaticText::Draw(const CViewRect& area)

{
	// Make sure the gray background gets completely erased 
	//InsetRect(theRect, fPenSize.h, fPenSize.v);
	::EraseRect(GetQDExtent());

	Inherited::Draw(area);
}


//========================================================================================
// CLASS TCalcDialog
//========================================================================================
#undef Inherited
#define Inherited TPicture


MA_DEFINE_CLASS(TCalcDialog);

//----------------------------------------------------------------------------------------
// TCalcDialog destructor
//----------------------------------------------------------------------------------------


TCalcDialog::~TCalcDialog()
{
}

//----------------------------------------------------------------------------------------
// TCalcDialog::DoEvent: 
//----------------------------------------------------------------------------------------


void TCalcDialog::DoEvent(EventNumber eventNumber,
						  TEventHandler* source,
						  TEvent* event)
{
	// dcs - 3.0 fix : Bad News. its either this or a mess of FindSubView calls..
	// Can we count on source being a view at this call.. Hmmm..
	//	origID = source->fIdentifier;
	IDType origID = dynamic_cast_AC(TView*,source)->GetIdentifier();
	char keyHit = static_cast<char>(origID & 0xFF);	// strip all but the last letter of the ID, which
										// we've assigned to the name of the key
	switch (eventNumber)
	{
		case mOKHit:							/*??? Should be mControlHit*/
			switch (keyHit)
			{
				case 'C':
					ClearSum();
					break;
				case '=':
				case 'E':
					TotalSum(noOperator);
					break;
				case '/':
					TotalSum(divOperator);
					break;
				case '*':
					TotalSum(mulOperator);
					break;
				case '-':
					TotalSum(subOperator);
					break;
				case '+':
					TotalSum(addOperator);
					break;
				default:
					NewDigit(keyHit);
					break;
			}
			break;

		default:
			Inherited::DoEvent(eventNumber, source, event);
			break;
	}
}


//----------------------------------------------------------------------------------------
// TCalcDialog::DoKeyEvent: 
//----------------------------------------------------------------------------------------


void TCalcDialog::DoKeyEvent(TToolboxEvent* event)
{
	bool invalidKeyStroke = false;

	// Determine the ID to find the view which will be used as the originator of the keystroke 
	IDType	theID;
	if (event->GetKeyCode() == kClearVirtualCode)
		theID = 'keyC';
	else
	{
		if (event->GetText() == '0'
		|| event->GetText() == '1'
		|| event->GetText() == '2'
		|| event->GetText() == '3'
		|| event->GetText() == '4'
		|| event->GetText() == '5'
		|| event->GetText() == '6'
		|| event->GetText() == '7'
		|| event->GetText() == '8'
		|| event->GetText() == '9'
		|| event->GetText() == '.'
		|| event->GetText() == '+'
		|| event->GetText() == '-'
		|| event->GetText() == '*'
		|| event->GetText() == '/'
		|| event->GetText() == '='
		|| event->GetText() == '1')
			theID = 'key ' | event->GetText()[1];
		else if (event->GetText() == chEnter || event->GetText() == chReturn)
			theID = 'keyE';
		else
			invalidKeyStroke = true;
	}

	if (!invalidKeyStroke)
	{
		TView *	theView = FindSubView(theID);
		if (theView)
			dynamic_cast_AC(TControl*,(theView))->Flash();
		HandleEvent(mOKHit, theView, NULL);
	}
	else
		SysBeep(1);
}

//----------------------------------------------------------------------------------------
// TCalcDialog::ClearSum: 
//----------------------------------------------------------------------------------------


void TCalcDialog::ClearSum()
{
	fArgument = 0;
	fSum = 0;
	fOperator = noOperator;
	fDecimalPoint = false;
	fRestart = true;
	dynamic_cast_AC(TStaticText*,(FindSubView('SUMM')))->SetText("0", true);
}

//----------------------------------------------------------------------------------------
// TCalcDialog::FetchValue: 
//----------------------------------------------------------------------------------------


double TCalcDialog::FetchValue()
{
	return atof(CChar255_AC(dynamic_cast_AC(TStaticText*,FindSubView('SUMM'))->GetText()));
}

//----------------------------------------------------------------------------------------
// TCalcDialog::SetValue: 
//----------------------------------------------------------------------------------------

void TCalcDialog::SetValue()
{
	double		aDouble = fSum;
	CString_AC	theStr;
	
	if (aDouble == 0)
		theStr = "0";
	else
	{
		double		orderOfMagnitude
						 = log2(fabs(aDouble)) / log2(10);	// this says how many digits are 
															// left of the decimal point;

		if ((orderOfMagnitude > kMaxPlaces - 1) || (orderOfMagnitude < -6))
		{
			short mantissaLength;
			
			orderOfMagnitude = log2(fabs(orderOfMagnitude)) / log2(10);// find the order of the exponent
			if (orderOfMagnitude > 2)
				mantissaLength = kMaxPlaces - 9;
			else
				mantissaLength = kMaxPlaces - 7;
				
			stringprintf(theStr, "%.*e", mantissaLength, aDouble);	// use floating point conversion
		}
		else
		{
			stringprintf(theStr, "%.*f", kMaxPlaces - 1, aDouble);
			Truncate(theStr);					// strip insignificant zeros / decimal point

			// now we must make sure it fits in the space in the dialog, which we know to be
			// kMaxPlaces wide (aren't fixed width fonts great?).  If the number is still too
			// large, we can just chop off what's off the end, because we know that the most
			// significant part of the number will still be correctly represented.
			if (theStr.size() > kMaxPlaces)		
				theStr.resize(kMaxPlaces);
		}
	}
	dynamic_cast_AC(TStaticText*,(FindSubView('SUMM')))->SetText(theStr, true);
}

//----------------------------------------------------------------------------------------
// TCalcDialog::Truncate: 
//----------------------------------------------------------------------------------------

void TCalcDialog::Truncate(CString_AC& theStr)
{
	if (theStr.size() > 0)
	{
		// First find the last non-zero character in the string.
		CString_AC::size_type	lastNonZero = theStr.find_last_not_of("0");
		
		// Now see if the last character is a period.
		if (lastNonZero != CString_AC::npos && lastNonZero >= 0 && theStr[lastNonZero] == '.')
		{
			if (lastNonZero > 0)
				--lastNonZero;
			else
				lastNonZero = CString_AC::npos;
		}
			
		// Either do the truncating or set the string to "0".
		if (lastNonZero == CString_AC::npos)
			theStr = "0";
		else if (lastNonZero < (theStr.size() - 1))
			theStr.resize(lastNonZero + 1);
		
	}
	else
		theStr = "0";
}

//----------------------------------------------------------------------------------------
// TCalcDialog::TotalSum: 
//----------------------------------------------------------------------------------------

void TCalcDialog::TotalSum(CalcOperator newOperator)
{
	fArgument = FetchValue();
	switch (fOperator)
	{
		case noOperator:
			fSum = fArgument;
			break;
		case divOperator:
			fSum = fSum / fArgument;
			break;
		case mulOperator:
			fSum = fSum * fArgument;
			break;
		case subOperator:
			fSum = fSum - fArgument;
			break;
		case addOperator:
			fSum = fSum + fArgument;
			break;
	}
	SetValue();
	fRestart = true;
	fArgument = fSum;
	fOperator = newOperator;
}

//----------------------------------------------------------------------------------------
// TCalcDialog::NewDigit: 
//----------------------------------------------------------------------------------------


void TCalcDialog::NewDigit(char theNumber)

{
	TStaticText* theText = dynamic_cast_AC(TStaticText*,(FindSubView('SUMM')));
	CString_AC theStr;
	if (!fRestart)
		theStr = theText->GetText();

	if (theStr.size() < kMaxPlaces - 1)	// is there room for another digit? 
	{
		fRestart = false;
		if ((theNumber == '.') && !fDecimalPoint)
			fDecimalPoint = true;
		theStr += theNumber;	// append the char onto the end
		theText->SetText(theStr, true);
	}
}


//========================================================================================
// CLASS TAdornmentDemo
//========================================================================================
#undef Inherited
#define Inherited TView


MA_DEFINE_CLASS(TAdornmentDemo);

//----------------------------------------------------------------------------------------
// TAdornmentDemo constructor 
//----------------------------------------------------------------------------------------


TAdornmentDemo::TAdornmentDemo() :
	fTestView(NULL)
{
}

//----------------------------------------------------------------------------------------
// TAdornmentDemo destructor
//----------------------------------------------------------------------------------------


TAdornmentDemo::~TAdornmentDemo()
{
}

//----------------------------------------------------------------------------------------
// TAdornmentDemo::DoPostCreate: 
//----------------------------------------------------------------------------------------


void TAdornmentDemo::DoPostCreate(TDocument* itsDocument)
{
	Inherited::DoPostCreate(itsDocument);

	fTestView = FindSubView('test');
}

//----------------------------------------------------------------------------------------
// TAdornmentDemo::DoEvent: 
//----------------------------------------------------------------------------------------


void TAdornmentDemo::DoEvent(EventNumber eventNumber,
							 TEventHandler* source,
							 TEvent* event)
{
	TView *			whichView;
	AdornPriority	priority;

	// Each adorner has the same class signature and ID as the ID of the corresponding checkbox 
	if (eventNumber == mCheckBoxHit)
	{

		if (source->GetIdentifier() == 'gray')
		{
			priority = kAdornFirst;
			whichView = this;
		}
		else if (source->GetIdentifier() == 'fram')
		{
			priority = kAdornLast;				// lower than the embossed frame adorner 
			whichView = fTestView;
		}
		else
		{
			priority = kAdornAfter;
			whichView = fTestView;
		}

		if (dynamic_cast_AC(TCheckBox*,source)->IsOn())
			whichView->AddAdorner(TAdorner::NewStdAdorner(source->GetIdentifier(),
														  CChar255_AC(gEmptyString),
														  source->GetIdentifier(),
														  kFreeOnDeletion), priority, kRedraw);
		else
			whichView->DeleteAdornerByID(source->GetIdentifier(), kRedraw);

	}
	else
		Inherited::DoEvent(eventNumber, source, event);
}


//========================================================================================
// CLASS TEmbossedFrame
//========================================================================================
#undef Inherited
#define Inherited TAdorner


MA_DEFINE_CLASS(TEmbossedFrame);

//----------------------------------------------------------------------------------------
// TEmbossedFrame destructor
//----------------------------------------------------------------------------------------


TEmbossedFrame::~TEmbossedFrame()
{
}

//----------------------------------------------------------------------------------------
// TEmbossedFrame::Draw: 
//----------------------------------------------------------------------------------------


void TEmbossedFrame::Draw(TView* itsView, const CViewRect&	/*area*/)
{
	PenNormal();

	CRect_AC QDArea(itsView->ViewToQD(itsView->GetAdornExtent()));
	CRect_AC tempRect(QDArea);

	// ¥ Build the region to use for filling, first create the outer region
	QDArea.Inset(1, 1);
	CTempRegion_AC outerRgn = NewRgn();
	RectRgn(outerRgn, QDArea);

	// ¥ Create the inner region
	MacInsetRect(QDArea, 6, 6);
	CTempRegion_AC innerRgn = NewRgn();
	RectRgn(innerRgn, QDArea);

	// ¥ Finally subtract the inner from the outer region
	DiffRgn(outerRgn, innerRgn, outerRgn);

	// ¥ Set the foreground color to the global face color, this allows the user to
	//	 change the color of the face																										
	SetIfColor(kRGBColorRamp[r2]);
	MacPaintRgn(outerRgn);

	// ¥ Draw the inside black frame
	SetIfColor(gRGBBlack);
	QDArea.Inset(1, 1);
	MacFrameRect(&QDArea);

	// ¥ Draw the shadows
	// THIS WAS "WITH tempRect"
	{
		// ¥ Draw the outer gray shadow
		SetIfColor(kRGBColorRamp[r7]);
		MoveTo(tempRect.left + 1, tempRect.bottom - 1);		//(h, v)
		LineToPt(tempRect[botRight] - CPoint_AC(1, 1));	//(h, v)
		MacLineTo(tempRect.right - 1, tempRect.top + 1);		//(h, v)

		// ¥ Draw the inner gray shadow	
		SetIfColor(kRGBColorRamp[r7]);
		MoveTo(tempRect.left + 7, tempRect.bottom - 8);		//(h, v)
		LineToPt(tempRect[topLeft] + CPoint_AC(7, 7));		//(h, v)
		MacLineTo(tempRect.right - 8, tempRect.top + 7);		//(h, v)
	}

	// ¥ Restore the drawing environment
	itsView->SetupDrawingEnvironment();
}


//========================================================================================
// CLASS TGrayFill
//========================================================================================
#undef Inherited
#define Inherited TAdorner


MA_DEFINE_CLASS(TGrayFill);

//----------------------------------------------------------------------------------------
// TGrayFill destructor
//----------------------------------------------------------------------------------------


TGrayFill::~TGrayFill()
{
}

//----------------------------------------------------------------------------------------
// TGrayFill::Draw: 
//----------------------------------------------------------------------------------------


void TGrayFill::Draw(TView* itsView,
					 const CViewRect& /*area*/)
{
	// ¥ Save off the current pen state and the foreground color
	PenState	savePenState;
	GetPenState(&savePenState);
	CRGBColor_AC saveColor(GetIfColor());
	PenNormal();

	SetIfColor(kRGBColorRamp[r7]);
	::PaintRect(itsView->ViewToQD(itsView->GetAdornExtent()));

	// ¥ Restore the foreground color and the pen
	SetIfColor(saveColor);
	SetPenState(&savePenState);
}


//========================================================================================
// CLASS TEtchedFrame
//========================================================================================
#undef Inherited
#define Inherited TAdorner


MA_DEFINE_CLASS(TEtchedFrame);

//----------------------------------------------------------------------------------------
// TEtchedFrame constructor 
//----------------------------------------------------------------------------------------


TEtchedFrame::TEtchedFrame() :
	fInset(1, 1)
{
}

//----------------------------------------------------------------------------------------
// TEtchedFrame destructor
//----------------------------------------------------------------------------------------


TEtchedFrame::~TEtchedFrame()
{
}

//----------------------------------------------------------------------------------------
// TEtchedFrame::Draw: 
//----------------------------------------------------------------------------------------


void TEtchedFrame::Draw(TView* itsView, const CViewRect& /*area*/)
{
	// ¥ Save off the current pen state and the foreground color
	PenState	savePenState;
	GetPenState(&savePenState);

	CRGBColor_AC saveColor(GetIfColor());
	PenNormal();

	CRect_AC QDArea(itsView->ViewToQD(itsView->GetAdornExtent()));

	SetIfColor(gRGBBlack);
	QDArea.Inset(fInset);
	MacFrameRect(QDArea);									// Draw the shadows 

	QDArea.Offset(1, 1);
	SetIfColor(gRGBWhite);
	MacFrameRect(QDArea);									// Draw the light edges 

	QDArea.Offset( -1, -1);
	SetCPixel(QDArea.left, QDArea.bottom, gRGBBlack);	// Finish the corners 
	SetCPixel(QDArea.right, QDArea.top, gRGBBlack);

	// ¥ Restore the foreground color and the pen
	SetIfColor(saveColor);
	SetPenState(&savePenState);
}


//========================================================================================
// CLASS TSlowScroller
//========================================================================================
#undef Inherited
#define Inherited TScroller


MA_DEFINE_CLASS(TSlowScroller);

//----------------------------------------------------------------------------------------
// TSlowScroller destructor
//----------------------------------------------------------------------------------------


TSlowScroller::~TSlowScroller()
{
}

//----------------------------------------------------------------------------------------
// TSlowScroller::ScrollStep: 
//----------------------------------------------------------------------------------------


ViewCoordinate TSlowScroller::ScrollStep(VHSelect vhs, short partCode)
{
	ViewCoordinate scrollUnit = fScrollUnit[vhs];
	if (IsControlKeyDown())
		scrollUnit = 1;
	ViewCoordinate delta;

	switch (partCode)
	{
		case kControlUpButtonPart:
		case kControlDownButtonPart:
			delta = scrollUnit;
			break;
			
		case kControlPageUpPart:
		case kControlPageDownPart:
			if (IsControlKeyDown())
				delta = 1;
			else
				delta = fSize[vhs] - scrollUnit;
			break;
			
#if qDebug
		default:
			{
				CStr255_AC theString;
				ConcatNumber("TScroller::ScrollStep: bad part code =", partCode, theString);
				ProgramBreak_AC(CChar255_AC(theString));
			}
			break;
#endif

	}

	if ((partCode == kControlUpButtonPart) || (partCode == kControlPageUpPart))
		delta = -delta;

	// Constrain if necessary 
	if (fConstrain[vhs] && scrollUnit)
	{
		ViewCoordinate adjustment = (Max_AC(0, fTranslation[vhs] + delta)) % scrollUnit;
		if (adjustment)
			if (delta > 0)
				delta -= adjustment;
			else
				delta += (scrollUnit - adjustment);
	}

	CViewPoint deltaPt;
	deltaPt[vhs] = delta;

	DoScroll(deltaPt, kRedraw);
	return delta;
}

//========================================================================================
// CLASS TShowErrorBehavior
//========================================================================================

#undef Inherited

MA_DEFINE_CLASS(TShowErrorBehavior);

//----------------------------------------------------------------------------------------
// TShowErrorBehavior::DoEvent: 
//----------------------------------------------------------------------------------------

void TShowErrorBehavior::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event)
// DoEvent will present an error alert whenever the Show Error button is pressed.
{
	const IDType		errNumID = 'ErNm';
	const IDType		msgNumID = 'MsNm';

	if (eventNumber == mButtonHit)
	{
		TView*			myView = dynamic_cast_or_throw_AC(TView*, GetOwner());
		TWindow*		myWindow = myView->GetWindow();
		ThrowIfNULL_AC(myWindow);
		TNumberText*	errNumView = dynamic_cast_or_throw_AC(TNumberText*, myWindow->FindSubView(errNumID));
		TNumberText*	msgNumView = dynamic_cast_or_throw_AC(TNumberText*, myWindow->FindSubView(msgNumID));
		long			errNum = errNumView->GetValue();
		long			msgNum = msgNumView->GetValue();
		gDispatcher->ShowError(errNum, msgNum);
	}

	TBehavior::DoEvent(eventNumber, source, event);
}

//========================================================================================
// CLASS TMsgNumPopupBehavior
//========================================================================================

#undef Inherited

MA_DEFINE_CLASS(TMsgNumPopupBehavior);

//----------------------------------------------------------------------------------------
// TMsgNumPopupBehavior::DoEvent: 
//----------------------------------------------------------------------------------------

void TMsgNumPopupBehavior::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event)
// DoEvent will cause the command number to be placed into the message number
// edit field.
{
	const IDType		msgNumID = 'MsNm';

	enum
	{
						cCloseAll		= 93,
						cArrangeIcons	= 92,
						cCascadeWindows	= 91,
						cTileWindows	= 90
	};

	const long msgNums[] = {cAboutApp, 0, cNew, cOpen, cClose,
							cCloseAll, cSave, cSaveAs, cSaveCopy, cRevert,
							cPageSetup, cPrint, cQuit, 0, cUndo,
							cRedo, cUndoRedo, cCut, cCopy, cPaste,
							cClear, cSelectAll, cShowClipboard, 0, cDrag,
							cDragMove, cDragMoveOut, cDragPrint, cDragView, cDrop,
							cFinderNew, cFinderOpen, cFinderPrint, cFinderQuit, 0,
							cChangePrinterStyle, cCustomPageSetup, cPrFileBase, cPrFileMax, cPrViewBase,
							cPrViewMax, cPrintOne, cPrintSelection, cPrintSpoolFile, cPrintToFile,
							cShowBreaks, 0, cInsert, cMouseCommand, cArrangeIcons,
							cCascadeWindows, cTileWindows, 0, cReduce50, cReduceToFit, 
							cRememberStyle, cShowBorders, cShowFullSize, cStyleChange, cTrackingControl, 
							cTyping, 0, cAppleEventReply, cAEClone, cAEClose, 
							cAECopy, cAECountElements, cAECreateElement, cAECut, cAEDelete, 
							cAEDoObjectsExist, cAEGetClassInfo, cAEGetData, cAEPrint, cAERevert, cAESave, 
							cAESetData, cAEUndo};
	if (eventNumber == mPopupHit)
	{
		TPopup*			myPopup = dynamic_cast_or_throw_AC(TPopup*, GetOwner());
		TWindow*		myWindow = myPopup->GetWindow();
		ThrowIfNULL_AC(myWindow);
		TNumberText*	msgNumView = dynamic_cast_or_throw_AC(TNumberText*, myWindow->FindSubView(msgNumID));
		msgNumView->SetValue(static_cast<long>(msgNums[myPopup->GetCurrentItem() - 1]), kRedraw);
	}

	TBehavior::DoEvent(eventNumber, source, event);
}

//========================================================================================
// CLASS TEnablePopupItemsBehavior
//========================================================================================

#undef Inherited

MA_DEFINE_CLASS(TEnablePopupItemsBehavior);

//----------------------------------------------------------------------------------------
// TEnablePopupItemsBehavior::DoSetupMenus: 
//----------------------------------------------------------------------------------------

void TEnablePopupItemsBehavior::DoSetupMenus()
// DoSetupMenus will enable all of the items in the popup with ID 'MsgP'.
{
	const IDType	msgPopupID = 'MsgP';

	TBehavior::DoSetupMenus();

	TView*			myView = dynamic_cast_or_throw_AC(TView*, GetOwner());
	TPopup*			msgPopupView = dynamic_cast_or_throw_AC(TPopup*, myView->FindSubView(msgPopupID));
	
	for (short i = 1; i <= 88; ++i)
		msgPopupView->EnableItem(i, true);
}

//----------------------------------------------------------------------------------------
// End of UDemoDialogs.More.cp



/*
	Historical Change Record:
		09/30/99	LineTo now MacLineTo.
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		 5/17/96	Account for dependencies not being in TObject anymore by mixing
		 					MDependable_AC into TUpdateBehavior.
		 5/08/96	Cleanup CRGBColor_AC and add new class CTextStyle_AC
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/26/96	Made TControl::ControlArea/ControlQDArea non virtual. Made TView/TControl::GetAdornExtent
							return their CViewRect as function results
		04/11/96	Supply missing paren to static_cast_AC usage
		----- R10 -----
		03/26/96	Cleanup references to gEmptyString and ""
		03/26/96	coerce CStrxxx_AC to const char* to get copies of the strings as c style strings
		03/18/96	Remove compatibility hacks.
		10/19/95	Use MoveToPt, LineToPt.
		 10/5/95	[1136797] Replace trackPress with trackBegin and trackRelease
		 					with trackEnd.
		----- 3.3b1 -----
		 3/23/95	Removed THomeBrewDialog. It consisted of an empty destructor and
		 					a DoPostCreate method. DoPostCreate set letsSubViewsHandleCursor
		 					to false, which was WRONG!
		 2/21/95	Add compatibility hack so we can compile with the 1.0 headers. 
		02/20/95	Update for USESOLDROUTINENAMES=0. 
		 6/27/94	Add TSlowScroller. 
*/