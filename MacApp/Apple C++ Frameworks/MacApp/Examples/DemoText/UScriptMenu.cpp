//----------------------------------------------------------------------------------------
// UScriptMenu.cpp
// Copyright © 1986-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/04/01	Clean up string casting. 
		01/02/01	Update copyright.
		11/17/00	Use CopyTo for setting an FSSpecÕs file name.
		02/23/00	[C] Use a CTempDesc_AC in InstallGlobalsScript and
					InstallSharedScript.
		09/30/99	InsertMenu now MacInsertMenu.  AppendMenu now MacAppendMenu.
		03/24/99	Update copyright notice.
		01/15/99	CAEDesc_AC is now in ACS. 
*/

#ifndef __USCRIPTMENU__
#include "UScriptMenu.h"
#endif

// MacApp

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UOSASCRIPT__
#include "UOSAScript.h"
#endif

#ifndef __USCRIPTING__
#include "UScripting.h"
#endif

// Toolbox

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

//----------------------------------------------------------------------------------------
// Global Functions: 
//----------------------------------------------------------------------------------------
OSErr GetAppLocation(short refNum,
					 short& vRefNum,
					 long& dirID,
					 CStr255_AC& fileName);
void FindFiles(OSType theType,
			   OSType theCreator,
			   CFSSpec_AC& inFSSpec,
			   long& numToFind,
			   CFSSpec_AC* theFSSpecs);

//----------------------------------------------------------------------------------------
// GetAppLocation: 
//----------------------------------------------------------------------------------------

OSErr GetAppLocation(short refNum,
					 short& vRefNum,
					 long& dirID,
					 CStr255_AC& fileName)
{
	FCBPBRec pb;
	OSErr error;

	pb.ioNamePtr = (StringPtr) & fileName;
	pb.ioVRefNum = 0;
	pb.ioRefNum = refNum;
	pb.ioFCBIndx = 0;
	error = PBGetFCBInfoSync(&pb);
	vRefNum = pb.ioFCBVRefNum;
	dirID = pb.ioFCBParID;
	return (error);
}

//----------------------------------------------------------------------------------------
// FindFiles: 
//----------------------------------------------------------------------------------------

void FindFiles(OSType theType,
			   OSType theCreator,
			   CFSSpec_AC& inFSSpec,
			   long& numToFind,
			   CFSSpec_AC* theFSSpecs)
{
	const short kBufferSize = 16384;
	CInfoPBRec spec1, spec2;
	CSParam pb;
	short err = 0;
	short bufferSize = kBufferSize;

	CTempHandle_AC buffer(TempNewHandle(kBufferSize, &err));
	::ThrowIfNULL_AC(buffer);
	HLock(buffer);
	Ptr bufferPtr = *(Handle)buffer;

	spec1.hFileInfo.ioFlFndrInfo.fdType = theType;
	spec1.hFileInfo.ioFlFndrInfo.fdCreator = theCreator;
	spec1.hFileInfo.ioNamePtr = NULL;
	spec1.hFileInfo.ioFlParID = inFSSpec.parID;

	spec2.hFileInfo.ioFlFndrInfo.fdType = (OSType)0xffffffff;
	spec2.hFileInfo.ioFlFndrInfo.fdCreator = (OSType)0xffffffff;
	spec2.hFileInfo.ioFlParID = inFSSpec.parID;
	spec2.hFileInfo.ioNamePtr = NULL;
	spec2.hFileInfo.ioFlFndrInfo.fdFlags = 0x0000;
	spec2.hFileInfo.ioFlFndrInfo.fdLocation.h = 0x0000;
	spec2.hFileInfo.ioFlFndrInfo.fdLocation.v = 0x0000;
	spec2.hFileInfo.ioFlFndrInfo.fdFldr = 0x0000;

	pb.ioCompletion = NULL;
	pb.ioNamePtr = NULL;
	pb.ioMatchPtr = (FSSpecPtr)theFSSpecs;
	pb.ioReqMatchCount = numToFind;
	pb.ioSearchBits = fsSBFlFndrInfo + fsSBFlParID;
	pb.ioSearchInfo1 = (CInfoPBPtr) & spec1;
	pb.ioSearchInfo2 = (CInfoPBPtr) & spec2;
	pb.ioSearchTime = 0;
	pb.ioOptBuffer = bufferPtr;
	pb.ioOptBufSize = bufferSize;

	pb.ioCatPosition.initialize = 0;
	pb.ioVRefNum = inFSSpec.vRefNum;
	err = PBCatSearchSync(&pb);
	if ((err != noErr) && (err != -39))
		::ThrowIfOSErr_AC(err);
	numToFind = pb.ioActMatchCount;
}

//----------------------------------------------------------------------------------------
// TScriptMenuBehavior
//----------------------------------------------------------------------------------------

#undef Inherited
#define Inherited TBehavior


MA_DEFINE_CLASS(TScriptMenuBehavior);

//----------------------------------------------------------------------------------------
// TScriptMenuBehavior::TScriptMenuBehavior: 
//----------------------------------------------------------------------------------------

TScriptMenuBehavior::TScriptMenuBehavior() :
	TBehavior('osas')
{	
	if (HasAppleScript_AC())
	{
		CStr63_AC scriptFolderName(kScriptMenuStrings, kFolderName);
		CStr63_AC globalsScriptName(kScriptMenuStrings, kGlobalsScript);
		CStr63_AC sharedScriptName(kScriptMenuStrings, kSharedScript);
		CStr63_AC startupScriptName(kScriptMenuStrings, kStartupScript);
		
		long stdScriptsFound = 0;
		ComponentInstance theCmp = COSAScript::GetDefaultComponent();
		
		InstallGlobalsScript(theCmp, scriptFolderName, globalsScriptName, stdScriptsFound);
		InstallSharedScript(theCmp, sharedScriptName, stdScriptsFound);
		ExecuteStartupScript(theCmp, startupScriptName, stdScriptsFound);
		AddScriptMenu(globalsScriptName, sharedScriptName, startupScriptName, stdScriptsFound);
	}
}

//----------------------------------------------------------------------------------------
// TScriptMenuBehavior destructor
//----------------------------------------------------------------------------------------

TScriptMenuBehavior::~TScriptMenuBehavior()
{
}

//----------------------------------------------------------------------------------------
// TScriptMenuBehavior::InstallGlobalsScript: 
//----------------------------------------------------------------------------------------

void TScriptMenuBehavior::InstallGlobalsScript(ComponentInstance theCmp,
											   const CStr63_AC& scriptFolderName,
											   const CStr63_AC& globalsScriptName,
											   long& stdScriptsFound)
{
	COSAScript globalsScript;
	OSErr err = noErr;
	
	CStr32_AC delimeter = HasAUX_AC() ? "/" : ":";

	// Look for a globals script
	CStr255_AC fileName;
	short appRef = LMGetCurApRefNum();
	CFSSpec_AC theSpec;
	::ThrowIfOSErr_AC(GetAppLocation(appRef, theSpec.vRefNum, theSpec.parID, fileName));
	fileName = delimeter + scriptFolderName + delimeter + globalsScriptName;
	err = FSMakeFSSpec(theSpec.vRefNum, theSpec.parID, fileName, &theSpec);
	fScriptFolder = theSpec;

#if 1
	globalsScriptName.CopyTo(theSpec.name);
#else
	(CStr63_AC &)theSpec.name = globalsScriptName;
#endif
	AliasHandle theAliasHdl = NULL;
	err = NewAliasMinimal(&theSpec, &theAliasHdl);
	if (err == noErr)
	{
#if !qCarbon
		CAEDesc_AC globalsAliasDesc(typeAlias, (Handle)theAliasHdl);
#else
		CTempDesc_AC globalsAliasDesc(typeAlias, (Handle)theAliasHdl);
#endif
		::ThrowIfOSErr_AC(globalsScript.SetScript(theCmp, globalsAliasDesc, 
										  kOSAModeCompileIntoContext, kOSAModeNull));
		COSAScript::SetGlobalScript(globalsScript);
		++stdScriptsFound;
	}
	theAliasHdl = (AliasHandle)DisposeIfHandle_AC((Handle)theAliasHdl);
}

//----------------------------------------------------------------------------------------
// TScriptMenuBehavior::InstallSharedScript: 
//----------------------------------------------------------------------------------------

void TScriptMenuBehavior::InstallSharedScript(ComponentInstance theCmp,
											  const CStr63_AC& sharedScriptName,
											  long& stdScriptsFound)
{
	OSErr err = noErr;
	CFSSpec_AC theSpec = fScriptFolder;
	sharedScriptName.CopyTo(theSpec.name);
	AliasHandle theAliasHdl = NULL;
	err = NewAliasMinimal(&theSpec, &theAliasHdl);
	if (err == noErr)
	{
#if !qCarbon
		CAEDesc_AC sharedAliasDesc(typeAlias, (Handle)theAliasHdl);
#else
		CTempDesc_AC sharedAliasDesc(typeAlias, (Handle)theAliasHdl);
#endif
		COSAScript sharedScript;
		::ThrowIfOSErr_AC(sharedScript.SetScript(theCmp, sharedAliasDesc, kOSAModeCompileIntoContext, kOSAModeNull));
		COSAScript::SetSharedScript(sharedScript);
		++stdScriptsFound;
	}
	theAliasHdl = (AliasHandle)DisposeIfHandle_AC((Handle)theAliasHdl);
}

//----------------------------------------------------------------------------------------
// TScriptMenuBehavior::ExecuteStartupScript: 
//----------------------------------------------------------------------------------------

void TScriptMenuBehavior::ExecuteStartupScript(ComponentInstance theCmp,
											   const CStr63_AC& startupScriptName,
											   long& stdScriptsFound)
{
	OSErr err = noErr;
	{
		CFSSpec_AC theSpec = fScriptFolder;
#if 1
		startupScriptName.CopyTo(theSpec.name);
#else
		(CStr63_AC &)theSpec.name = startupScriptName;
#endif
		AliasHandle theAliasHdl = NULL;
		err = NewAliasMinimal(&theSpec, &theAliasHdl);
		if (err == noErr)
		{
#if !qCarbon
			CAEDesc_AC startupAliasDesc(typeAlias, (Handle)theAliasHdl);
#else
			CTempDesc_AC startupAliasDesc(typeAlias, (Handle)theAliasHdl);
#endif
			COSAScript startupScript;
			::ThrowIfOSErr_AC(startupScript.SetScript(theCmp, startupAliasDesc, kOSAModeCompileIntoContext, kOSAModeNull));
			COSAScript aResult;
			COSAScript globalsScript = COSAScript::GetGlobalScript();
			startupScript.Execute(theCmp, globalsScript, kOSAModeNull, aResult.fScriptID);
			aResult.DisposeScript(theCmp);
			++stdScriptsFound;
		}
		theAliasHdl = (AliasHandle)DisposeIfHandle_AC((Handle)theAliasHdl);
	}
}

//----------------------------------------------------------------------------------------
// TScriptMenuBehavior::AddScriptMenu: 
//----------------------------------------------------------------------------------------

void TScriptMenuBehavior::AddScriptMenu(const CStr63_AC& globalsScriptName,
										const CStr63_AC& sharedScriptName,
										const CStr63_AC& startupScriptName,
										long& stdScriptsFound)
{
	gApplication->SetupTheMenus();
	long numScripts = 20;
	CFSSpec_AC* theSpecs = (CFSSpec_AC *)NewPtr(sizeof(CFSSpec_AC) * numScripts);
	CFSSpec_AC theSpec = fScriptFolder;
	FindFiles('osas', 'ToyS', theSpec, numScripts, theSpecs);
	if ((numScripts - stdScriptsFound) > 0)
	{
		CStr255_AC fileName;
		MenuRef scriptMenu = MAGetMenu(mScripts);
		MacInsertMenu(scriptMenu, /* mScripts, */ 0);
		CFSSpec_AC* aScriptSpec = theSpecs;
		short theMItem = 1;
		while (numScripts--)
		{
			fileName = aScriptSpec->name;
			if ((fileName != globalsScriptName) &&
				(fileName != sharedScriptName) &&
				(fileName != startupScriptName))
			{
				MacAppendMenu(scriptMenu, "\ptemp");
				fileName = aScriptSpec->name;
				SetMenuItemText(scriptMenu, theMItem++, fileName);
			}
			++aScriptSpec;
		}
	}
	TMenuBarManager::InvalidateMenuBar();
	theSpecs = (CFSSpec_AC *)DisposeIfPtr_AC((Ptr)theSpecs);
}

//----------------------------------------------------------------------------------------
// TScriptMenuBehavior::DoMenuCommand:
//----------------------------------------------------------------------------------------

void TScriptMenuBehavior::DoMenuCommand(CommandNumber aCommandNumber)
{
	CStr255_AC aName;
	short menu;
	short item;
	CommandToMenuItem(aCommandNumber, menu, item);
	if (menu == mScripts)
	{
		GetMenuItemText(MAGetMenu(menu), item, aName);
		CFSSpec_AC theSpec = fScriptFolder;
		aName.CopyTo(theSpec.name);
		AliasHandle theAliasHdl = NULL;

		OSErr err = NewAliasMinimal(&theSpec, &theAliasHdl);
		if (err == noErr)
		{
			ComponentInstance theCmp = COSAScript::GetDefaultComponent();
#if !qCarbon
			CAEDesc_AC scriptAliasDesc(typeAlias, (Handle)theAliasHdl);
#else
			CTempDesc_AC scriptAliasDesc(typeAlias, (Handle)theAliasHdl);
#endif
			COSAScript theScript;
			::ThrowIfOSErr_AC(theScript.SetScript(theCmp, scriptAliasDesc, kOSAModeCompileIntoContext, kOSAModeNull));

			fOwner->PostCommand(TH_new TExecuteScriptCommand(cNoCommand, dynamic_cast_AC(TCommandHandler*,fOwner), false, false, fOwner, theScript, kOSANullScript, kOSAModeNull, false, theCmp));
			TMenuBarManager::HiliteMenu(0);			// Go ahead and unhilite the menu item since this script might
			// cause a context switch and MacApp won't unhilite it until later.
		}
	}
	else
		Inherited::DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// End of UScriptMenu.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		05/08/96	Create and use CFSSpec_AC. You should search/replace in your code to switch to
		 					CFSSpec_AC.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/26/96	Fix some compile bugs
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		----- R10 -----
		04/01/96	Fix copyright date and release marker.
		03/28/99	Added prototypes for GetAppLocation/FindFiles 
		----- 3.3 -----
		----- 3.3b1 -----
		07/28/95	Add configuration functions to use instead of gConfiguration. 
		07/26/95	Use OSAID instead of COSAScript. 
							Modularize IScriptMenuBehavior. 
		06/13/95	Fix to compile with changes to scripting dispatcher. 
		05/16/95	MenuRef
		04/04/95	Sort the includes. 
		03/17/95	MAVolatile. 
		03/07/95	1161932	(SPEED) HiliteMenu takes 13% of execution time + fix
		03/14/95	Include UApplication and UMenuMgr. 
		02/20/95	Fixes to compile with CFront. 
		02/14/95	Second batch of attachability changes. 
*/