//----------------------------------------------------------------------------------------
// UTEDocument.cpp
// Copyright © 1990-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/16/01	DoNeedDiskSpace is now const.  Cosmetic.
		01/02/01	Update copyright.
		11/27/00	Can't cast gEmptyString object to a pointer. 
		11/17/00	[C] DonÕt include Balloons.h, or Packages.h.
		07/13/00	Removed dead MA_DEFINE_CLASS of TTEDocument.
		06/23/00	Removed GetRegionCode call.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		04/18/00	Include UPrintMg.hr instead of UPrinting.h
		12/08/99	Take out MA_DEFINE_CLASS of TTEDocument.  Actually use
					exception in DoRead.
		11/19/99	After creating the window, open and select it.
					Now use EnableMenuItems_AC.
		09/30/99	SetPort now MacGetPort. EnableMenuItem now MacEnableMenuItem. 
					Carbon: CountMItems now CountMenuItems.	CheckItem now CheckMenuItem.
		03/24/99	Update copyright notice.
		11/13/98	[2279266] Removed const from itsScrapType in ctor.
		11/09/98	For Carbon, don't include Editions.h
		11/03/98	Carbonize: EnableItem becomes EnableMenuItem
*/

#ifndef __UTEDOCUMENT__
#include "UTEDocument.h"
#endif

// MacApp

#ifndef __CPoint_AC__
#include "CPoint_AC.h"
#endif

#ifndef __CRect_AC__
#include "CRect_AC.h"
#endif

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

#ifndef __UERRORMGR__
#include "UErrorMgr.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPATCH__
#include "UPatch.h"
#endif

#if UsingDemoTextPrinting
	#ifndef __UPRINTING__
	#include "UPrinting.h"
	#endif
#endif

#ifndef __UTECOMMANDS__
#include "UTECommands.h"
#endif

#ifndef __UTEVIEW__
#include "UTEView.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __MenuUtils_AC__
#include "MenuUtils_AC.h"
#endif

// Toolbox

#ifndef __ALIASES__
#include <Aliases.h>
#endif

#ifndef __DIALOGS__
#include <Dialogs.h>
#endif

#if !qCarbon
	#ifndef __EDITIONS__
	#include <Editions.h>
	#endif
	
	#ifndef __BALLOONS__
	#include <Balloons.h>
	#endif
	
	#ifndef __PACKAGES__
	#include <Packages.h>
	#endif
#endif

#ifndef __COLORPICKER__
#include <ColorPicker.h>
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __MENUS__
#include <Menus.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

//----------------------------------------------------------------------------------------
// static data members
//----------------------------------------------------------------------------------------

TextSpecs TTEDocument::gDefaultSpecs;

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUTEDocument: 
//----------------------------------------------------------------------------------------

void InitUTEDocument()
{
	TTEDocument::gDefaultSpecs.theTextFont = "Geneva";
	TTEDocument::gDefaultSpecs.theTextFace = 0;
	TTEDocument::gDefaultSpecs.theTextSize = 12;
	TTEDocument::gDefaultSpecs.theTextColor = gRGBBlack;
	TTEDocument::gDefaultSpecs.theJustification = teFlushDefault;
	TTEDocument::gDefaultSpecs.theBackColor = gRGBWhite;
}

//========================================================================================
// CLASS TTEDocument
//========================================================================================

//----------------------------------------------------------------------------------------
// TTEDocument::TTEDocument: 
//----------------------------------------------------------------------------------------

TTEDocument::TTEDocument(TFile* itsFile,
						 OSType itsScrapType,
						 ResNumber itsViewResourceID)
	:	TFileBasedDocument(itsFile, itsScrapType),
		fTextSpecs(gDefaultSpecs),
		fTEView(NULL),
		fDocText(NewPermHandle(0)),
		fStyles(NULL),
		fElements(NULL),
		fViewResourceID(itsViewResourceID)
{
}

//----------------------------------------------------------------------------------------
// TTEDocument destructor
//----------------------------------------------------------------------------------------

TTEDocument::~TTEDocument()
{
	fDocText = DisposeIfHandle_AC(fDocText);
}

//----------------------------------------------------------------------------------------
// TTEDocument::ChangeBackColor: 
//----------------------------------------------------------------------------------------

void TTEDocument::ChangeBackColor(const CRGBColor_AC& newColor)
{
	GrafPtr oldPort;
	TView * itsRootView;

	//??? Is this right?  Should we set the background color even if
	// the view isn't in a window yet?
	GetPort(&oldPort);
	MacSetPort((*fTEView->fHTE)->inPort);
	RGBBackColor(newColor);
	itsRootView = fTEView->GetRootView();
	if (itsRootView)
		itsRootView->ForceRedraw();
	MacSetPort(oldPort);
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoInitialState: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoInitialState()
{
	fTextSpecs = gDefaultSpecs;
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoMakeViews: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoMakeViews(bool forPrinting) 
{
	#pragma unused (forPrinting)
	
	TWindow* aWindow = gViewServer->NewTemplateWindow(fViewResourceID, this);
	::ThrowIfNULL_AC(aWindow);

	fTEView = dynamic_cast_AC(TTEView*,aWindow->FindSubView('TEVW'));	// Must cast because FindSubView returns TView

#if UsingDemoTextPrinting
	TStdPrintHandler* aHandler = TH_new TStdPrintHandler(this,			// its document 
							   fTEView,			// its view 
							   kFixedSize,		// horzontal page size is fixed 
							   !kFixedSize);	// vertical page size is variable (could be
	// set to true on non-style TE systems)
#endif

	ShowReverted();
	
	aWindow->Open();
	aWindow->Select();
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoJustChange: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoJustChange(CommandNumber aCommandNumber)
{
	short newJust;

	switch (aCommandNumber)
	{
		case cJustSystem:
			newJust = teFlushDefault;
			break;
			
		case cJustForceLeft:
			newJust = teFlushLeft;
			break;
			
		case cJustCenter:
			newJust = teCenter;
			break;
			
		case cJustRight:
			newJust = teFlushRight;
			break;

#if qDebugMsg
		default:
			ProgramReport_AC("TTEDocument::DoJustChange: Unknown command number: %d.",aCommandNumber);
			newJust = teFlushDefault;
#endif
	};
	TJustCommand * aJustChange = TH_new TJustCommand(fTEView, newJust);
	fTextSpecs.theJustification = newJust;
	PostCommand(aJustChange);
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoStyleChange: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoStyleChange(CommandNumber aCommandNumber)
{
	CTextStyle_AC newStyle;

	switch (aCommandNumber)
	{
		case cBold:
			newStyle.tsFace = bold;
			break;
			
		case cItalic:
			newStyle.tsFace = italic;
			break;
			
		case cUnderline:
			newStyle.tsFace = underline;
			break;
			
		case cOutline:
			newStyle.tsFace = outline;
			break;
			
		case cShadow:
			newStyle.tsFace = shadow;
			break;
			
		case cCondense:
			newStyle.tsFace = condense;
			break;
			
		case cExtend:
			newStyle.tsFace = extend;
			break;
	}

	fTEView->DoneTyping();
	
	if ((newStyle.tsFace * fTextSpecs.theTextFace) == newStyle.tsFace)
		fTextSpecs.theTextFace -= newStyle.tsFace;
	else
		fTextSpecs.theTextFace += newStyle.tsFace;
	PostCommand(fTEView->DoMakeStyleCommand(newStyle, cStyleChange, doFace + doToggle));
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoColTextChange: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoColTextChange()
{
	CTextStyle_AC newStyle;
	if (GetColor(kBestSystemLocation, CStr255_AC(kPromptsRsrcID, kColTextPrompt), fTextSpecs.theTextColor, ((CRGBColor_AC &) newStyle.tsColor)))
	{
		fTEView->DoneTyping();
	
		fTextSpecs.theTextColor = newStyle.tsColor;
		PostCommand(fTEView->DoMakeStyleCommand(newStyle, cColorChange, doColor + doToggle));
	}
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoColBackChange: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoColBackChange()
{
	CRGBColor_AC newColor;
	if (GetColor(kBestSystemLocation, CStr255_AC(kPromptsRsrcID, kColBackPrompt), fTextSpecs.theBackColor, newColor))
	{
		fTextSpecs.theBackColor = newColor;
		ChangeBackColor(newColor);
	}
}

//----------------------------------------------------------------------------------------
// TTEDocument::InstallChangedDeterminer: 
//----------------------------------------------------------------------------------------

void TTEDocument::InstallChangedDeterminer(VHSelect vhs,
										   SizeDeterminer sd)
{
	if (sd != fTEView->GetSizeDeterminer(vhs))
	{
		fTEView->SetSizeDeterminer(vhs, sd);

		// If we changed the horizontal size determiner,
		//  we must ask the TTEView to recompute the TE rectangles.
		if (vhs == hSel)
			switch (sd)
			{
				case sizeSuperView:
					{
						CViewRect itsFrame(fTEView->GetFrame());
						fTEView->SuperViewChangedFrame(itsFrame, itsFrame, true);// Don't care about deltas
						break;
					}

				case sizePage:
					fTEView->DoPagination();
					break;
			}

		fTEView->AdjustFrame();
		fTEView->ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoWidthChange: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoWidthChange(CommandNumber aCommandNumber)
{
	SizeDeterminer sd;

	if (aCommandNumber == cWidthSuperView)
		sd = sizeSuperView;
	else if (aCommandNumber == cWidthOnePage)
		sd = sizePage;
	else
		sd = sizeFixed;

	// NB: The following is not undoable in the
	// current version
	InstallChangedDeterminer(hSel, sd);
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoHeightChange: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoHeightChange(CommandNumber aCommandNumber)
{
	SizeDeterminer sd;

	switch (aCommandNumber)
	{
		case cHeightSuperView:
			sd = sizeSuperView;
			break;
			
		case cHeightPages:
			sd = sizeFillPages;
			break;
			
		case cHeightText:
			sd = sizeVariable;
			break;
			
		case cHeightConst:
			sd = sizeFixed;
			break;
			
#if qDebugMsg
		default:
			ProgramReport_AC("TTEDocument::DoHeightChange : Unknown command number: %d.",aCommandNumber);
			sd = sizeFixed;
#endif
	}

	// NB: The following is not undoable in the
	// current version
	InstallChangedDeterminer(vSel, sd);
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoMenuCommand: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoMenuCommand(CommandNumber aCommandNumber) 
{
	CStr255_AC aName;
	short menu;
	short item;
	CTextStyle_AC newStyle;

	CommandToMenuItem(aCommandNumber, menu, item);

	if (menu == mFont)
	{
		fTEView->DoneTyping();
	
		GetMenuItemText(MAGetMenu(menu), item, aName);
		GetFNum(aName, &(newStyle.tsFont));
		fTextSpecs.theTextFont = aName;
		PostCommand(fTEView->DoMakeStyleCommand(newStyle, cFontChange, doFont + doToggle));
	}
	else if ((aCommandNumber > cSizeBase) && (aCommandNumber <= cSizeMax))
	{
		fTEView->DoneTyping();
	
		newStyle.tsSize = static_cast<short>(aCommandNumber - cSizeBase);
		fTextSpecs.theTextSize = newStyle.tsSize;
		PostCommand(fTEView->DoMakeStyleCommand(newStyle, cSizeChange, doSize + doToggle));
	}
	else
		switch (aCommandNumber)
		{
			case cSizeOther:
				// as yet unsupported
				break;

			case cSizeGrow:
			case cSizeShrink:
				fTEView->DoneTyping();
	
				if (aCommandNumber == cSizeGrow)
				{
					newStyle.tsSize = kRelSizeAmount;
					fTextSpecs.theTextSize += kRelSizeAmount;
				}
				else
				{
					newStyle.tsSize = -kRelSizeAmount;
					fTextSpecs.theTextSize -= kRelSizeAmount;
				}
				PostCommand(fTEView->DoMakeStyleCommand(newStyle, cSizeChange, doSize + addSize + doToggle));
				break;
	
			case cJustForceLeft:
			case cJustCenter:
			case cJustRight:
			case cJustSystem:
				DoJustChange(aCommandNumber);
				break;
	
			case cPlainText:
				fTEView->DoneTyping();
	
				newStyle.tsFace = 0;
				fTextSpecs.theTextFace = 0;
				PostCommand(fTEView->DoMakeStyleCommand(newStyle, cStyleChange, doFace));
				break;
	
			case cBold:
			case cItalic:
			case cUnderline:
			case cOutline:
			case cShadow:
			case cCondense:
			case cExtend:
				DoStyleChange(aCommandNumber);
				break;
	
			case cColorText:
				DoColTextChange();
				break;
	
			case cColorBackground:
				DoColBackChange();
				break;
	
			case cWidthSuperView:
			case cWidthView:
			case cWidthOnePage:
				DoWidthChange(aCommandNumber);
				break;
	
			case cHeightSuperView:
			case cHeightPages:
			case cHeightText:
			case cHeightConst:
				DoHeightChange(aCommandNumber);
				break;
			default:
				TFileBasedDocument::DoMenuCommand(aCommandNumber);
				break;
		}
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoNeedDiskSpace: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoNeedDiskSpace(TFile* itsFile,
										 long& dataForkBytes,
										 long& rsrcForkBytes) const
{

	dataForkBytes += GetHandleSize(fDocText);

	if (fTEView->fHTE)
	{
		TEStyleHandle styles;
		STHandle elements;
		fTEView->ExtractStyles(styles, elements);
		rsrcForkBytes += GetHandleSize((Handle)styles) + kRsrcTypeOverhead + kRsrcOverhead + GetHandleSize((Handle)elements) + kRsrcTypeOverhead + kRsrcOverhead;
	}

	rsrcForkBytes += sizeof(TextSpecs) + kRsrcTypeOverhead + kRsrcOverhead;

	// Get resource file overhead 
	TFileBasedDocument::DoNeedDiskSpace(itsFile, dataForkBytes, rsrcForkBytes);
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoRead: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoRead(TFile* aFile, bool forPrinting) 
{
	long numChars;
	TextSpecsHdl hTextSpecs;
	bool oldPermAllocation;

	::ThrowIfOSErr_AC(aFile->GetDataLength(numChars));	// Read in the text 

	if (numChars > kUnlimited)					// The file may have been created byÉ 
	{
		// Ésomeone else - limit it to 32K! 
		gApplication->ShowError(0, messageAlert + kFileTooBig);
		numChars = kUnlimited;
	}

	SetPermHandleSize(fDocText, numChars);
	SignedByte savedState = LockHandleHigh(fDocText);	// lock handle before deref

	try
	{
		::ThrowIfOSErr_AC(aFile->ReadData(*fDocText, numChars));
		
		HSetState(fDocText, savedState);		// restore state of handle
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		HSetState(fDocText, savedState);		// restore state of handle
		throw;
	}
	
	// Read in the TEStyleRec 
	fStyles = (TEStyleHandle)CMultiLocale_AC::Get1Resource(kTextStyleRsrcType, kStylesRsrcID);
	if (fStyles)
		DetachResource((Handle)fStyles);

	// Read in the STElement array from permanent allocation 
	oldPermAllocation = PermAllocation(true);
	fElements = (STHandle)(CMultiLocale_AC::Get1Resource(kTextStyleRsrcType, kElementsRsrcID));
	PermAllocation(oldPermAllocation);
	
	if (fElements)
		DetachResource((Handle)fElements);

	// Read the text specs resource 
	hTextSpecs = (TextSpecsHdl)CMultiLocale_AC::Get1Resource(kTextSpecsRsrcType, kTextSpecsRsrcID);
	if (hTextSpecs)
	{
		fTextSpecs = **hTextSpecs;
		ReleaseResource((Handle)hTextSpecs);
	}
	else
		DoInitialState();

	TFileBasedDocument::DoRead(aFile, forPrinting);
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoSetupMenus: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoSetupMenus()
{
	TFileBasedDocument::DoSetupMenus();

	short startOfSelection = (*fTEView->fHTE)->selStart;
	short endOfSelection = (*fTEView->fHTE)->selEnd;

	CTextStyle_AC aStyle;
	short aMode = doFace;
	bool checkPlain = fTEView->ContinuousStyle(startOfSelection, endOfSelection, aMode, aStyle) && !aStyle.tsFace;

	aMode = doAll;
	aStyle.tsFace = bold | italic | underline | outline | shadow | extend | condense;

	fTEView->ContinuousStyle(startOfSelection, endOfSelection, aMode, aStyle);
	bool checkFont = (aMode & doFont) != 0;

	MenuRef aMenuRef = MAGetMenu(mFont);
	if (aMenuRef)
	{
		CStr255_AC aName;
		short theFont;

		::GetFontName(aStyle.tsFont, aName);		// Get real font number in case tsFont is 
		::GetFNum(aName, &theFont);					// Éthe system or application font.
		short nItems = CountMenuItems_AC(aMenuRef);
 
		for (short item = 1; item <= nItems; ++item)
		{
			EnableMenuItems_AC(aMenuRef, item);

			if (checkFont)
			{
				short fnt;
	
				::GetMenuItemText(aMenuRef, item, aName);
				::GetFNum(aName, &fnt);
				::MacCheckMenuItem(aMenuRef, item, (fnt == theFont));
			}
		}
	}

	SizeDeterminer sd = fTEView->GetSizeDeterminer(hSel);		// Enable size determiner related menu items
	EnableCheck(cWidthSuperView, true, (sd == sizeSuperView));
	EnableCheck(cWidthOnePage, true, (sd == sizePage));
	EnableCheck(cWidthView, true, (sd == sizeFixed));

	sd = fTEView->GetSizeDeterminer(vSel);
	EnableCheck(cHeightSuperView, true, (sd == sizeSuperView));
	EnableCheck(cHeightPages, true, (sd == sizeFillPages));
	EnableCheck(cHeightText, true, (sd == sizeVariable));
	EnableCheck(cHeightConst, true, (sd == sizeFixed));

	short just = fTEView->fJustification;				// Enable justification related menu items 
	EnableCheck(cJustSystem, true, (just == teFlushDefault));
	EnableCheck(cJustForceLeft, true, (just == teFlushLeft));
	EnableCheck(cJustCenter, true, (just == teCenter));
	EnableCheck(cJustRight, true, (just == teFlushRight));

	Enable(cStyle, true);						// Enable sub-menus 
	Enable(cSize, true);
	Enable(cFont, true);
	Enable(cColor, true);

	Style aFace = aStyle.tsFace;
	EnableCheck(cPlainText, true, checkPlain);	// Enable normal Style menu items 
	EnableCheck(cBold, true, bold & aFace);
	EnableCheck(cItalic, true, italic & aFace);
	EnableCheck(cUnderline, true, underline & aFace);
	EnableCheck(cOutline, true, outline & aFace);
	EnableCheck(cShadow, true, shadow & aFace);
	EnableCheck(cCondense, true, condense & aFace);
	EnableCheck(cExtend, true, extend & aFace);

	for (CommandNumber c = cSizeMin; c <= cSizeMax; ++c)
	{
		bool checkSize;

		if (!(aMode & doSize))
			checkSize = false;
		else
			checkSize = ((c - cSizeBase) == aStyle.tsSize);

		EnableCheck(c, true, checkSize);
		// if it _is_ styled and font is continuous 
		// Éand the size is a real one
		if ((aMode & doFont) && RealFont(aStyle.tsFont, static_cast<short>(c - cSizeBase)))
			aFace = outline;				// Éthen we outline it 
		else
			aFace = 0;
		SetStyle(c, aFace);
	}

	Enable(cSizeGrow, true);
	Enable(cSizeShrink, true);

	Enable(cColorText, true);
	Enable(cColorBackground, true);
}

//----------------------------------------------------------------------------------------
// TTEDocument::DoWrite: 
//----------------------------------------------------------------------------------------

void TTEDocument::DoWrite(TFile* aFile, bool makingCopy)
{
	// Write out the text 
	long numChars = GetHandleSize(fDocText);

	{	
		CTempHandleLock_AC tempHandleLock(fDocText, eMoveHi);
		::ThrowIfOSErr_AC(aFile->WriteData(*fDocText, numChars));
	}

	TEStyleHandle styles;
	STHandle elements;

	const unsigned char kEmptyString[1] = { 0 };

	fTEView->ExtractStyles(styles, elements);
	::AddResource((Handle)PermCopyHandle((Handle)styles), kTextStyleRsrcType, kStylesRsrcID, kEmptyString);
	::ThrowIfResError_AC();						// !!! need a failure handler
	::AddResource((Handle)PermCopyHandle((Handle)elements), kTextStyleRsrcType, kElementsRsrcID, kEmptyString);
	::ThrowIfResError_AC();						// !!! need a failure handler

	// Write the text specification resource, after converting it to a handle 
	TextSpecsHdl hTextSpecs = (TextSpecsHdl)NewPermHandle(sizeof(TextSpecs));
	**hTextSpecs = fTextSpecs;
	::AddResource((Handle)hTextSpecs, kTextSpecsRsrcType, kTextSpecsRsrcID, kEmptyString);
	::ThrowIfResError_AC();							// !!! need a failure handler
	
	TFileBasedDocument::DoWrite(aFile, makingCopy);
}

//----------------------------------------------------------------------------------------
// TTEDocument::FreeData: 
//----------------------------------------------------------------------------------------

void TTEDocument::FreeData()
{
	SetPermHandleSize(fDocText, 0);
}

//----------------------------------------------------------------------------------------
// TTEDocument::SetSpecStyle: 
//----------------------------------------------------------------------------------------

void TTEDocument::SetSpecStyle()
{
	short theFont;
	GetFNum(fTextSpecs.theTextFont, &theFont);

	CTextStyle_AC theTS(theFont, fTextSpecs.theTextFace, fTextSpecs.theTextSize, fTextSpecs.theTextColor);

	fTEView->SetOneStyle(0, 0, doAll, theTS, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TTEDocument::ShowReverted: 
//----------------------------------------------------------------------------------------

void TTEDocument::ShowReverted()
{
	CRGBColor_AC aColor;

	fTEView->StuffText(fDocText);				// put in the text 
	fTEView->SetSelection(0, 0, !kRedraw);
	if (fStyles && fElements)					// If we're able, stuff style info 
		fTEView->StuffStyles(fStyles, fElements);
	else
		SetSpecStyle();

	aColor = fTextSpecs.theBackColor;
	ChangeBackColor(aColor);

	fTEView->SetJustification(fTextSpecs.theJustification, kDontRedraw);
	TFileBasedDocument::ShowReverted();
}


//========================================================================================
// CLASS TJustCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TJustCommand::TJustCommand:
//----------------------------------------------------------------------------------------

TJustCommand::TJustCommand(TTEView* itsTEView,
									   short itsNewJust) :
	TCommand(cJustChange, itsTEView ? itsTEView->GetContext(cJustChange) : NULL, kCanUndo, kCausesChange, itsTEView ? itsTEView->GetContext(cJustChange) : NULL),

	fTEView(itsTEView),
	fOldJust(itsTEView ? itsTEView->fJustification : teFlushDefault),
	fNewJust(itsNewJust)
{
}

//----------------------------------------------------------------------------------------
// TJustCommand destructor
//----------------------------------------------------------------------------------------

TJustCommand::~TJustCommand()
{
}

//----------------------------------------------------------------------------------------
// TJustCommand::DoIt: 
//----------------------------------------------------------------------------------------

void TJustCommand::DoIt()
{
	fTEView->SetJustification(fNewJust, kRedraw);
}

//----------------------------------------------------------------------------------------
// TJustCommand::UndoIt: 
//----------------------------------------------------------------------------------------

void TJustCommand::UndoIt()
{
	fTEView->SetJustification(fOldJust, kRedraw);
}

//----------------------------------------------------------------------------------------
// End of UTEDocument.cpp



/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		06/19/96	Fix compile error for qPowerTalk. 
		05/17/96	There isn't any CTempLockHandle it's CTempHandleLock_AC!
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/09/96	Added CopyHandle_AC: a better HandToHand replacement. And created
		 					PermCopyHandle a better PermHandToHand.
		05/08/96	Cleanup CRGBColor_AC and add new class CTextStyle_AC
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		----- R10 -----
		04/01/96	Fix copyright date and release marker.
		03/30/96	Add flag to control the inclusion/use of printing support
		03/27/96	Replace several BlockMoves_AC with string operations
		03/21/96	The "SquareDots" parameter of IStdPrintHandler is obsolete
		03/18/96	Made better use of TView calls that return CRect_AC/CViewPoint/CViewRect
		03/04/96	made gDefaultSpecs a static member of TTEDocument
		----- 3.3 -----
		11/08/95	[RADAR 1299619] Fixed logic bug in ReadSnapshotFormat 
		11/02/95	Change from "False" to "True" logic
							when opening letters. Changed TTE::ReadNativeFormat
							logic back to respect fSytles and fElements. Cosmetic. 
		11/02/95	Cosmetic.
		11/01/95	The ReadXXXFormats return boolean, add ReadSnapshotFormat
		10/26/95	Completed the unread mail format fixes. 
		10/25/95	Preserved sytle information when reading AppleMail. Removed 
							unecessary ShowReverted call.
		10/18/95	Added check for unread StandardMail Formats.
		10/11/95	Change ReadStandardMailContent so it does not invalidate
							a signature. Uses the style of the letter and does not call
							SMPContentChanged() also added null checks for reading in 
							AppleMail content in SetReplyContent.
		----- 3.3b1 -----
		09/06/95	Use kBestSystemLocation for GetColor calls
		08/30/95	Use TLetter::GetMailerWindowRef.
		07/31/95	Removed kPrintInfoSize, use TPrintInfo::GetSize instead
		07/28/95	Add configuration functions to use instead of gConfiguration. 
		06/15/95	Use TMailableDocument for PowerTalk. 
		05/31/95	Typo: LockHandlehigh. 
		05/16/95	MenuRef, WindowRef
		04/14/95	save/lock and restore handle state instead of lock and unlock.
		03/14/95	Add TLetter and TFileBaseLetter classes. 
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		11/15/94	Create conditional compile based on
							qPowerTalk.
*/