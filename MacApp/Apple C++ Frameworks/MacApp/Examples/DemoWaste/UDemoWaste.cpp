//----------------------------------------------------------------------------------------
// UDemoWaste.cpp
// Copyright © 1986-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		01/11/00	Carbon: new scrap APIs. 
		01/07/00	Call DoPostCreate for newly created clip view so it can create
					its WE record. 
		12/10/99	Changed c-style comment to if 0 block in HandleCursor to satisfy MacBrowse.
		11/19/99	Import the scrap into a TWEView. 
					Rename from .cp to .cpp
		10/19/99	Update for Carbon and universal headers 3.3.
		11/05/99	Move menu and command numbers for TWEView to WEView.r.h. 
		11/05/99	Add support for dispatching to contextual menus. 
		10/12/99	Force nav svcs to show all readable files. 
		03/24/99	Update copyright notice.
		02/12/99	[C] Must use GetRegionBounds accessor instead of rgnBBox.
					'qd' is no longer accessible; use accessors.
		11/13/98	[2279268] Include UPerform.h.
		10/08/98	GetEvent now allows events to be allocated on the stack. 
					Change operator const char* to AsText. 
					Put back lost begin comment in HandleCursor. 
*/

#ifndef __UDEMOWASTE__
#include "UDemoWaste.h"
#endif

// DemoWaste

#ifndef __CWEImage__
#include "CWEImage.h"
#endif

#ifndef __CWELink__
#include "CWELink.h"
#endif

#ifndef __UWEDOCUMENT__
#include "UWEDocument.h"
#endif

#ifndef __WEView_r__
#include "WEView.r.h"
#endif

// MacApp

#ifndef PLATFORMMEMORY_H
#include "PlatformMemory.h"
#endif

#ifndef __UCONTEXTMENUBEHAVIOR__
#include "UContextMenuBehavior.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UOSASCRIPT__
#include "UOSAScript.h"
#endif

#ifndef __UPERFORM__
#include "UPerform.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

// ACS

#ifndef __CClipboard_AC__
#include "CClipboard_AC.h"
#endif

// Toolbox

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __SCRIPT__
#include <Script.h>
#endif

#ifndef __TEXTSERVICES__
#include <TextServices.h>
#endif

//----------------------------------------------------------------------------------------
// Constants
//----------------------------------------------------------------------------------------

const unsigned long kSignature	= 'SS45';			// application signature
const unsigned long kFileType	= kTextType_AC;		// file-type code for saved disk files 

enum { kDefaultTextStyleRsrcID = 1000 };

enum { kWindowRsrcID = 1000 };				// 'view' template for a DemoWaste window

//----------------------------------------------------------------------------------------
// Global Variables
//----------------------------------------------------------------------------------------

bool gHasTSMTE = false;
long gSavedFontForce;

//========================================================================================
// Global Functions
//========================================================================================

// ••• Can't use CClipboard_AC::GetScrap because it has a different API 
//     for qCarbon and !qCarbon (!!!)

static Size ScrapFlavorSize(ResType scrapType)
{ 
#if qCarbon
	 Size byteCount = 0;
	 ScrapRef aScrapRef = NULL;
	::GetCurrentScrap(&aScrapRef);
	::GetScrapFlavorSize(aScrapRef, scrapType, &byteCount);
	return byteCount;
#else
	long offset = 0;
	return GetScrap(NULL, scrapType, &offset);
#endif
}


//========================================================================================
// CLASS TDemoWasteApplication
//========================================================================================

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::TDemoWasteApplication: 
//----------------------------------------------------------------------------------------
TDemoWasteApplication::TDemoWasteApplication() :
	TApplication(kFileType, kSignature)
{
	InitializeTSM();
	InitializeWASTE();

	AppendResMenu(MAGetMenu(mFont), 'FONT');

	SetStyle(cBold, bold);
	SetStyle(cUnderline, underline);
	SetStyle(cItalic, italic);
	SetStyle(cOutline, outline);
	SetStyle(cShadow, shadow);
	SetStyle(cCondense, condense);
	SetStyle(cExtend, extend);

#if qAttachable
	if (fOSAScript)
		fOSAScript->fNextScriptIdle = 0;
#endif
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication destructor
//----------------------------------------------------------------------------------------
TDemoWasteApplication::~TDemoWasteApplication()
{
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::DoInitialState 
//----------------------------------------------------------------------------------------
void TDemoWasteApplication::DoInitialState()	// Override
{
	TApplication::DoInitialState();

	TWEDocument::Initialize();

	// Get the default text style from the resource	file
	CTextStyle_AC textStyle;
	textStyle = MAGetTextStyle(kDefaultTextStyleRsrcID);

	CStr255_AC fontName;
	short dummy;
	GetPortFontInfo(textStyle.tsFont, fontName, dummy);

	// Set up initial text specs 
	TWEDocument::gDefaultSpecs.theTextFont = fontName;
	TWEDocument::gDefaultSpecs.theTextFace = textStyle.tsFace;
	TWEDocument::gDefaultSpecs.theTextSize = textStyle.tsSize;
	TWEDocument::gDefaultSpecs.theTextColor = textStyle.tsColor;
	TWEDocument::gDefaultSpecs.theJustification = teFlushDefault;
	TWEDocument::gDefaultSpecs.theBackColor = gRGBWhite;

#if qWantsContextualMenus
	// Support dispatching contextual menu clicks.
	if (TContextMenuBehavior::HasContextualMenus())
		AddBehavior(TH_new TContextMenuBehavior());
#endif

	CWEImage::Install();
	CWELink::Install();
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::GetNavSvcsFileParameters
//----------------------------------------------------------------------------------------

void TDemoWasteApplication::GetNavSvcsFileParameters(CommandNumber itsCommandNumber,
													 CAEDesc*& defaultLocation,
													 NavReplyRecord& customReply,
													 NavDialogOptions& dialogOptions,
													 NavEventProcPtr& eventFilter,
													 NavPreviewProcPtr& previewProc,
													 NavCallBackUserData& callBackUD,
													 NavTypeListHandle& navTypeList,
													 NavObjectFilterProcPtr& objectFilter) // override
{
	TApplication::GetNavSvcsFileParameters(itsCommandNumber, defaultLocation, customReply,
										   dialogOptions, eventFilter, previewProc,
										   callBackUD, navTypeList, objectFilter);

	dialogOptions.dialogOptionFlags |= kNavSelectDefaultLocation;
	if (itsCommandNumber == cOpen)
		dialogOptions.dialogOptionFlags |= kNavSelectAllReadableItem;
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::DoMakeDocument: 
//----------------------------------------------------------------------------------------
TDocument* TDemoWasteApplication::DoMakeDocument(CommandNumber /* itsCommandNumber */, TFile* itsFile) // override 
{
	return TH_new TWEDocument(itsFile, kFileType, kWindowRsrcID); 
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::MakeViewForAlienClipboard: 
//----------------------------------------------------------------------------------------

TView* TDemoWasteApplication::MakeViewForAlienClipboard() // override
{
	CAutoPtr_AC<TWEView> clipWEView;

	if (ScrapFlavorSize(kTextType_AC) > 0)
	{
		// Create and initialize a new view for the clipboard
		clipWEView = TH_new TWEView(gZeroVPt, CViewPoint(100, 50), sizeSuperView, sizeVariable, 
									CViewRect(10, 8, 10, 0), TWEDocument::gDefaultSpecs, weFlushDefault, 
									true);
		clipWEView->DoPostCreate(NULL);
		::WESetSelection(0, kWEUnlimited, clipWEView->GetWEReference());
		::WEPaste(clipWEView->GetWEReference());
		::WESetSelection(0, 0, clipWEView->GetWEReference());
		clipWEView->fAcceptsChanges = false;				// This is a read-only view
		clipWEView->fFreeText = true;						// Let WEView know it has to free the text
	}

	return clipWEView.release();
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::InitializeTSM
//----------------------------------------------------------------------------------------
void TDemoWasteApplication::InitializeTSM()
{
	// Determine whether the Text Services Manager is available
	SInt32 response;
	if ((::Gestalt(gestaltTSMgrVersion, &response) == noErr) && (response >= 1))
	{
		gHasTextServices = true;
		if (::Gestalt(gestaltTSMTEAttr, &response) == noErr)
			gHasTSMTE = (response & 1<<gestaltTSMTEPresent);	// •••  ???
	}

	// Register this application with the TSM
#if qCarbon
/* Explicit initialization not needed for Carbon clients, since TSM is */
/* instanciated per-context. */
	if (!gHasTSMTE) 
#else
	if (!(gHasTSMTE && ::InitTSMAwareApplication() == noErr)) 
#endif
	{
		// If this happens, just move on without text services.
		gHasTextServices = false;
		gHasTSMTE = false;
	}

	// Get global font force flag; make sure it's off whenever we run. 
	// Do this even if text services don't exist.
	gSavedFontForce = ::GetScriptManagerVariable(smFontForce);
	::SetScriptManagerVariable(smFontForce, 0);
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::InitializeWASTE
//----------------------------------------------------------------------------------------
void TDemoWasteApplication::InitializeWASTE()
{
	// Install Apple event handlers for inline input
	ThrowIfOSErr_AC(::WEInstallTSMHandlers());

	// •••  What about "core handlers"?

	InitUWEView();
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::Terminate
//----------------------------------------------------------------------------------------
void TDemoWasteApplication::Terminate()	// Override
{
	// Remove the Apple event handlers previously installed by WEInstallTSMHandlers
	::WERemoveTSMHandlers();

	// Restore value of the font force flag
	::SetScriptManagerVariable(smFontForce, gSavedFontForce);

	// Terminate TSM if necessary
#if !qCarbon
	if (gHasTextServices)
		::CloseTSMAwareApplication();
#endif
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::GetEvent - experimental - Call TSMEvent after WaitNextEvent
//----------------------------------------------------------------------------------------

bool TDemoWasteApplication::GetEvent(short eventMask,
									 unsigned long sleep,
									 RgnHandle sleepRegion,
									 TToolboxEvent& event)	// Override
{
	bool gotAnEvent = false;

	if (--gRsrcCheck <= 0)
	{
		CheckRsrcUsage();
		gRsrcCheck = kRsrcCheckInterval;
	}

#if qDebug
	if (gIntenseDebugging && gReportEvent)
	{
		ProgramReport_AC("WaitNextEvent: sleep=0%d", sleep);
		// faceless driver bug fixed in MF 7.0 
		if (!sleepRegion)
			ProgramReport_AC(", sleep region=nil");
		else
		{
			CRect_AC bBox (GetRegionBounds_AC(sleepRegion));
			ProgramReport_AC(", sleep region = %s", bBox.AsText());
		}
		ProgramReport_AC("\n");

	}

	if (gShowCursorRegion || gShowHelpRegion || gShowSleepRegion)
	{
		if (gShowCursorRegion)
			ShowGlobalRegion(fCursorRegion);

		if (gShowHelpRegion)
			ShowGlobalRegion(fHelpRegion);

		if (gShowSleepRegion)
			ShowGlobalRegion(fSleepRegion);

		sleep = 60;
	}

#endif // qDebug

	// If we are in a nested event level than don't turn off the busy cursor since we are
	// probably in the middle of an idle or filter proc and don't want to turn on and off
	// the busy cursor each time it gets to service an event.
	bool oldActivateBusyCursor;
	if (fEventLevel <= 1)
		oldActivateBusyCursor = ActivateBusyCursor(false);				// Turn off busy cursor while we're away.

#if qPerform
	bool oldSetting = PerfMonitorEnabled();
#endif

	// Foreground applications don't really "sleep" so we have a code here to just hang around
	// til we get an event OR the sleep time expires
    unsigned long sleepTil = TickCount() + sleep;
    unsigned long snooze;
    do
    {
    	unsigned long now = TickCount();
    	
    	// don't use Max_AC with a subtraction instead of the comparison b/c the unsigned value
    	// won't go negative for overdue sleep and we'll sleep forever.
		snooze = (sleepTil > now) ? sleepTil - now : 0;

        // SystemEvents aren't queued and will be lost if not retrieved when available. So we
        // ensure here that they are always retrieved by adding osMask.
        EventRecord anEvent;
        if (WaitNextEvent(eventMask | osMask, &anEvent, snooze, sleepRegion))
        {
       	// •••  Experimental
#if !qCarbon
// This event loop call not needed for Carbon clients
        	if (gHasTextServices) 
        		if (TSMEvent(&anEvent))	// give TSM a chance to handle it
        			break;
#endif

//			{
//				CTempObjectAllocation tempObjectAllocation(true);
//				event = TH_new TToolboxEvent(this, &anEvent);
//			}
			gotAnEvent = true;
			event.SetMainEvent(anEvent);
            if (event.IsDoubleEvent())
            {
                // The event was part of a pair used to input 16 bit characters
                // Retrieve the second half of the pair immediately.
                // NOTE: although you would think that the second event can be retrieved with GetOSEvent
                // The two byte sytems (KanjiTalk, etc.) seem to only return the second byte thru Wait/GetNextEvent.
                EventRecord secondaryEvent;
                if (WaitNextEvent(keyDownMask | keyUpMask | autoKeyMask, &secondaryEvent, 0, NULL))
                    event.AddSecondaryKeyEvent(secondaryEvent);
            }

            // We have an event, let's go
           break;
        }
    } while (snooze && fAllowApplicationToSleep && IsFrontProcess());


#if qPerform
	EnablePerfMonitor(oldSetting);
#endif

	if (fEventLevel <= 1 && IsFrontProcess())						// If we're not in the background, then 
		ActivateBusyCursor(oldActivateBusyCursor);					// restore the busy cursor mechanism. 

	return gotAnEvent;
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::DoSetCursor - call SetTSMCursor before SetCursor
//----------------------------------------------------------------------------------------
void TDemoWasteApplication::DoSetCursor(CPoint_AC globalMouse, RgnHandle cursorRegion)	// Override
{
	GetDefaultCursorRegion(globalMouse, cursorRegion);
#if qCarbon
	SetCursorToArrow_AC();
#else
	MySetTSMCursor(globalMouse, &(qd.arrow));
#endif
}

//----------------------------------------------------------------------------------------
// TDemoWasteApplication::HandleCursor - save the globalMouse in gGlobalMouseForCursor
//----------------------------------------------------------------------------------------
void TDemoWasteApplication::HandleCursor(CPoint_AC globalMouse, RgnHandle cursorRegion)	// Override
{
	if (gHasTextServices)
		gGlobalMouseForCursor = globalMouse;	// save globalMouse for TWEView::DoSetCursor

#if 0
	// •••  This is commented out because it causes the cursor to blink
	// furiously while being moved...

	// Give WASTE the opportunity to adjust the cursor
	TWindow* window = GetFrontWindow();
	if (window && window->IsActive())
	{
		TWEView* weView = dynamic_cast<TWEView*>(window->GetWindowTarget());
		if (weView)
			if (WEAdjustCursor(globalMouse, cursorRegion, weView->GetWEReference()))
				return;		// WASTE handled the cursor, so we don't have to
	}
#endif

	TApplication::HandleCursor(globalMouse, cursorRegion);
}

//----------------------------------------------------------------------------------------
// End of UDemoWaste.cpp
