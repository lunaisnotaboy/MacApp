//----------------------------------------------------------------------------------------
// CWEPicture.cpp
// Copyright © 1985-2001 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/04/99	WEInstallObjectHandler takes only a UniversalProcPtr so we
							have to cast for the 68K build. 
		10/10/99	Split off PICT handler from UWEView. 
		09/24/99	StuffTextAndStyles wasn't unlocking the text handle. 
		08/18/99	Adapted from DemoWaste. 
		07/26/99	Update all the places that look at 'TEXT' flavors to also accept 'PICT'
							flavors.
		07/20/99	Update from PICT handler sample code from
							PICT Object Handler for the WASTE Text Engine
							by Michael F. Kamprath, kamprath@kagi.com
							maintenance by John C. Daub, hsoi@eden.com
*/

#ifndef __CWEPicture__
#include "CWEPicture.h"
#endif

// Bowser

#include "WETabs.h"
#include "WEExtras.h"

// MacApp

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

// Toolbox

// ANSI


//========================================================================================
// class CWEPicture
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// CWEPicture::Install()
//		Installs the PICT handler into WASTE.
//----------------------------------------------------------------------------------------

void CWEPicture::Install(WEReference theWE)
{
	static WENewObjectUPP		pNewHandlerUPP;
	static WEDisposeObjectUPP	pDisposeHandlerUPP;
	static WEDrawObjectUPP		pDrawHandlerUPP;

	if (!pNewHandlerUPP)
	{
		pNewHandlerUPP = NewWENewObjectProc(HandleNew);
		ThrowIfNULL_AC(pNewHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weNewHandler, (UniversalProcPtr)pNewHandlerUPP, theWE));
	}

	if (!pDisposeHandlerUPP)
	{
		pDisposeHandlerUPP = NewWEDisposeObjectProc(HandleDispose);
		ThrowIfNULL_AC(pDisposeHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weDisposeHandler, (UniversalProcPtr)pDisposeHandlerUPP, theWE));
	}

	if (!pDrawHandlerUPP)
	{
		pDrawHandlerUPP = NewWEDrawObjectProc(HandleDraw);
		ThrowIfNULL_AC(pDrawHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weDrawHandler, (UniversalProcPtr)pDrawHandlerUPP, theWE));
	}
}

//----------------------------------------------------------------------------------------
// HandleNew
// New Object Handler for PICTs
//----------------------------------------------------------------------------------------

pascal OSErr CWEPicture::HandleNew(Point *defaultObjectSize, WEObjectReference obj)
{
	PicHandle thePic = (PicHandle)WEGetObjectDataHandle(obj);
	
	//SetPointFromPICT(defaultObjectSize,thePic);
	*defaultObjectSize = CRect_AC((*thePic)->picFrame).GetSize();

	return noErr;
}

//----------------------------------------------------------------------------------------
// Dispose Object Handler for PICTS
//----------------------------------------------------------------------------------------

pascal OSErr CWEPicture::HandleDispose(WEObjectReference obj)
{
	PicHandle thePic = (PicHandle)WEGetObjectDataHandle(obj);
	if (thePic)
		KillPicture(thePic);

	return MemError();
}
//----------------------------------------------------------------------------------------
// Draw Object Handler for PICTs
//----------------------------------------------------------------------------------------

pascal OSErr CWEPicture::HandleDraw(Rect *destRect, WEObjectReference obj)
{
	PicHandle thePic = (PicHandle)WEGetObjectDataHandle(obj);

	DrawPicture(thePic, destRect);
			
	return noErr;
}


//----------------------------------------------------------------------------------------
// End of CWEPicture.cpp

