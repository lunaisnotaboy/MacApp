//----------------------------------------------------------------------------------------
// UWEDocument.cpp 
// Copyright � 1990-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/16/01	DoNeedDiskSpace, GetDocText are now const.
		01/02/01	Update copyright.
		07/13/00	Stripped MA_DEFINE_CLASS of TWEDocument.
		06/22/00	Add link behavior. 
		02/15/00	Take out the copy constructor. 
		12/10/99	Include UPopup.h.  Took out MA_DEFINE_CLASS of TWEDocument.
					Added check for unexpected command in DoJustChange and
					DoHeightChange.
		11/19/99	Add some convenience methods to TextSpecs. 
					Rename from .cp to .cpp
		11/10/99	Implement a copy constructor. 
		11/10/99	WEFontTableHandle is opaque instead of a Handle. 
		11/08/99	Update for Carbon and universal headers 3.3.
		11/04/99	Implement MacEnableMenuItem for 68K. 
		11/05/99	Move menu and command numbers for TWEView to WEView.r.h. 
		09/24/99	ShowReverted wouldn't insert text if it didn't have style
					information. 
		03/24/99	Update copyright notice.
		02/12/99	[C] Use EnableMenuItem instead of EnableItem.
*/

#ifndef __UWEDOCUMENT__
#include "UWEDocument.h"
#endif

// DemoWASTE

#ifndef __ULinkBehavior__
#include "ULinkBehavior.h"
#endif

#ifndef __UWEVIEW__
#include "UWEView.h"
#endif

#ifndef __UWECOMMANDS__
#include "UWECommands.h"
#endif

#ifndef __WEView_r__
#include "WEView.r.h"
#endif

// MacApp

#ifndef __CPoint_AC__
#include "CPoint_AC.h"
#endif

#ifndef __CRect_AC__
#include "CRect_AC.h"
#endif

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

#ifndef __UERRORMGR__
#include "UErrorMgr.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UPOPUP__
#include "UPopup.h"
#endif

// ACS

#ifndef __MenuUtils_AC__
#include "MenuUtils_AC.h"
#endif

// Toolbox

#ifndef __ALIASES__
#include <Aliases.h>
#endif

#ifndef __DIALOGS__
#include <Dialogs.h>
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __MENUS__
#include <Menus.h>
#endif

#ifndef __PACKAGES__
#include <Packages.h>
#endif

#ifndef __COLORPICKER__
#include <ColorPicker.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

// for TextStyle struct
#ifndef __TEXTEDIT__
#include <TextEdit.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

//========================================================================================
// struct TextSpecs
//========================================================================================

//----------------------------------------------------------------------------------------
// TextSpecs::GetFont
//----------------------------------------------------------------------------------------

short TextSpecs::GetFont() const
{
	short theFont = 1;
	GetFNum(theTextFont, &theFont);
	return theFont;
}

//----------------------------------------------------------------------------------------
// TextSpecs::operator CTextStyle_AC
//----------------------------------------------------------------------------------------

TextSpecs::operator CTextStyle_AC() const
{
	return CTextStyle_AC(GetFont(), theTextFace, theTextSize, theTextColor);
}

//========================================================================================
// CLASS TWEDocument
//========================================================================================

#undef Inherited
#define Inherited TFileBasedDocument

//----------------------------------------------------------------------------------------
// static data members
//----------------------------------------------------------------------------------------

TextSpecs TWEDocument::gDefaultSpecs;

//----------------------------------------------------------------------------------------
// THTMLDocument::Initialize
//----------------------------------------------------------------------------------------

void TWEDocument::Initialize()
{
	TWEDocument::gDefaultSpecs.theTextFont = "Geneva";
	TWEDocument::gDefaultSpecs.theTextFace = 0;
	TWEDocument::gDefaultSpecs.theTextSize = 12;
	TWEDocument::gDefaultSpecs.theTextColor = gRGBBlack;
	TWEDocument::gDefaultSpecs.theJustification = teFlushDefault;
	TWEDocument::gDefaultSpecs.theBackColor = gRGBWhite;

	TWEView::Initialize();
	TLinkBehavior::Initialize();
}

//----------------------------------------------------------------------------------------
// TWEDocument constructor 
//----------------------------------------------------------------------------------------

TWEDocument::TWEDocument(TFile* itsFile,
						 const OSType itsScrapType,
						 ResNumber itsViewResourceID)
	:	TFileBasedDocument(itsFile, itsScrapType),
		fDocText(NULL),
		fStyles(NULL),
		fSoup(NULL),
		fWEView(NULL),
		fTextSpecs(gDefaultSpecs),
		fViewResourceID(itsViewResourceID),
		fScalePopup(NULL),
		fScales(NULL)
{
}

#if 0 // TFileBasedDocument doesn't have a copy constructor
//----------------------------------------------------------------------------------------
// TWEDocument copy constructor
//----------------------------------------------------------------------------------------

TWEDocument::TWEDocument(const TWEDocument& from)
	:	TFileBasedDocument(from),
		fDocText(NULL),
		fStyles(NULL),
		fSoup(NULL),
		fWEView(NULL),
		fTextSpecs(from.fTextSpecs),
		fViewResourceID(from.fViewResourceID),
		fScalePopup(NULL),
		fScales(NULL)
{
}
#endif

//----------------------------------------------------------------------------------------
// TWEDocument destructor
//----------------------------------------------------------------------------------------

TWEDocument::~TWEDocument()
{
	fDocText = DisposeIfHandle_AC(fDocText);
	fStyles = DisposeIfHandle_AC(fStyles);
	fSoup = DisposeIfHandle_AC(fSoup);
	if (fScales)
	{
		ReleaseResource(reinterpret_cast<Handle>(fScales));
		fScales = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TWEDocument::ChangeBackColor: 
//----------------------------------------------------------------------------------------

void TWEDocument::ChangeBackColor(const CRGBColor_AC& newColor)
{
	GrafPtr oldPort;
	TView * itsRootView;

	//??? Is this right?  Should we set the background color even if
	// the view isn't in a window yet?
	GetPort(&oldPort);

	TWindow* itsTWindow = GetWindow();
	WindowRef itsWindow = itsTWindow ? itsTWindow->GetWindowRef() : gWorkPort;
	SetPortWindowPort(itsWindow);

	RGBBackColor(newColor);
	itsRootView = fWEView->GetRootView();
	if (itsRootView)
		itsRootView->ForceRedraw();
	SetPort(oldPort);
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoInitialState: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoInitialState() // override
{
	fTextSpecs = gDefaultSpecs;
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoMakeViews: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoMakeViews(bool /*forPrinting*/ ) // override
{
	TWindow* aWindow = gViewServer->NewTemplateWindow(fViewResourceID, this);
	::ThrowIfNULL_AC(aWindow);

	fWEView = dynamic_cast_AC(TWEView*,aWindow->FindSubView('WEVW'));	// Must cast because FindSubView returns TView
	ThrowIfNonObject_AC(fWEView);
	TStdPrintHandler* aHandler = TH_new TStdPrintHandler(this,	// its document 
											fWEView,			// its view 
											kFixedSize,			// horzontal page size is fixed 
											!kFixedSize);		// vertical page size is variable
	fWEView->AddBehavior(TH_new TLinkBehavior('link'));
	ShowReverted();
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoJustChange: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoJustChange(CommandNumber aCommandNumber)
{
	short newJust;

	switch (aCommandNumber)
	{
		case cJustSystem:
			newJust = teFlushDefault;
			break;
			
		case cJustForceLeft:
			newJust = teFlushLeft;
			break;
			
		case cJustCenter:
			newJust = teCenter;
			break;
			
		case cJustRight:
			newJust = teFlushRight;
			break;

	#if qDebug
		default:
			ProgramBreak_AC("TWEDocument::DoJustChange: Unexpected command number.");
	#endif
	};
	TJustCommand * aJustChange = TH_new TJustCommand(fWEView, newJust);
	fTextSpecs.theJustification = newJust;
	PostCommand(aJustChange);
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoStyleChange: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoStyleChange(CommandNumber aCommandNumber)
{
	CTextStyle_AC newStyle;

	switch (aCommandNumber)
	{
		case cBold:
			newStyle.tsFace = bold;
			break;
			
		case cItalic:
			newStyle.tsFace = italic;
			break;
			
		case cUnderline:
			newStyle.tsFace = underline;
			break;
			
		case cOutline:
			newStyle.tsFace = outline;
			break;
			
		case cShadow:
			newStyle.tsFace = shadow;
			break;
			
		case cCondense:
			newStyle.tsFace = condense;
			break;
			
		case cExtend:
			newStyle.tsFace = extend;
			break;
	}

	fWEView->DoneTyping();
	
	if ((newStyle.tsFace * fTextSpecs.theTextFace) == newStyle.tsFace)
		fTextSpecs.theTextFace -= newStyle.tsFace;
	else
		fTextSpecs.theTextFace += newStyle.tsFace;
	PostCommand(fWEView->DoMakeStyleCommand(newStyle, cStyleChange, weDoFace + weDoToggleFace));
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoColTextChange: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoColTextChange()
{
	CTextStyle_AC newStyle;
	if (GetColor(kBestSystemLocation, CStr255_AC(kPromptsRsrcID, kColTextPrompt), fTextSpecs.theTextColor, ((CRGBColor_AC &) newStyle.tsColor)))
	{
		fWEView->DoneTyping();
	
		fTextSpecs.theTextColor = newStyle.tsColor;
		PostCommand(fWEView->DoMakeStyleCommand(newStyle, cColorChange, weDoColor));	// ���  Was doColor + doToggle
	}
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoColBackChange: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoColBackChange()
{
	CRGBColor_AC newColor;
	if (GetColor(kBestSystemLocation, CStr255_AC(kPromptsRsrcID, kColBackPrompt), fTextSpecs.theBackColor, newColor))
	{
		fTextSpecs.theBackColor = newColor;
		ChangeBackColor(newColor);
	}
}

//----------------------------------------------------------------------------------------
// TWEDocument::InstallChangedDeterminer: 
//----------------------------------------------------------------------------------------

void TWEDocument::InstallChangedDeterminer(VHSelect vhs, SizeDeterminer sd)
{
	if (sd != fWEView->GetSizeDeterminer(vhs))
	{
		fWEView->SetSizeDeterminer(vhs, sd);

		// If we changed the horizontal size determiner,
		//  we must ask the TWEView to recompute the WE rectangles.
		if (vhs == hSel)
			switch (sd)
			{
				case sizeSuperView:
					{
						CViewRect itsFrame(fWEView->GetFrame());
						fWEView->SuperViewChangedFrame(itsFrame, itsFrame, true);// Don't care about deltas
						break;
					}

				case sizePage:
					fWEView->DoPagination();
					break;
			}

		fWEView->AdjustFrame();
		fWEView->ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoWidthChange: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoWidthChange(CommandNumber aCommandNumber)
{
	SizeDeterminer sd;

	if (aCommandNumber == cWidthSuperView)
		sd = sizeSuperView;
	else if (aCommandNumber == cWidthOnePage)
		sd = sizePage;
	else
		sd = sizeFixed;

	// NB: The following is not undoable in the current version
	InstallChangedDeterminer(hSel, sd);
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoHeightChange: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoHeightChange(CommandNumber aCommandNumber)
{
	SizeDeterminer sd;

	switch (aCommandNumber)
	{
		case cHeightSuperView:
			sd = sizeSuperView;
			break;
			
		case cHeightPages:
			sd = sizeFillPages;
			break;
			
		case cHeightText:
			sd = sizeVariable;
			break;
			
		case cHeightConst:
			sd = sizeFixed;
			break;
	
	#if qDebug
		default:
			ProgramBreak_AC("TWEDocument::DoHeightChange: Unexpected command number.");
	#endif
	}

	// NB: The following is not undoable in the current version
	InstallChangedDeterminer(vSel, sd);
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoEvent: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event) // override
{
	bool handled = false;

	switch (eventNumber)
	{
		case mButtonHit:
			if (source && ((source->GetIdentifier() == 'ZmIn') || (source->GetIdentifier() == 'ZOut')))
			{
				DoZoomButtonHit(source->GetIdentifier() == 'ZmIn');
				handled = true;
			}
			break;

		case mPopupHit:
			if (source && (source == GetScalePopup()))
			{
				DoScalePopupHit();
				handled = true;
			}
			break;

		default:
			break;
	}

	if (!handled)
		Inherited::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoZoomButtonHit: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoZoomButtonHit(bool zoomIn)
{
	if (fWEView)
	{
		Fixed zoom = fWEView->GetZoom();
		if (zoomIn)
			zoom <<= 1;
		else
			zoom >>= 1;
		
		TPopup* scalePopup = GetScalePopup();
		if (scalePopup)
		{
			short item = scalePopup->GetNumberOfItems();
			Fixed** scales = GetScales();
			short numScales = GetHandleSize(reinterpret_cast<Handle>(scales)) / sizeof(Fixed);
			for (short index = 1; index <= numScales; ++index)
			{
				if (((*scales)[index - 1] | 3) == (zoom | 3))
				{
					item = index;
					zoom = (*scales)[index - 1];
					break;
				}
			}
			scalePopup->SetCurrentItem(item, kRedraw);
		}

		fWEView->SetZoom(zoom);
	}
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoEvent: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoScalePopupHit()
{
	short item = fScalePopup->GetCurrentItem();
	if ((item > 0) && (item < fScalePopup->GetNumberOfItems()))
	{
		Fixed** scales = GetScales();
		Fixed zoom = (*scales)[item - 1];
		if (fWEView)
			fWEView->SetZoom(zoom);
	}
}

//----------------------------------------------------------------------------------------
// TWEDocument::GetScalePopup: 
//----------------------------------------------------------------------------------------

TPopup* TWEDocument::GetScalePopup()
{
	if (!fScalePopup)
	{
		if (fWEView)
		{
			TWindow* window = fWEView->GetWindow();
			if (window)
				fScalePopup = dynamic_cast<TPopup*>(window->FindSubView('Scal'));
		}
	}

	return fScalePopup;
}

//----------------------------------------------------------------------------------------
// TWEDocument::GetScales: 
//----------------------------------------------------------------------------------------

Fixed** TWEDocument::GetScales()
{
	if (!fScales)
	{
		fScales = reinterpret_cast<Fixed**>(Get1Resource('LONG', 1003));
		ThrowIfNULLResource_AC(fScales);
	}
	
	if (!*fScales)
	{
		LoadResource(reinterpret_cast<Handle>(fScales));
		ThrowIfResError_AC();
	}

	return fScales;
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoMenuCommand: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoMenuCommand(CommandNumber aCommandNumber) // override
{
	CStr255_AC aName;
	short menu;
	short item;
	CTextStyle_AC newStyle;

	CommandToMenuItem(aCommandNumber, menu, item);

	if (menu == mFont)
	{
		fWEView->DoneTyping();
	
		GetMenuItemText(MAGetMenu(menu), item, aName);
		GetFNum(aName, &(newStyle.tsFont));
		fTextSpecs.theTextFont = aName;
		PostCommand(fWEView->DoMakeStyleCommand(newStyle, cFontChange, weDoFont));	// ���  Was doFont + doToggle
	}
	else if ((aCommandNumber > cSizeBase) && (aCommandNumber <= cSizeMax))
	{
		fWEView->DoneTyping();
	
		newStyle.tsSize = static_cast_AC(short, aCommandNumber - cSizeBase);
		fTextSpecs.theTextSize = newStyle.tsSize;
		PostCommand(fWEView->DoMakeStyleCommand(newStyle, cSizeChange, weDoSize));	// ���  was doSize + doToggle
	}
	else
		switch (aCommandNumber)
		{
			case cSizeOther:
				// as yet unsupported
				break;

			case cSizeGrow:
			case cSizeShrink:
				fWEView->DoneTyping();
	
				if (aCommandNumber == cSizeGrow)
				{
					newStyle.tsSize = kRelSizeAmount;
					fTextSpecs.theTextSize += kRelSizeAmount;
				}
				else
				{
					newStyle.tsSize = -kRelSizeAmount;
					fTextSpecs.theTextSize -= kRelSizeAmount;
				}
				PostCommand(fWEView->DoMakeStyleCommand(newStyle, cSizeChange, weDoSize + weDoAddSize));	// ���  Was doSize + addSize + doToggle
				break;
	
			case cJustForceLeft:
			case cJustCenter:
			case cJustRight:
			case cJustSystem:
				DoJustChange(aCommandNumber);
				break;
	
			case cPlainText:
				fWEView->DoneTyping();
	
				newStyle.tsFace = 0;
				fTextSpecs.theTextFace = 0;
				PostCommand(fWEView->DoMakeStyleCommand(newStyle, cStyleChange, weDoFace));
				break;
	
			case cBold:
			case cItalic:
			case cUnderline:
			case cOutline:
			case cShadow:
			case cCondense:
			case cExtend:
				DoStyleChange(aCommandNumber);
				break;
	
			case cColorText:
				DoColTextChange();
				break;
	
			case cColorBackground:
				DoColBackChange();
				break;
	
			case cWidthSuperView:
			case cWidthView:
			case cWidthOnePage:
				DoWidthChange(aCommandNumber);
				break;
	
			case cHeightSuperView:
			case cHeightPages:
			case cHeightText:
			case cHeightConst:
				DoHeightChange(aCommandNumber);
				break;
	
			default:
				Inherited::DoMenuCommand(aCommandNumber);
				break;
		}
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoNeedDiskSpace: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoNeedDiskSpace(TFile* itsFile,
								  long& dataForkBytes,
								  long& rsrcForkBytes) const
{
	// Calculate size of text
	dataForkBytes += GetHandleSize(GetDocText());

	if (fWEView->GetWEReference())
	{
		// Calculate size of style data
		Handle styles = (Handle) WEGetStyleScrapHandle(fWEView->GetWEReference());
		if (styles)
			rsrcForkBytes += GetHandleSize((Handle)styles) + kRsrcTypeOverhead + kRsrcOverhead;
		DisposeIfHandle_AC(styles);
	}

	// ���  What's this for?
	rsrcForkBytes += sizeof(TextSpecs) + kRsrcTypeOverhead + kRsrcOverhead;

	// Get resource file overhead 
	Inherited::DoNeedDiskSpace(itsFile, dataForkBytes, rsrcForkBytes);
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoSetupMenus: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoSetupMenus() // override
{
	bool checkPlain;
	bool checkFont;
	short just;
	WEStyleMode aMode;
	Style aFace;
	SizeDeterminer sd;
	MenuRef aMenuRef;
	CStr255_AC aName;
	CTextStyle_AC aStyle;
	short theFont;
	short nItems;
	
	Inherited::DoSetupMenus();

	SInt32 startOfSelection;
	SInt32 endOfSelection;
	::WEGetSelection(&startOfSelection, &endOfSelection, fWEView->GetWEReference());

	aMode = weDoFace;
	checkPlain = fWEView->ContinuousStyle(startOfSelection, endOfSelection, aMode, aStyle) && !aStyle.tsFace;

	aMode = weDoAll;
	aStyle.tsFace = bold | italic | underline | outline | shadow | extend | condense;

	fWEView->ContinuousStyle(startOfSelection, endOfSelection, aMode, aStyle);
	checkFont = (aMode & weDoFont) != 0;

	aMenuRef = MAGetMenu(mFont);
	if (aMenuRef)
	{
		GetFontName(aStyle.tsFont, aName);			// Get real font number in case tsFont is 
		GetFNum(aName, &theFont);					// �the system or application font. 

		nItems = CountMenuItems(aMenuRef);

		for (short item = 1; item <= nItems; ++item)
		{
			EnableMenuItems_AC(aMenuRef, item);

			if (checkFont)
			{
				short fnt;
	
				GetMenuItemText(aMenuRef, item, aName);
				GetFNum(aName, &fnt);
				::MacCheckMenuItem(aMenuRef, item, (fnt == theFont));
			}
		}
	}

	sd = fWEView->GetSizeDeterminer(hSel);		// Enable size determiner related menu items
	EnableCheck(cWidthSuperView, true, (sd == sizeSuperView));
	EnableCheck(cWidthOnePage, true, (sd == sizePage));
	EnableCheck(cWidthView, true, (sd == sizeFixed));

	sd = fWEView->GetSizeDeterminer(vSel);
	EnableCheck(cHeightSuperView, true, (sd == sizeSuperView));
	EnableCheck(cHeightPages, true, (sd == sizeFillPages));
	EnableCheck(cHeightText, true, (sd == sizeVariable));
	EnableCheck(cHeightConst, true, (sd == sizeFixed));

	just = fWEView->fJustification;				// Enable justification related menu items 
	EnableCheck(cJustSystem, true, (just == teFlushDefault));
	EnableCheck(cJustForceLeft, true, (just == teFlushLeft));
	EnableCheck(cJustCenter, true, (just == teCenter));
	EnableCheck(cJustRight, true, (just == teFlushRight));

	Enable(cStyle, true);						// Enable sub-menus 
	Enable(cSize, true);
	Enable(cFont, true);
	Enable(cColor, true);

	aFace = aStyle.tsFace;
	EnableCheck(cPlainText, true, checkPlain);	// Enable normal Style menu items 
	EnableCheck(cBold, true, bold & aFace);
	EnableCheck(cItalic, true, italic & aFace);
	EnableCheck(cUnderline, true, underline & aFace);
	EnableCheck(cOutline, true, outline & aFace);
	EnableCheck(cShadow, true, shadow & aFace);
	EnableCheck(cCondense, true, condense & aFace);
	EnableCheck(cExtend, true, extend & aFace);

	for (CommandNumber c = cSizeMin; c <= cSizeMax; ++c)
	{
		bool checkSize;

		if (!(aMode & weDoSize))
			checkSize = false;
		else
			checkSize = ((c - cSizeBase) == aStyle.tsSize);

		EnableCheck(c, true, checkSize);
		// if it _is_ styled and font is continuous 
		// �and the size is a real one
		if ((aMode & weDoFont) && RealFont(aStyle.tsFont, static_cast_AC(short, c - cSizeBase)))
			aFace = outline;				// �then we outline it 
		else
			aFace = 0;
		SetStyle(c, aFace);
	}

	Enable(cSizeGrow, true);
	Enable(cSizeShrink, true);

	Enable(cColorText, true);
	Enable(cColorBackground, true);
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoRead: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoRead(TFile* aFile, bool forPrinting) // override
{
	long numBytes;
	ThrowIfOSErr_AC(aFile->GetDataLength(numBytes)); 
	fDocText = NewPermHandle(numBytes);
	SignedByte savedState = LockHandleHigh(fDocText);	// lock handle before deref

	// Read in the text
	try
	{
		ThrowIfOSErr_AC(aFile->ReadData(*fDocText, numBytes));	// Read in the text 
		
		::HSetState(fDocText, savedState);		// restore state of handle
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		::HSetState(fDocText, savedState);		// restore state of handle
		throw;
	}
	
	// Read in the style data 
	fStyles = ::Get1IndResource(kStyleType_AC, kStylesRsrcID);
	if (fStyles)
		::DetachResource(fStyles);
	fSoup = ::Get1IndResource(kTypeSoup, kStylesRsrcID);
	if (fSoup)
		::DetachResource(fSoup);
	WEFontTableHandle hFontTable = (WEFontTableHandle)::Get1IndResource(kTypeFontTable, kStylesRsrcID);
	if (hFontTable)
		::DetachResource((Handle)hFontTable);

	// If both a style scrap and a font table were found,
	// re-map font IDs in the style scrap
	if (fStyles && hFontTable)
	{
		Boolean wasChanged;
		if ((::WEUpdateFontTable(hFontTable, NULL, &wasChanged) == noErr) && wasChanged)
		{
			::WEUpdateStyleScrap((StScrpHandle) fStyles, hFontTable);
		}
	}

	// We're done with the font table handle
	DisposeIfHandle_AC((Handle)hFontTable);

	// Read the text specs resource 
	TextSpecsHdl hTextSpecs = (TextSpecsHdl)Get1Resource(kTextSpecsRsrcType, kTextSpecsRsrcID);
	if (hTextSpecs)
	{
		fTextSpecs = **hTextSpecs;
		ReleaseResource((Handle)hTextSpecs);
	}
	else
		DoInitialState();

	Inherited::DoRead(aFile, forPrinting);
}

//----------------------------------------------------------------------------------------
// TWEDocument::DoWrite: 
//----------------------------------------------------------------------------------------

void TWEDocument::DoWrite(TFile* aFile, bool makingCopy) // override
{
	// Write out the text 
	Handle docText = GetDocText();
	long numChars = GetHandleSize(docText);
	WEReference we = fWEView->GetWEReference();

	// Allocate temporary handles to hold the style scrap, soup, and font table
	Handle hStyles = ::NewHandle(0);
	ThrowIfNULL_AC(hStyles);
	Handle hSoup = ::NewHandle(0);
	ThrowIfNULL_AC(hSoup);
	WEFontTableHandle hFontTable = (WEFontTableHandle)::NewHandle(0);
	ThrowIfNULL_AC(hFontTable);

	try
	{
		{	
			CTempHLock_AC tempHandleLock(docText, eDontMoveHi);
			::ThrowIfOSErr_AC(aFile->WriteData(*docText, numChars));
		}

		// Create the style scrap and the soup
		ThrowIfOSErr_AC(::WECopyRange(0, LONG_MAX, NULL, (StScrpHandle)hStyles, hSoup, we));

		// Create the font table
		ThrowIfOSErr_AC(::WEBuildFontTable(hFontTable, NULL, we));
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		DisposeIfHandle_AC(hStyles);
		DisposeIfHandle_AC(hSoup);
		DisposeIfHandle_AC((Handle)hFontTable);
		throw;
	}

	TextSpecsHdl hTextSpecs = NULL;

	try
	{
		// Make them resource handles
		::AddResource(hStyles, kStyleType_AC, kStylesRsrcID, "\p");
		ThrowIfResError_AC();
		::AddResource(hSoup, kTypeSoup, kStylesRsrcID, "\p");
		ThrowIfResError_AC();
		::AddResource((Handle)hFontTable, kTypeFontTable, kStylesRsrcID, "\p");
		ThrowIfResError_AC();

		// Write them to the resource file
		::ChangedResource(hStyles);
		::WriteResource(hStyles);
		ThrowIfResError_AC();
		::ChangedResource(hSoup);
		::WriteResource(hSoup);
		ThrowIfResError_AC();
		::ChangedResource((Handle)hFontTable);
		::WriteResource((Handle)hFontTable);
		ThrowIfResError_AC();

		// Write the text specification resource, after converting it to a handle 
		hTextSpecs = (TextSpecsHdl)NewPermHandle(sizeof(TextSpecs));
		**hTextSpecs = fTextSpecs;
		::AddResource((Handle)hTextSpecs, kTextSpecsRsrcType, kTextSpecsRsrcID, gEmptyString);
		ThrowIfResError_AC();
		::ChangedResource((Handle)hTextSpecs);
		::WriteResource((Handle)hTextSpecs);
		ThrowIfResError_AC();
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		if (hStyles) ReleaseResource(hStyles);
		if (hSoup) ReleaseResource(hSoup);
		if (hFontTable) ReleaseResource((Handle)hFontTable);
		if (hTextSpecs) ReleaseResource((Handle)hTextSpecs);
		throw;
	}

	// "Clean" this document by resetting the WE instance modification count
	::WEResetModCount(we);

	Inherited::DoWrite(aFile, makingCopy);
}

//----------------------------------------------------------------------------------------
// TWEDocument::FreeData: 
//----------------------------------------------------------------------------------------

void TWEDocument::FreeData() // override
{
	SetPermHandleSize(fDocText, 0);
}

//----------------------------------------------------------------------------------------
// TWEDocument::SetSpecStyle: 
//----------------------------------------------------------------------------------------

void TWEDocument::SetSpecStyle()
{
	short theFont;
	GetFNum(fTextSpecs.theTextFont, &theFont);

	CTextStyle_AC theTS(theFont, fTextSpecs.theTextFace, fTextSpecs.theTextSize, fTextSpecs.theTextColor);

	fWEView->SetOneStyle(0, 0, weDoAll, theTS, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TWEDocument::ShowReverted: 
//----------------------------------------------------------------------------------------

void TWEDocument::ShowReverted() // override
{
	SetSpecStyle();

	if (fDocText /*&& fStyles*/)
	{
		fWEView->StuffTextAndStyles(fDocText, fStyles, fSoup);
		fWEView->SetJustification(fTextSpecs.theJustification, kDontRedraw);
		fWEView->SetSelection(0, 0, !kRedraw);
	}
	//else if (!fStyles)
	//	SetSpecStyle();

	CRGBColor_AC aColor = fTextSpecs.theBackColor;
	ChangeBackColor(aColor);

	// Now that we've stuffed the text and style info, dispose the handles
	fDocText = DisposeIfHandle_AC(fDocText);
	fStyles = DisposeIfHandle_AC(fStyles);
	fSoup = DisposeIfHandle_AC(fSoup);

	Inherited::ShowReverted();
}

//----------------------------------------------------------------------------------------
// TWEDocument::GetDocText - return a Handle to the text
//----------------------------------------------------------------------------------------

Handle TWEDocument::GetDocText() const
{
	return fWEView->ExtractText();
}


//========================================================================================
// CLASS TJustCommand
//========================================================================================

#undef Inherited
#define Inherited TCommand

//----------------------------------------------------------------------------------------
// TJustCommand::TJustCommand:
//----------------------------------------------------------------------------------------
TJustCommand::TJustCommand(TWEView* itsWEView, short itsNewJust) :
	TCommand(cJustChange, itsWEView ? itsWEView->GetContext(cJustChange) : NULL, kCanUndo, kCausesChange, itsWEView ? itsWEView->GetContext(cJustChange) : NULL),

	fWEView(itsWEView),
	fOldJust(itsWEView ? itsWEView->fJustification : teFlushDefault),
	fNewJust(itsNewJust)
{
}

//----------------------------------------------------------------------------------------
// TJustCommand destructor
//----------------------------------------------------------------------------------------
TJustCommand::~TJustCommand()
{
}

//----------------------------------------------------------------------------------------
// TJustCommand::DoIt: 
//----------------------------------------------------------------------------------------
void TJustCommand::DoIt() // override
{
	fWEView->SetJustification(fNewJust, kRedraw);
}

//----------------------------------------------------------------------------------------
// TJustCommand::UndoIt: 
//----------------------------------------------------------------------------------------
void TJustCommand::UndoIt() // override
{
	fWEView->SetJustification(fOldJust, kRedraw);
}

//----------------------------------------------------------------------------------------
// End of UWEDocument.cpp
