//----------------------------------------------------------------------------------------
// UWECommands.cpp
// Copyright � 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/26/01	Use gClipboardMgr accessor methods. 
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		06/22/00	Add TWEDropFileCommand. 
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		01/07/00	Call DoPostCreate for newly created clip view so it can create
							its WE record. 
		12/19/99	Add a styler command. 
		11/19/99	TWEStyleCommand needs to save all the old styles in the selection. 
							GivePasteData no longer has a scrapRef parameter under Carbon. 
							Rename from .cp to .cpp
		10/19/99	Update for Carbon and universal headers 3.3.
		11/03/99	Give pictures their own commands. 
							Removed fStyleType: code was using it but it was never set. 
							Fix the typing command to save object soup. 
							Use WASTE functions for adding to style and soup handles. 
							Move the code for getting item data into the drop command. 
		11/02/99	Save and restore the object soup as well as the styles. 
							Remove the padding code because soup would have made it even
							more complex and it isn't worth it. 
							Remove PostProcessCommand. Make DumpTWECommand a method. 
		10/12/99	Set selection in InstallNewPict so the picture is inserted
							where it's supposed to be. Add SetNewPicture so the caller
							doesn't have to treat pictures as if they were text. 
		07/26/99	Update all the places that look at 'TEXT' flavors to also accept 'PICT'
							flavors.
		03/24/99	Update copyright notice.
		10/27/98	Need to select text before applying styles. 
		07/28/98	[2253749] Added PostProcessCommand and call from DoIt, RedoIt and UndoIt.
		07/23/98	In TWETypingCommand::RedoIt: Changed !kRedraw to fWE.
		05/22/98	Removed obsolete, non colorQD code. 
*/

#ifndef __UWECOMMANDS__
#include "UWECommands.h"
#endif

// DemoWaste

#ifndef __CWEImage__
#include "CWEImage.h"
#endif

// MacApp

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

// Toolbox

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MOVIES__
#include <Movies.h>
#endif

// ANSI

#ifndef __LIMITS__
#include <limits.h>
#endif

#ifndef __STDIO__
#include <stdio.h>
#endif

// WASTE

#ifndef __UWEVIEW__
#include "UWEView.h"
#endif

//	WEScraps.c (private)
extern pascal OSErr _WEPrependStyle(Handle hStyleScrap, const WERunInfo *info, SInt32 offsetDelta);
extern pascal OSErr _WEAppendStyle(Handle hStyleScrap, const WERunInfo *info, SInt32 offset);
extern pascal OSErr _WEPrependObject(Handle hSoup, const WERunInfo *info, SInt32 offsetDelta);
extern pascal OSErr _WEAppendObject(Handle hSoup, const WERunInfo *info, SInt32 offset);

//========================================================================================
// CLASS TWECommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWECommand constructor
//----------------------------------------------------------------------------------------

TWECommand::TWECommand(TWEView* itsWEView, CommandNumber itsCommandNumber, bool itsSaveText)
	:	TCommand(itsCommandNumber, NULL, kCanUndo, kCausesChange, NULL),
		fWEView(NULL),
		fOldStart(0),
		fOldEnd(0),
		fOldText(NULL),
		fOldStyles(NULL),
		fOldSoup(NULL),
		fNewStart(0),
		fNewEnd(0),
		fNewText(NULL),
		fNewStyles(NULL),
		fNewSoup(NULL)
{
	ThrowIfNULL_AC(itsWEView);
	fWEView = itsWEView;
	SetWEReference(itsWEView->GetWEReference());

	fContext = itsWEView->GetContext(itsCommandNumber);
	fObjectToNotify = fContext;

	::WEGetSelection(&fOldStart, &fOldEnd, fWE);

	if (itsSaveText)
	{
		CTempAllocation tempAllocation(false);
		ThrowIfNULL_AC(fOldText = NewHandle(0));
		ThrowIfNULL_AC(fOldStyles = (StScrpHandle)NewHandle(0));
		ThrowIfNULL_AC(fOldSoup = (WESoupHandle)NewHandle(0));
		::WECopyRange(fOldStart, fOldEnd, fOldText, fOldStyles, fOldSoup, fWE);// Will resize handles
	}
}

//----------------------------------------------------------------------------------------
// TWECommand::~TWECommand:
//----------------------------------------------------------------------------------------

TWECommand::~TWECommand() // override
{
	fOldText = DisposeIfHandle_AC(fOldText);
	fOldStyles = (StScrpHandle)DisposeIfHandle_AC((Handle)fOldStyles);
	fOldSoup = (WESoupHandle)DisposeIfHandle_AC((Handle)fOldSoup);
	fNewText = DisposeIfHandle_AC(fNewText);
	fNewStyles = (StScrpHandle)DisposeIfHandle_AC((Handle)fNewStyles);
	fNewSoup = (WESoupHandle)DisposeIfHandle_AC((Handle)fNewSoup);
}

//----------------------------------------------------------------------------------------
// TWECommand::BanishOldText:
//----------------------------------------------------------------------------------------

void TWECommand::BanishOldText()
{
	if (fOldEnd > fOldStart)
		ThrowIfOSErr_AC(::WEDelete(fWE));
}

//----------------------------------------------------------------------------------------
// TWECommand::InstallNewText:
//----------------------------------------------------------------------------------------

void TWECommand::InstallNewText()
{
	if (fNewEnd > fNewStart)
	{
		Handle itsText = fWEView->fText;
		long savedSize = GetHandleSize(itsText);

#if qDebug
		if (fNewText == NULL)
			ProgramBreak_AC("InstallNewText called with fNewText == NULL!");
#endif

		CTempHandleLock_AC tempHandleLock(fNewText, eMoveHi); // Prevent heap fragmentation for WEInsert 

		// ���  TTECommand::InstallNewText does a lot more here

		ThrowIfOSErr_AC(::WEInsert(*fNewText, GetHandleSize(fNewText), fNewStyles, fNewSoup, fWE));

		if (GetHandleSize(itsText) <= savedSize)
			ThrowIfOSErr_AC(memFullErr);

		fWEView->fSpecsChanged = true;
	}
}

//----------------------------------------------------------------------------------------
// TWECommand::RemoveAdditions:
//----------------------------------------------------------------------------------------

void TWECommand::RemoveAdditions()
{
	if (fNewText)
	{
		fWEView->SetSelection(fNewStart, fNewEnd, !kRedraw);
		ThrowIfOSErr_AC(::WEDelete(fWE));
	}
}

//----------------------------------------------------------------------------------------
// TWECommand::RestoreSelection:
//----------------------------------------------------------------------------------------

void TWECommand::RestoreSelection()
{
	fWEView->SetSelection(fOldStart, fOldEnd, kRedraw);
}

//----------------------------------------------------------------------------------------
// TWECommand::ReviveDeletions:
//----------------------------------------------------------------------------------------

void TWECommand::ReviveDeletions()
{
	fWEView->SetSelection(fOldStart, fOldStart, !kRedraw);	// so insert will take place at right point
	long nChars = GetHandleSize(fOldText);
	if (nChars > 0)
	{
		Handle itsText = fWEView->fText;
		long savedSize = GetHandleSize(itsText);

		CTempHandleLock_AC tempHandleLock(fOldText, eMoveHi); // Prevent heap fragmentation 

		ThrowIfOSErr_AC(::WEInsert(*fOldText, nChars, fOldStyles, fOldSoup, fWE));

		if (GetHandleSize(itsText) <= savedSize)
			ThrowIfOSErr_AC(memFullErr);

		fWEView->fSpecsChanged = true;
	}
}

//----------------------------------------------------------------------------------------
// TWECommand::DoMainFunction:
//----------------------------------------------------------------------------------------

void TWECommand::DoMainFunction()
{
	if (fIdentifier != cCopy)
		BanishOldText();

	InstallNewText();

	if (fIdentifier != cCopy)
		fWEView->SynchView(kRedraw);
}

//----------------------------------------------------------------------------------------
// TWECommand::SetupDependencies:
//----------------------------------------------------------------------------------------

void TWECommand::SetupDependencies()
{
	TCommand::SetupDependencies();

	if ((fWEView) && CanBeUndone())
		fWEView->AddDependent(this);
}

//----------------------------------------------------------------------------------------
// TCommand::DoUpdate:
//----------------------------------------------------------------------------------------

void TWECommand::DoUpdate(ChangeID_AC theChange, 
						  MDependable_AC* changedObject,
						  void* changeData, 
						  CDependencySpace_AC* dependencySpace) // override
{
	if ((theChange == mClosed) && (changedObject == fWEView))
		fContext->CommitLastCommand();
	else
		TCommand::DoUpdate(theChange, changedObject, changeData, dependencySpace);
}

//----------------------------------------------------------------------------------------
// TWECommand::DoIt:
//----------------------------------------------------------------------------------------

void TWECommand::DoIt() // override
{
	fWEView->Focus();

	DoMainFunction();
#if qDebug
	if (TWEView::fgWEIntenseDebugging)
		Dump();
#endif
}

//----------------------------------------------------------------------------------------
// TWECommand::UndoIt:
//----------------------------------------------------------------------------------------

void TWECommand::UndoIt() // override
{
	fWEView->Focus();

	RemoveAdditions();
	if (fOldText)
		ReviveDeletions();

	RestoreSelection();
	if (fIdentifier != cCopy)
		fWEView->SynchView(kRedraw);

#if qDebug
	if (TWEView::fgWEIntenseDebugging)
		Dump();
#endif
}

//----------------------------------------------------------------------------------------
// TWECommand::RedoIt:
//----------------------------------------------------------------------------------------

void TWECommand::RedoIt() // override
{
//	gApplication->SetTarget(fWEView);	// ���  Necessary?
	fWEView->Focus();

	RestoreSelection();
	DoMainFunction();

#if qDebug
	if (TWEView::fgWEIntenseDebugging)
		Dump();
#endif
}

//----------------------------------------------------------------------------------------
// TWECommand::PrepareForUndoRedo
//----------------------------------------------------------------------------------------

void TWECommand::PrepareForUndoRedo() // override
{
	if (fWEView)
		fWEView->PrepareForUndoRedo(this);
	else
		TCommand::PrepareForUndoRedo();
}

//----------------------------------------------------------------------------------------
// TWECommand::RevealUndoRedo
//----------------------------------------------------------------------------------------

void TWECommand::RevealUndoRedo() // override
{
	if (fWEView)
		fWEView->RevealUndoRedo(this);
	else
		TCommand::RevealUndoRedo();
}

//----------------------------------------------------------------------------------------
// DumpTWECommand:
//----------------------------------------------------------------------------------------

#if qDebug

void TWECommand::Dump()
{
	long oldStyleSize;
	long newStyleSize;
	long last;

	long oldDiff = Max_AC(fOldEnd - fOldStart, 0);
	long newDiff = Max_AC(fNewEnd - fNewStart, 0);

	ProgramReport_AC("old start/end, new start/end, diff :%1d/%1d,  %1d/%1d,  %1d \n",
					fOldStart,
					fOldEnd,
					fNewStart,
					fNewEnd,
					Max_AC(oldDiff, newDiff));

	oldStyleSize = 0;
	newStyleSize = 0;
	ProgramReport_AC("** Old styles:\n");
	if (fOldStyles == NULL)
		ProgramReport_AC("NONE!\n");
	else
	{

		last = (**(fOldStyles)).scrpNStyles;
		ProgramReport_AC("Number of table entries: %1d\n", last);
		for (long i = 0; i <= last - 1; ++i)
		{
			ScrpSTElement & theScrpSTElement = (**(fOldStyles)).scrpStyleTab[i];

			ProgramReport_AC("%1d, ofs:%1d ", theScrpSTElement.scrpStartChar);
			ProgramReport_AC("\n");
		}
		oldStyleSize = GetHandleSize((Handle)(fOldStyles));
	}

	ProgramReport_AC("** New styles:\n");
	if (fNewStyles == NULL)
		ProgramReport_AC("NONE!\n");
	else
	{
		last = (**(fNewStyles)).scrpNStyles;
		ProgramReport_AC("Number of table entries: %1d\n", last);
		for (long i = 0; i <= last - 1; ++i)
		{
			ScrpSTElement & theScrpSTElement = (**(fNewStyles)).scrpStyleTab[i];

			ProgramReport_AC("%1d, ofs:%1d ", theScrpSTElement.scrpStartChar);
			ProgramReport_AC("\n");
		}
		newStyleSize = GetHandleSize((Handle)(fNewStyles));
	}

	ProgramReport_AC("Styles size diff: %1d\n", Max_AC(newStyleSize, oldStyleSize));
}

#endif // qDebug


//========================================================================================
// CLASS TWECutCopyCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWECutCopyCommand constructor
//----------------------------------------------------------------------------------------

TWECutCopyCommand::TWECutCopyCommand(TWEView* itsWEView, CommandNumber itsCommandNumber)
	:	TWECommand(itsWEView, itsCommandNumber, true),
		fClipCreated(false)
{
	fChangesClipboard = true;
	fCausesChange = (itsCommandNumber != cCopy);
	fCanUndo = fCausesChange;
}

//----------------------------------------------------------------------------------------
// TWECutCopyCommand destructor
//----------------------------------------------------------------------------------------

TWECutCopyCommand::~TWECutCopyCommand()
{
	if (fClipCreated)
		fOldText = NULL;
}

//----------------------------------------------------------------------------------------
// TWECutCopyCommand::DoIt:
//----------------------------------------------------------------------------------------

void TWECutCopyCommand::DoIt() // override
{
	fWEView->Focus();

	CTextStyle_AC clipStyle(fWEView->fTextStyle);		// Copy the view�s text style

	CViewPoint itsSize(100, 50);						// An arbitrary initial size.
	CViewRect itsMargins(10, 8, 10, 0);					// No bottom margin.

	// Create and initialize a new view for the clipboard
	CAutoPtr_AC<TWEView> clipWEView = TH_new TWEView(gZeroVPt, itsSize, sizeSuperView, sizeVariable, 
													 itsMargins, clipStyle, weFlushDefault, 
													 fWEView->fAutoWrap);
	clipWEView->DoPostCreate(NULL);
	clipWEView->fAcceptsChanges = false;				// This is a read-only view

	// Cut can eat into temp memory so users can rescue text from overweight documents
	if (!WillCauseChange())								// If Copy-ing, assure there's enough room
		FailSpaceIsLow();

//	clipWEView->StuffText(fOldText);
//	FailSpaceIsLow();

	::WESetSelection(0, kWEUnlimited, clipWEView->GetWEReference());
	{
		CTempHandleLock_AC tempHandleLock(fOldText, eMoveHi); // Prevent heap fragmentation 
		long nChars = GetHandleSize(fOldText);
		ThrowIfOSErr_AC(::WEInsert(*fOldText, nChars, fOldStyles, fOldSoup, clipWEView->GetWEReference()));
	}
	FailSpaceIsLow();
	::WESetSelection(0, 0, clipWEView->GetWEReference());

	clipWEView->fFreeText = true;						// Let WEView know it has to free the text

	ClaimClipboard(clipWEView);							// Okay to claim (will call RecalcText!)
	clipWEView.release();

	fClipCreated = true;								// We be done
	DoMainFunction();									// Do the actual cut/copy

#if qDebug
	if (TWEView::fgWEIntenseDebugging)
	{
		TWEView::DumpWERecord(clipWEView->GetWEReference());
		Dump();
	}
#endif

}														// TWECutCopyCommand::DoIt

//----------------------------------------------------------------------------------------
// TWECutCopyCommand::ReviveDeletions:
//----------------------------------------------------------------------------------------

void TWECutCopyCommand::ReviveDeletions() // override
{
	if (fIdentifier == cCut)
		TWECommand::ReviveDeletions();					// Don�t do it for COPY
}

//========================================================================================
// CLASS TWEPasteCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEPasteCommand constructor
//----------------------------------------------------------------------------------------

TWEPasteCommand::TWEPasteCommand(TWEView* itsWEView)
	:	TWECommand(itsWEView, cPaste, true)
{
	// Get new text data
	{
		ResType dataType = '%%%%';
		CTempHandle_AC newText = NewPermHandle(0);
		SInt32 newLength = gClipboardMgr->GetDataToPaste(newText, dataType);
		if (newLength <= 0)
			ThrowError_AC(noScrapErr);

		if (dataType != kTextType_AC)
			ThrowError_AC(badDragFlavorErr);

		fNewText = newText.release();

		::WEGetSelection(&fNewStart, &fNewEnd, fWE);
		fNewEnd = fNewStart + newLength;
	}

#if qCarbon
	ScrapRef curScrapRef;
	::GetCurrentScrap(&curScrapRef);
#endif

	// Get new style data, if any
	{
		TemplateTempHandle<StScrpHandle> newStyles = reinterpret_cast<StScrpHandle>(NewPermHandle(0));
		long newStyleLen = gClipboardMgr->GetClipView()->GivePasteData(reinterpret_cast<Handle>(newStyles.get()), kStyleType_AC);
		if (newStyleLen > 0)
			fNewStyles = newStyles.release();
	}

	// Get new soup data, if any
	{
		TemplateTempHandle<WESoupHandle> newSoup = reinterpret_cast<WESoupHandle>(NewPermHandle(0));
		long newSoupLen = gClipboardMgr->GetClipView()->GivePasteData(reinterpret_cast<Handle>(newSoup.get()), 'SOUP');
		if (newSoupLen > 0)
			fNewSoup = newSoup.release();
	}

	FailSpaceIsLow();
}

//----------------------------------------------------------------------------------------
// TWEPasteCommand destructor
//----------------------------------------------------------------------------------------

TWEPasteCommand::~TWEPasteCommand()
{
}

//----------------------------------------------------------------------------------------
// TWEPasteCommand::DoIt:
//----------------------------------------------------------------------------------------

void TWEPasteCommand::DoIt() // override
{
	TWECommand::DoIt();

	// The first time we paste, the selection should be just after the pasted data, 
	// so that typing will not delete the new data. 
	fWEView->SetSelection(fNewEnd, fNewEnd, !kRedraw);
}


//========================================================================================
// CLASS TWEStyleCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEStyleCommand constructor
//----------------------------------------------------------------------------------------

TWEStyleCommand::TWEStyleCommand(TWEView* itsWEView, 
								 const CTextStyle_AC& itsNewStyle, 
								 CommandNumber itsCommandNumber, 
								 WEStyleMode itsMode)
	:	TWECommand(itsWEView, itsCommandNumber, false),
//		fOldTextStyle(itsWEView ? itsWEView->fTextStyle : itsNewStyle),
		fNewTextStyle(itsNewStyle),
		fMode(itsMode)
{
	CTempAllocation tempAllocation(false);
	ThrowIfNULL_AC(fOldStyles = (StScrpHandle)NewHandle(0));
	::WECopyRange(fOldStart, fOldEnd, NULL, fOldStyles, NULL, fWE);
}

//----------------------------------------------------------------------------------------
// TWEStyleCommand destructor
//----------------------------------------------------------------------------------------

TWEStyleCommand::~TWEStyleCommand()
{
}

//----------------------------------------------------------------------------------------
// TWEStyleCommand::InstallOneStyle:
//----------------------------------------------------------------------------------------

void TWEStyleCommand::InstallOneStyle(const CTextStyle_AC& newStyle)
{
	fWEView->SetOneStyle(fOldStart, fOldEnd, fMode, newStyle, kRedraw);// Focuses for us
}

//----------------------------------------------------------------------------------------
// TWEStyleCommand::InstallManyStyles:
//----------------------------------------------------------------------------------------

void TWEStyleCommand::InstallManyStyles(StScrpHandle newStyles)
{
	fWEView->Focus();

	ThrowIfOSErr_AC(::WEUseStyleScrap(newStyles, fWE));

	if (fOldEnd == fOldStart)
	{
		CTextStyle_AC theStyle(*(TextStyle*)&(*newStyles)->scrpStyleTab[0].scrpFont);

		ThrowIfOSErr_AC(::WESetStyle(weDoAll, &theStyle, fWE));
	}

	fWEView->RecalcText();								// Might have changed number of lines
	fWEView->SynchView(kRedraw);						// Show corrected view

	fWEView->fSpecsChanged = true;
}

//----------------------------------------------------------------------------------------
// TWEStyleCommand::DoIt:
//----------------------------------------------------------------------------------------

void TWEStyleCommand::DoIt() // override
{
	CTextStyle_AC aTextStyle = fNewTextStyle;

	InstallOneStyle(aTextStyle);
	fMode = fMode & ~weDoToggleFace;
#if qDebug
	if (TWEView::fgWEIntenseDebugging)
		Dump();
#endif
}

//----------------------------------------------------------------------------------------
// TWEStyleCommand::UndoIt:
//----------------------------------------------------------------------------------------

void TWEStyleCommand::UndoIt() // override
{
	CTextStyle_AC aTextStyle;
	fWEView->Focus();

	RestoreSelection();

//	if (fWEView->fStyleType == kWithoutStyle)
//	{
//		aTextStyle = fOldTextStyle;
//		InstallOneStyle(aTextStyle);
//	}
//	else

	InstallManyStyles(fOldStyles);	// ��� What about fOldSoup???

#if qDebug
	if (TWEView::fgWEIntenseDebugging)
		Dump();
#endif
}

//----------------------------------------------------------------------------------------
// TWEStyleCommand::RedoIt:
//----------------------------------------------------------------------------------------

void TWEStyleCommand::RedoIt() // override
{
	fWEView->Focus();
	RestoreSelection();
	DoIt();
}


//========================================================================================
// CLASS TWEStylerCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEStylerCommand constructor
//----------------------------------------------------------------------------------------

TWEStylerCommand::TWEStylerCommand(TWEView* itsWEView, 
								   WEStylerReference itsStyler, 
								   CommandNumber itsCommandNumber)
	:	TWECommand(itsWEView, itsCommandNumber, false),
		fStyler(itsStyler)
{
	CTempAllocation tempAllocation(false);
	ThrowIfNULL_AC(fOldStyles = (StScrpHandle)NewHandle(0));
	::WECopyRange(fOldStart, fOldEnd, NULL, fOldStyles, NULL, fWE);
}

//----------------------------------------------------------------------------------------
// TWEStylerCommand destructor
//----------------------------------------------------------------------------------------

TWEStylerCommand::~TWEStylerCommand()
{
}

//----------------------------------------------------------------------------------------
// TWEStylerCommand::GetStyler:
//----------------------------------------------------------------------------------------

WEStylerReference TWEStylerCommand::GetStyler()
{
	return fStyler;
}

//----------------------------------------------------------------------------------------
// TWEStylerCommand::DoIt:
//----------------------------------------------------------------------------------------

void TWEStylerCommand::DoIt() // override
{
	WEStylerReference styler = GetStyler();
	if (styler)
	{
		ThrowIfOSErr_AC(::WESetStyler(styler, fWE));
#if qDebug
		if (TWEView::fgWEIntenseDebugging)
			Dump();
#endif
	}
}

//----------------------------------------------------------------------------------------
// TWEStylerCommand::UndoIt:
//----------------------------------------------------------------------------------------

void TWEStylerCommand::UndoIt() // override
{
	CTextStyle_AC aTextStyle;
	fWEView->Focus();

	RestoreSelection();

//	InstallManyStyles(fOldStyles);	// ��� What about fOldSoup???
	fWEView->Focus();

	ThrowIfOSErr_AC(::WEUseStyleScrap(fOldStyles, fWE));

	if (fOldEnd == fOldStart)
	{
		CTextStyle_AC theStyle(*(TextStyle*)&(*fOldStyles)->scrpStyleTab[0].scrpFont);

		ThrowIfOSErr_AC(::WESetStyle(weDoAll, &theStyle, fWE));
	}

	fWEView->RecalcText();								// Might have changed number of lines
	fWEView->SynchView(kRedraw);						// Show corrected view

	fWEView->fSpecsChanged = true;

#if qDebug
	if (TWEView::fgWEIntenseDebugging)
		Dump();
#endif
}

//----------------------------------------------------------------------------------------
// TWEStylerCommand::RedoIt:
//----------------------------------------------------------------------------------------

void TWEStylerCommand::RedoIt() // override
{
	fWEView->Focus();
	RestoreSelection();
	DoIt();
}


//========================================================================================
// CLASS TWETypingCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWETypingCommand constructor
//----------------------------------------------------------------------------------------

TWETypingCommand::TWETypingCommand(TWEView* itsWEView, const CStr2_AC& itsFirstCh)
	:	TWECommand(itsWEView, cTyping, true),
		fFirstChar(itsFirstCh),							// Save character[s] for DoIt
		fCompleted(false)
{
	WEGetSelection(&fNewStart, &fNewEnd, fWE);
	fNewEnd = fNewStart;							// Start and end are the same

	fNewText = NewPermHandle(0);					// Allocate an empty block for text
}

//----------------------------------------------------------------------------------------
// TWETypingCommand destructor
//----------------------------------------------------------------------------------------

 TWETypingCommand::~TWETypingCommand() // override
{
	if (fWEView->fTypingCommand == this)
		fWEView->fTypingCommand = NULL;
}

//----------------------------------------------------------------------------------------
// TWETypingCommand::DoNormalChar:
//----------------------------------------------------------------------------------------

void TWETypingCommand::DoNormalChar(const CStr2_AC& ch)
{
	// Append char[s] to end of fNewText

	bool oldPerm = PermAllocation(true);
	::ThrowIfOSErr_AC(PtrAndHand((Ptr) & ch[1], fNewText, ch.Length()));
	PermAllocation(oldPerm);

	fNewEnd += ch.Length();						// Bump both end of "selection" 
}

//----------------------------------------------------------------------------------------
// TWETypingCommand::BkSpcLeft
//----------------------------------------------------------------------------------------

void TWETypingCommand::BkSpcLeft(Handle theText, SInt32 curStart)
// User has backspaced to the left of the original starting
// point. First, copy the character (which may be more than one byte long if we are using
// a non-Roman script) to a temporary buffer. The assumption is that no character will
// ever be longer than two bytes. Next, copy the character to the front of
// fOldText, and adjust fOldStart, fNewStart, and fNewEnd. Note that we do !check for
// MemSpaceIsLow, since we want to let the user delete characters.
{
	SInt32 saveLength = 1;
	if (MACharacterByteType((*theText), curStart - 1, smCurrentScript) == smLastByte)
		++saveLength;

	curStart -= saveLength;

	CStr2_AC savedCh;
	savedCh.CopyFrom(static_cast_AC(void*, *theText + curStart), saveLength);

	Munger(fOldText, 0, NULL, 0, &savedCh[1], savedCh.Length());
	ThrowIfMemError_AC();

	{
		WERunInfo runInfo;
		::WEGetRunInfo(curStart, &runInfo, fWE);

		ThrowIfOSErr_AC(_WEPrependStyle(reinterpret_cast<Handle>(fOldStyles), &runInfo, saveLength));
		
		ThrowIfOSErr_AC(_WEPrependObject(fOldSoup, &runInfo, saveLength));
	}

	fOldStart = curStart;								// Treat this as though original selection
	fNewStart = curStart;								// �had included this character
	fNewEnd = curStart;
}

//----------------------------------------------------------------------------------------
// TWETypingCommand::BkSpcRight:
//----------------------------------------------------------------------------------------

void TWETypingCommand::BkSpcRight(Handle theText,
								  SInt32 curStart)
{
	short savedSize = 1;
	if (MACharacterByteType((*theText), curStart - savedSize, smCurrentScript) == smLastByte)
		++savedSize;

	fNewEnd -= savedSize;

	SetPermHandleSize(fNewText, fNewEnd - fNewStart);	// Shouldn't fail as we're only shrinking it
}

//----------------------------------------------------------------------------------------
// TWETypingCommand::FwdDelete:
//----------------------------------------------------------------------------------------

void TWETypingCommand::FwdDelete(Handle theText, SInt32 curStart, SInt32 curEnd)
// Forward delete courtesy of: Larry Goldman. Used by permission.
{
	CStr2_AC savedCh;

	long textSize = GetHandleSize(theText);
	if ((curStart == curEnd) && (curStart < textSize))
	{
		unsigned char saveLength = 1;			// Get the complete character
		if ((curStart <= textSize) && (MACharacterByteType(*theText, curStart, smCurrentScript) == smLastByte))
			++saveLength;

		savedCh.CopyFrom(static_cast_AC(void*, *theText + curStart), saveLength);

		if ((curStart >= fNewStart) && (curStart < fNewEnd)) // char is within fNewText
		{
			// Remove the char from fNewText and update fNewEnd
			fNewEnd -= savedCh.Length();

			// Shouldn't fail as we're only shrinking it
			Munger(fNewText, curStart - fNewStart, NULL, savedCh.Length(), &savedCh[1], 0);
			ThrowIfMemError_AC();
		}
		else
		{
			// add char to the end of fOldChars, don't update fOldEnd
			long oldTextSize = GetHandleSize(fOldText);
			Munger(fOldText, oldTextSize, NULL, 0, &savedCh[1], savedCh.Length());
			ThrowIfMemError_AC();

			WERunInfo runInfo;
			::WEGetRunInfo(curStart, &runInfo, fWE);

			ThrowIfOSErr_AC(_WEAppendStyle(reinterpret_cast<Handle>(fOldStyles), &runInfo, oldTextSize));

			fWEView->fSpecsChanged = true;	// User may have backspaced into new style

			ThrowIfOSErr_AC(_WEAppendObject(fOldSoup, &runInfo, oldTextSize));
		}
	}
}

//----------------------------------------------------------------------------------------
// TWETypingCommand::AddCharacter:
//----------------------------------------------------------------------------------------

void TWETypingCommand::AddCharacter(const CStr2_AC& ch)
{
	Handle theText;
	SInt32 curSelStart;
	SInt32 curSelEnd;

	fWEView->Update();								// Makes sure that all of WE's actions are Visible
	fWEView->Focus();

	::WEGetSelection(&curSelStart, &curSelEnd, fWE);
	theText = ::WEGetText(fWE);

	CWhileOutlinePreferred_AC setOP(fWEView->fPreferOutline);
	{
		CTempAllocation tempAllocation(false);

		// Update the fNewText handle and other information. Note that because of
		// backspace, this can be tricky.*/
		if (ch == chFwdDelete)						// User types forward delete, so keep in synch
			FwdDelete(theText, curSelStart, curSelEnd);

		else if (ch != chBackspace)					// Not a backspace. Do the right thing
			DoNormalChar(ch);

		else if ((curSelStart <= fOldStart) && (curSelStart > 0) && (curSelStart == curSelEnd))// User typed backspace so keep in synch
			BkSpcLeft(theText, curSelStart);		// Handle backspace to left of start

		else if (fNewEnd > fNewStart)				// Delete 1 character from end of fNewText
			BkSpcRight(theText, curSelStart);		// Handle backspace to right of start
	}

	EventModifiers mods = fWEView->fEventRecord.modifiers;

	if (ch != chFwdDelete)
	{
		// Let WASTE have the character, as either 1) we're adding a byte, so we know
		// there is a reserve tank, so the worst this will do is eat into it a little, or
		// 2) we're deleting a character, which can only decrease memory usage.
		::WEActivate(fWE);							// Fix blasted insertion point

		// NOTE: here is where we insert multibyte characters all at once
		::WEKey(ch[1], mods, fWE);
		if (ch.Length() > 1)
			::WEKey(ch[2], mods, fWE);
	}
	else if (curSelStart != curSelEnd)				// forward delete with chars selected
	{
		ThrowIfOSErr_AC(::WEDelete(fWE));			// Remove old text, including vacuumed chars
	}
	else if (curSelStart < GetHandleSize(theText))
	{
		// forward delete with insertion point
		::WEActivate(fWE);							// Fix blasted insertion point
		::WEKey(chRight, mods, fWE);
		::WEKey(chBackspace, mods, fWE);
	}

	fWEView->SynchView(kRedraw);						// Now clean up the view.

#if qDebugMsg
	if (TWEView::fgWEIntenseDebugging)
	{
		WrLblHandleContents("fOldText", fOldText);
		ProgramReport_AC("\n");
		WrLblHandleContents("fNewText", fNewText);
		ProgramReport_AC("\n");
		Dump();
	}
#endif

}

//----------------------------------------------------------------------------------------
// TWETypingCommand::DoIt:
//----------------------------------------------------------------------------------------

void TWETypingCommand::DoIt() // override
{
	AddCharacter(fFirstChar);
#if qDebug
	if (TWEView::fgWEIntenseDebugging)
		Dump();
#endif

	if (fFirstChar[1] == chReturn)
		fWEView->RedrawBelow();
}

//----------------------------------------------------------------------------------------
// TWETypingCommand::RedoIt:
//----------------------------------------------------------------------------------------

void TWETypingCommand::RedoIt() // override
{
	if ((fOldEnd - fOldStart) == GetHandleSize(fOldText))
	{
		// No chars were vacuumed
		bool resetStyle = false;
		if (fOldEnd == fOldStart)
		{
			WERunInfo runInfo;
			::WEGetRunInfo(fOldStart, &runInfo, fWE);
			CTextStyle_AC currentStyle(runInfo.runStyle);
			resetStyle = !EqualBlocks(&currentStyle, &(*fOldStyles)->scrpStyleTab[0].scrpFont, sizeof(currentStyle));
		}

		if (resetStyle)									// The new text has a style of its own
			fNewStyles = fOldStyles;					// Make InstallNewText insert styles, too

		TWECommand::RedoIt();

		if (resetStyle)
			fNewStyles = NULL;							// So fNewStyles doesn't get disposed
	}
	else
	{
		fWEView->Focus();
		fWEView->SetWESelect(fOldStart, fOldStart + GetHandleSize(fOldText), fWE);

		// vacuumed chars, too
		// Remove old text, including vacuumed chars
		ThrowIfOSErr_AC(::WEDelete(fWE));
		InstallNewText();
		fWEView->SynchView(kRedraw);
#if qDebug
		if (TWEView::fgWEIntenseDebugging)
			Dump();
#endif
	}
}

//----------------------------------------------------------------------------------------
// TWETypingCommand::UndoIt:
//----------------------------------------------------------------------------------------

void TWETypingCommand::UndoIt() // override
{
	CompleteTyping();
	TWECommand::UndoIt();
}

//----------------------------------------------------------------------------------------
// TWETypingCommand::CompleteTyping:
//----------------------------------------------------------------------------------------

void TWETypingCommand::CompleteTyping()
{
	fCompleted = true;

	// Fix up the offsets in the style table. 
	// Because we're using _WEPrependStyle and _WEAppendStyle now, 
	// this code should never actually do anything. 
	{
		ScrpSTElement* scrpStyleTab = (*fOldStyles)->scrpStyleTab;
		long offset = -scrpStyleTab[0].scrpStartChar;
		if (offset > 0)
		{
			short scrpNStyles = (*fOldStyles)->scrpNStyles;
			for (short i = 0; i < scrpNStyles; ++i)
				scrpStyleTab[i].scrpStartChar += offset;
		}
	}

#if qDebug
	if (TWEView::fgWEIntenseDebugging)
		Dump();
#endif

}


//========================================================================================
// CLASS TWEInsertObjectCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEInsertObjectCommand constructor
//----------------------------------------------------------------------------------------

TWEInsertObjectCommand::TWEInsertObjectCommand(TWEView* itsWEView,
											   CommandNumber itsCommandNumber,
											   bool itsSaveText,
											   FlavorType objectType,
											   Handle objectData,
											   Point objectSize)
	:	TWECommand(itsWEView, itsCommandNumber, itsSaveText),
		fObjectType(objectType),
		fObjectData(objectData),
		fObjectSize(objectSize)
{
}

//----------------------------------------------------------------------------------------
// TWEInsertObjectCommand destructor
//----------------------------------------------------------------------------------------

TWEInsertObjectCommand::~TWEInsertObjectCommand()
{
}

//----------------------------------------------------------------------------------------
// TWEInsertObjectCommand::DoIt:
//----------------------------------------------------------------------------------------

void TWEInsertObjectCommand::DoIt() // override
{
	TWECommand::DoIt();

	// The first time we insert, the selection should be just after the new data, 
	// so that typing will not delete it. 
	fWEView->SetSelection(fNewEnd, fNewEnd, !kRedraw);
}

//----------------------------------------------------------------------------------------
// TWEInsertObjectCommand::InstallNewText:
//----------------------------------------------------------------------------------------

static Handle Duplicate(const Handle h)
{
	Handle copy = NULL;
	if (h)
	{
		Size n = GetHandleSize(h);
		copy = NewPermHandle(n);
		ThrowIfNULL_AC(copy);
		BlockMove_AC(*h, *copy, n);
	}
	return copy;
}

void TWEInsertObjectCommand::InstallNewText() // override
{
	if (fObjectData)
	{
		fWEView->SetSelection(fNewStart, fNewStart, !kRedraw);
		{
			// Give the WASTE object a copy of the object data rather than the
			// original, because our undo code deletes the WASTE object. 
			CTempHandle_AC objectDataCopy = Duplicate(fObjectData);
			InsertObject(fObjectType, objectDataCopy, fObjectSize);
			objectDataCopy.release();
		}

		fWEView->SetSelection(fNewStart, fNewEnd, !kRedraw);
		fWEView->fSpecsChanged = true;
	}
}

//----------------------------------------------------------------------------------------
// TWEInsertObjectCommand::InsertObject:
//----------------------------------------------------------------------------------------

void TWEInsertObjectCommand::InsertObject(FlavorType objectType,
										  Handle objectData,
										  Point objectSize)
{
	ThrowIfOSErr_AC(::WEInsertObject(objectType, objectData, objectSize, fWE));
}

//----------------------------------------------------------------------------------------
// TWEInsertObjectCommand::RemoveAdditions:
//----------------------------------------------------------------------------------------

void TWEInsertObjectCommand::RemoveAdditions() // override
{
	if (fObjectData)
	{
		fWEView->SetSelection(fNewStart, fNewEnd, !kRedraw);
		ThrowIfOSErr_AC(::WEDelete(fWE));
	}
}


//========================================================================================
// CLASS TWEPasteObjectCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEPasteObjectCommand constructor
//----------------------------------------------------------------------------------------

TWEPasteObjectCommand::TWEPasteObjectCommand(TWEView* itsWEView)
	:	TWEInsertObjectCommand(itsWEView, cPaste, true, '%%%%', NULL, gZeroPt)
{
	CTempHandle_AC aDataHandle = NewPermHandle(0);
	ResType dataType = '%%%%';
	long newLength = gClipboardMgr->GetDataToPaste(aDataHandle, dataType);
	if (newLength <= 0)
		ThrowError_AC(noScrapErr);

	fObjectType = dataType;
	fObjectData = aDataHandle.release();
	FailSpaceIsLow();

	fNewStart = fOldStart;
	fNewEnd = fNewStart + 1;
}

//----------------------------------------------------------------------------------------
// TWEPasteObjectCommand destructor
//----------------------------------------------------------------------------------------

TWEPasteObjectCommand::~TWEPasteObjectCommand()
{
}


#if qDrag

//========================================================================================
// CLASS TWEDragDropCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEDragDropCommand constructor
//----------------------------------------------------------------------------------------

TWEDragDropCommand::TWEDragDropCommand(TWEView* itsWEView,
									   CommandNumber itsCommandNumber,
									   TDragItem* dragItem,
									   long newStart)
	:	TWECommand(itsWEView, itsCommandNumber, false)
{

	dragItem->FocusOnFlavor(kTextType_AC);
	fNewText = dragItem->GetDataAsHandle();
	::ThrowIfNULL_AC(fNewText);

	if (dragItem->FlavorExists(kStyleType_AC))
	{
		dragItem->FocusOnFlavor(kStyleType_AC);
		fNewStyles = reinterpret_cast<StScrpHandle>(dragItem->GetDataAsHandle());
	}

	enum { kTypeSoup = 'SOUP' };
	if (dragItem->FlavorExists(kTypeSoup))
	{
		dragItem->FocusOnFlavor(kTypeSoup);
		fNewSoup = reinterpret_cast<WESoupHandle>(dragItem->GetDataAsHandle());
	}

	fOldStart = fOldEnd = fNewStart = newStart;
	fNewEnd = fNewStart + GetHandleSize(fNewText);
}

//----------------------------------------------------------------------------------------
// TWEDragDropCommand destructor
//----------------------------------------------------------------------------------------

TWEDragDropCommand::~TWEDragDropCommand()
{
}


//========================================================================================
// CLASS TWEDropFileCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEDropFileCommand constructor
//----------------------------------------------------------------------------------------

TWEDropFileCommand::TWEDropFileCommand(TWEView* itsWEView,
									   FlavorType objectType,
									   TDragItem* dragItem,
									   long newStart)
	:	TWEInsertObjectCommand(itsWEView, cDrop, false, objectType, NULL, gZeroPt)
{
	fObjectType = CWEImage::kFlavor;

	HFSFlavor theHFSFlavor;
	long count = sizeof(theHFSFlavor);
	dragItem->FocusOnFlavor(flavorTypeHFS);
	dragItem->SetPosition(0);
	dragItem->GetData(&theHFSFlavor, count);

	DataReferenceRecord dataReference;
	dataReference.dataRefType = rAliasType;
	dataReference.dataRef = NULL;

	AliasHandle alias = NULL;
	ThrowIfOSErr_AC(NewAliasMinimal(&theHFSFlavor.fileSpec, &alias));
	dataReference.dataRef = reinterpret_cast<Handle>(alias);

	fObjectData = NewHandle(sizeof(DataReferenceRecord));
	ThrowIfNULL_AC(fObjectData);
	BlockMove_AC(&dataReference, *fObjectData, sizeof(DataReferenceRecord));
	
	fOldStart = fOldEnd = fNewStart = newStart;
	fNewEnd = newStart + 1;
}

//----------------------------------------------------------------------------------------
// TWEDropFileCommand destructor
//----------------------------------------------------------------------------------------

TWEDropFileCommand::~TWEDropFileCommand()
{
}


//========================================================================================
// CLASS TWEDropObjectCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEDropObjectCommand constructor
//----------------------------------------------------------------------------------------

TWEDropObjectCommand::TWEDropObjectCommand(TWEView* itsWEView,
										   FlavorType objectType,
										   TDragItem* dragItem,
										   long newStart)
	:	TWEInsertObjectCommand(itsWEView, cDrop, false, objectType, NULL, gZeroPt)
{
	dragItem->FocusOnFlavor(fObjectType);
	fObjectData = dragItem->GetDataAsHandle();

	fOldStart = fOldEnd = fNewStart = newStart;
	fNewEnd = newStart + 1;
}

//----------------------------------------------------------------------------------------
// TWEDropObjectCommand destructor
//----------------------------------------------------------------------------------------

TWEDropObjectCommand::~TWEDropObjectCommand()
{
}


//========================================================================================
// CLASS TWEDragMoveCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEDragMoveCommand constructor
//----------------------------------------------------------------------------------------

TWEDragMoveCommand::TWEDragMoveCommand(TWEView* itsWEView,
									   CommandNumber itsCommandNumber,
									   SInt32 newStart)
	:	TWECommand(itsWEView, itsCommandNumber, true)
{
	// initialize the command, and save the selection into fOldText

	// fOldStart and fOldEnd represent the text being dragged
	// fNewStart takes its impending relocation into account
	fNewStart = (fOldStart < newStart) ? (newStart - (fOldEnd - fOldStart)) : newStart;
	fNewEnd = fNewStart + (fOldEnd - fOldStart);

	// since new and old text are the same, the text handle can be shared
	fNewText = fOldText;
	fNewStyles = fOldStyles;
	fNewSoup = fOldSoup;
}

//----------------------------------------------------------------------------------------
// TWEDragMoveCommand destructor
//----------------------------------------------------------------------------------------

TWEDragMoveCommand::~TWEDragMoveCommand()
{
	// fNewText and fOldText share a handle in this command. fNewText is NULLed to
	// prevent double disposal in the base destructor.
	fNewText = NULL;
	fNewStyles = NULL;
	fNewSoup = NULL;
}

//----------------------------------------------------------------------------------------
// TWEDragMoveCommand::InstallNewText: 
//----------------------------------------------------------------------------------------

void TWEDragMoveCommand::InstallNewText()
{
	// set the text insertion point
	fWEView->SetSelection(fNewStart, fNewStart, !kRedraw);

	TWECommand::InstallNewText();

	fWEView->SetSelection(fNewStart, fNewEnd, !kRedraw);
}

#endif // qDrag

//----------------------------------------------------------------------------------------
// End of UWECommands.cpp
