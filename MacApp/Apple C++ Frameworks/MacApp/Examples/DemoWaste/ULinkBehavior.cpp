//----------------------------------------------------------------------------------------
// ULinkBehavior.cpp
// Copyright © 1999-2001 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/18/01	Qualify strlen with std::.
		01/02/01	Update copyright.
		12/19/99	Add the link dialog. 
		12/07/99	Add SetBackgroundColor. 
		11/17/99	Streaming support for stylers. 
		11/16/99	Add an EndLink method. 
		11/15/99	Use a styler for the link object. 
		11/11/99	Bring back link objects. 
		10/15/99	Provide the default text style to the HTML encoder. 
		10/14/99	Fill in the ExtractHTML method. 
		10/12/99	Try making real images with URL references. 
		09/24/99	Initial version. 
*/

#ifndef __ULinkBehavior__
#include "ULinkBehavior.h"
#endif

// DemoWaste

#ifndef __CWEImage__
#include "CWEImage.h"
#endif

#ifndef __CWELink__
#include "CWELink.h"
#endif

#ifndef __WEView_r__
#include "WEView.r.h"
#endif

#ifndef __UWEVIEW__
#include "UWEView.h"
#endif

// MacApp

#ifndef __UBACKGROUNDADORNER__
#include "UBackgroundAdorner.h"
#endif

#ifndef __UBUTTON__
#include "UButton.h"
#endif

#ifndef __UEDITTEXT__
#include "UEditText.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CTextStyle_AC__
#include "CTextStyle_AC.h"
#endif

#ifndef _MEMMGR_
#include "MemMgr.h"
#endif

// WASTE

#ifndef _WASTE_
#include "WASTE.h"
#endif

// Toolbox

// ANSI


//========================================================================================
// GLOBAL Procedures
//========================================================================================
#undef Inherited

//========================================================================================
// CLASS TLinkBehavior
//========================================================================================

MA_DEFINE_CLASS(TLinkBehavior);

//----------------------------------------------------------------------------------------
// TLinkBehavior::Initialize
//----------------------------------------------------------------------------------------

void TLinkBehavior::Initialize()
{
	static bool pInitialized;
	if (!pInitialized)
	{
		pInitialized = true;

#if qTemplateViews
		REGISTER_SIGNATURE_AC(TLinkBehavior, TLinkBehavior::kStandardSignature);
#endif

		CWEImage::Install();
		CWELink::Install();

		InitUButton();
		InitUEditText();
		REGISTER_CLASS_AC(TWhiteBackgroundAdorner);
		REGISTER_CLASS_AC(TBorderFrameAdorner);

		InitUTEView();
	}
}

//----------------------------------------------------------------------------------------
// TLinkBehavior constructor
//----------------------------------------------------------------------------------------

TLinkBehavior::TLinkBehavior(IDType itsIdentifier)
	:	TBehavior(itsIdentifier)
{
}

//----------------------------------------------------------------------------------------
// TLinkBehavior copy constructor
//----------------------------------------------------------------------------------------

TLinkBehavior::TLinkBehavior(const TLinkBehavior& inLinkBehavior)
	:	TBehavior(inLinkBehavior)
{
}

//----------------------------------------------------------------------------------------
// TLinkBehavior destructor
//----------------------------------------------------------------------------------------

TLinkBehavior::~TLinkBehavior() // override
{
}

//----------------------------------------------------------------------------------------
// TLinkBehavior::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TLinkBehavior::GetStandardSignature() const // override
{
	return kStandardSignature;
}

//----------------------------------------------------------------------------------------
// TLinkBehavior::DoSetupMenus:
//----------------------------------------------------------------------------------------

void TLinkBehavior::DoSetupMenus() // override
{
	TBehavior::DoSetupMenus();

	if (!MemSpaceIsLow())
	{
		SInt32 selStart;
		SInt32 selEnd;
		::WEGetSelection(&selStart, &selEnd, GetWEReference());
		if (selStart < selEnd)
			Enable(cLink, true);
	}
}

//----------------------------------------------------------------------------------------
// TLinkBehavior::DoMenuCommand:
//----------------------------------------------------------------------------------------

void TLinkBehavior::DoMenuCommand(CommandNumber aCommandNumber) // override
{
	bool handled = true;

	switch (aCommandNumber)
	{
		case cLink:
			{
				char* link = PoseLinkDialog();
				if (link)
					GetOwner()->PostCommand(TH_new TLinkCommand(GetOwner(), link, aCommandNumber));
			}
			break;

		default:
			handled = false;
			break;
	}

	if (!handled)
		TBehavior::DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// TLinkBehavior::PoseLinkDialog:
//----------------------------------------------------------------------------------------

char* TLinkBehavior::PoseLinkDialog()
{
	char* link = NULL;

	{
		CAutoPtr_AC<TWindow> dialog = TViewServer::fgViewServer->NewTemplateWindow(kLinkDlgID, GetOwner()->GetDocument());
		ThrowIfNULL_AC(dialog);
		TEditText* urlEditText = dynamic_cast<TEditText*>(dialog->FindSubView('url.'));
		IDType dismisser = dialog->PoseModally();
		dialog->Close();
		if (dismisser == 'okay')
		{
			if (urlEditText)
			{
				CStr255_AC url = urlEditText->GetText();
				link = (char*) MMAllocate(url.Length() + 1);
				ThrowIfNULL_AC(link);
				BlockMove_AC(&url[1], link, url.Length());
				link[url.Length()] = 0;
			}
		}
	}

	return link;
}

//----------------------------------------------------------------------------------------
// GetOwner
//----------------------------------------------------------------------------------------

TWEView* TLinkBehavior::GetOwner() const
{
	TWEView* itsView = dynamic_cast_AC(TWEView*, fOwner);
	ThrowIfNonObject_AC(itsView);
	return itsView;
}

//----------------------------------------------------------------------------------------
// GetWEReference
//----------------------------------------------------------------------------------------

WEReference TLinkBehavior::GetWEReference() const
{
	WEReference hWE = GetOwner()->GetWEReference();
	return hWE;
}


//========================================================================================
// CLASS TLinkCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TLinkCommand constructor
//----------------------------------------------------------------------------------------

TLinkCommand::TLinkCommand(TWEView* itsView, char* itsLink, CommandNumber itsCommandNumber)
	:	TWEStylerCommand(itsView, NULL, itsCommandNumber),
		fLink(itsLink)
{
}

//----------------------------------------------------------------------------------------
// TLinkCommand destructor
//----------------------------------------------------------------------------------------

TLinkCommand::~TLinkCommand()
{
}

//----------------------------------------------------------------------------------------
// TLinkCommand::GetStyler:
//----------------------------------------------------------------------------------------

WEStylerReference TLinkCommand::GetStyler()
{
	if (!fStyler)
	{
		char* link = GetLink();
		if (link)
		{
			int count = std::strlen(link) + 1;
			Handle objectDataHandle = NewHandle(count);
			ThrowIfNULL_AC(objectDataHandle);
			BlockMove_AC(link, *objectDataHandle, count);
			ThrowIfOSErr_AC(WENewStyler('url ', objectDataHandle, fWE, &fStyler));
		}
	}
	return fStyler;
}

//----------------------------------------------------------------------------------------
// TLinkCommand::GetLink:
//----------------------------------------------------------------------------------------

char* TLinkCommand::GetLink()
{
	if (!fLink)
	{
		fLink = reinterpret_cast<TLinkBehavior*>(fWEView)->PoseLinkDialog();
	}
	return fLink;
}


//----------------------------------------------------------------------------------------
// End of ULinkBehavior.cpp
