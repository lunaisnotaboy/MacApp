//----------------------------------------------------------------------------------------
// CCursor.cpp
// Copyright © 1999-2001 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/17/00	Include Resources.h.
		11/22/99	Initial version. 
*/

#ifndef __CCursor__
#include "CCursor.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

// Toolbox

#ifndef __RESOURCES__
#include <Resources.h>
#endif

//========================================================================================
// class CColorCursor
//========================================================================================
#undef Inherited

//========================================================================================
// class CMonoCursor
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// CMonoCursor constructor
//----------------------------------------------------------------------------------------

CMonoCursor::CMonoCursor(short cursorID)
{
	CursHandle cursor = GetCursor(cursorID);
	if (cursor)
		*static_cast<Cursor*>(this) = **cursor;
	else
		ThrowIfResError_AC();

	ReleaseResource(reinterpret_cast<Handle>(cursor));
}

//========================================================================================
// class CTempCursor
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// CTempCursor constructor
//----------------------------------------------------------------------------------------

CTempCursor::CTempCursor(short cursorID)
	:	fColorCursor(cursorID),
		fMonoCursor()
{
	if (!fColorCursor)
		fMonoCursor = TH_new CMonoCursor(cursorID);
}

//----------------------------------------------------------------------------------------
// CTempCursor copy constructor
//----------------------------------------------------------------------------------------

CTempCursor::CTempCursor(CTempCursor& from)
	:	fColorCursor(from.fColorCursor.release()),
		fMonoCursor(from.fMonoCursor.release())
{
}

//----------------------------------------------------------------------------------------
// CTempCursor::Set
//----------------------------------------------------------------------------------------

void CTempCursor::Set()
{
	if (fColorCursor)
		fColorCursor.Set();
	else if (fMonoCursor)
		fMonoCursor->Set();
}


//----------------------------------------------------------------------------------------
// End of CCursor.cpp
