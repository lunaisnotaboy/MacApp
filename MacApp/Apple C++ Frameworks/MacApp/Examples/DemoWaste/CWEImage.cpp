//----------------------------------------------------------------------------------------
// CWEImage.cpp
// Copyright © 1999-2001 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		06/24/00	Idle for objects. Use a movie for the images. 
		06/23/00	Change object data handle to a DataReferenceRecord so it can
							accomodate any data reference type. 
		11/19/99	Move to DemoWaste from Bowser. 
		11/04/99	WEInstallObjectHandler takes only a UniversalProcPtr so we
							have to cast for the 68K build. 
		11/03/99	Force the graphics importer to draw in the current GWorld so 
							it will work when WASTE is drawing offscreen. 
		10/12/99	Initial version. 
*/

#ifndef __CWEImage__
#include "CWEImage.h"
#endif

// Bowser

// MacApp

// ACS

#ifndef __Bail_AC__
#include "Bail_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

// WASTE

#include "WETabs.h"
#include "WEExtras.h"

// Toolbox

#ifndef __IMAGECOMPRESSION__
#include <ImageCompression.h>
#endif

#ifndef __MOVIES__
#include <Movies.h>
#endif

// ANSI

#define MOVIE 0

//========================================================================================
// class CWEImage
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// CWEImage::Install()
//		Installs the handler into WASTE.
//----------------------------------------------------------------------------------------

void CWEImage::Install(WEReference theWE)
{
	static WENewObjectUPP		pNewHandlerUPP;
	static WEDisposeObjectUPP	pDisposeHandlerUPP;
	static WEDrawObjectUPP		pDrawHandlerUPP;
	static WEIdleObjectUPP		pIdleHandlerUPP;

	if (!pNewHandlerUPP)
	{
		pNewHandlerUPP = NewWENewObjectProc(HandleNew);
		ThrowIfNULL_AC(pNewHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weNewHandler, (UniversalProcPtr)pNewHandlerUPP, theWE));
	}

	if (!pDisposeHandlerUPP)
	{
		pDisposeHandlerUPP = NewWEDisposeObjectProc(HandleDispose);
		ThrowIfNULL_AC(pDisposeHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weDisposeHandler, (UniversalProcPtr)pDisposeHandlerUPP, theWE));
	}

	if (!pDrawHandlerUPP)
	{
		pDrawHandlerUPP = NewWEDrawObjectProc(HandleDraw);
		ThrowIfNULL_AC(pDrawHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weDrawHandler, (UniversalProcPtr)pDrawHandlerUPP, theWE));
	}

	if (!pIdleHandlerUPP)
	{
		pIdleHandlerUPP = NewWEIdleObjectProc(HandleIdle);
		ThrowIfNULL_AC(pIdleHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weIdleHandler, (UniversalProcPtr)pIdleHandlerUPP, theWE));
	}
}

//----------------------------------------------------------------------------------------
// HandleNew
// New Object Handler
//----------------------------------------------------------------------------------------

pascal OSErr CWEImage::HandleNew(Point *defaultObjectSize, WEObjectReference obj)
{
	OSErr err = noErr;

	DataReferenceRecord** dataRefHandle = reinterpret_cast<DataReferenceRecord**>(WEGetObjectDataHandle(obj));
	BailIf(GetHandleSize((Handle)dataRefHandle) != sizeof(DataReferenceRecord), invalidDataRef)

    OSType dataRefType = (**dataRefHandle).dataRefType;
    Handle dataRef = (**dataRefHandle).dataRef;
	
	CRect_AC naturalBounds;

#if MOVIE
	BailOSErr(EnterMovies());

	Movie theMovie = NULL;
	short id = 0;
	BailOSErr(NewMovieFromDataRef(&theMovie, 0, &id, dataRef, dataRefType));
	
	WESetObjectRefCon(obj, (long)theMovie);

	GetMovieNaturalBoundsRect(theMovie, &naturalBounds);
	BailOSErr(GetMoviesError());

	*defaultObjectSize = naturalBounds.GetSize();
#else
	ComponentInstance gi = NULL;
	BailOSErr(GetGraphicsImporterForDataRef(dataRef, dataRefType, &gi));
	
	WESetObjectRefCon(obj, (long)gi);

	BailOSErr(GraphicsImportGetNaturalBounds(gi, &naturalBounds));

	*defaultObjectSize = naturalBounds.GetSize();
#endif

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// Dispose Object Handler
//----------------------------------------------------------------------------------------

pascal OSErr CWEImage::HandleDispose(WEObjectReference obj)
{
	OSErr err = noErr;

#if MOVIE
	Movie theMovie = (Movie)WEGetObjectRefCon(obj);
	if (theMovie)
	{
		DisposeMovie(theMovie);
		WESetObjectRefCon(obj, NULL);
	}

	ExitMovies();
#else
	ComponentInstance gi = (ComponentInstance)WEGetObjectRefCon(obj);
	if (gi)
	{
		CloseComponent(gi);
		WESetObjectRefCon(obj, NULL);
	}
#endif

	DataReferenceRecord** dataRefHandle = reinterpret_cast<DataReferenceRecord**>(WEGetObjectDataHandle(obj));
    Handle dataRef = (**dataRefHandle).dataRef;
    if (dataRef)
    {
		DisposeHandle(dataRef);
		(**dataRefHandle).dataRef = NULL;
		BailMemErr();
    }

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// Draw Object Handler
//----------------------------------------------------------------------------------------

pascal OSErr CWEImage::HandleDraw(Rect *destRect, WEObjectReference obj)
{
	OSErr err = noErr;

#if MOVIE
	Movie theMovie = (Movie)WEGetObjectRefCon(obj);
	if (theMovie)
	{
		CGrafPtr port = NULL;
		GDHandle gdh = NULL;
		GetGWorld(&port, &gdh);
		SetMovieGWorld(theMovie, port, gdh);
		BailOSErr(GetMoviesError());
		SetMovieBox(theMovie, destRect);
		BailOSErr(GetMoviesError());
		BailOSErr(UpdateMovie(theMovie));
		MoviesTask(theMovie, 1);
		BailOSErr(GetMoviesError());
	}
#else
	ComponentInstance gi = (ComponentInstance)WEGetObjectRefCon(obj);
	if (gi)
	{
		CGrafPtr port = NULL;
		GDHandle gdh = NULL;
		GetGWorld(&port, &gdh);
		BailOSErr(GraphicsImportSetGWorld(gi, port, gdh));
		BailOSErr(GraphicsImportSetBoundsRect(gi, destRect));
		BailOSErr(GraphicsImportDraw(gi));
	}
#endif

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// Idle Object Handler
//----------------------------------------------------------------------------------------

pascal void CWEImage::HandleIdle(WEObjectReference obj)
{
#if MOVIE
	Movie theMovie = (Movie)WEGetObjectRefCon(obj);
	if (theMovie)
	{
		MoviesTask(theMovie, 1);
		OSErr err = GetMoviesError();
	}
#else
#pragma unused (obj)
#endif
}


//----------------------------------------------------------------------------------------
// End of CWEImage.cpp
