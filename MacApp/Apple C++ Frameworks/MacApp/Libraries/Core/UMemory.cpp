//----------------------------------------------------------------------------------------
// UMemory.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/01/01	Don't include Memory_AC. 
		01/26/01	Do not resize in SetPermPtrSize or SetPermHandleSize if size is
					not changing.  (This works around a problem when closing
					file-mapped resources.)
		01/02/01	Update copyright.
		12/27/00	Define oldSize in SetPermHandleSize for qCoreDebug not qDebug.
		11/09/00	[PB] Suppress GCC warnings about unused return variables. 
		11/04/00	[C] Don’t include UPatch.h.
		11/01/00	[PB] Include MacErrors instead of Errors.   No GrowZoneProc
					or InstallGrowZoneProc.
		09/20/00	No need to coerce const string to StringPtr in GrowZoneProc.
		07/31/00	[W] Conditionalized implementation of FailNoReserve, 
					FailSpaceIsLow, MoreMasterPointers and HasLowSpaceReserve.
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Use CTempResLoad.
					Include ResourceUtils_AC.h.
		06/14/00	Replace MASetResLoad with CTempResLoad.  Include CMultiLocal_AC.h.
		05/15/00	CW Pro 6: ambiguous ProgramBreak and ProgramReport overloads. 
					Switch the order of the arguments for the buffer-oriented calls. 
					Work around local abs conflicting with std::abs. 
		04/25/00	Use kNewInitVal_AC in NewPermHandle, NewPermPtr and SetPermHandleSize
					only if qCoreDebug, not qDebug and kResizedPtrInitVal_AC in SetPermPtrSize.
		02/22/00	[W] Do not implement MemSpaceIsLow for Windows.  Do
					not call MoreMasterPointers in InitUMemory.
		12/08/99	Made IsHandleEligible, abs, BuildTemporaryReserve inline.
		10/20/99	Add call to MoreMasterPointers() to match Carbon's version.
		10/18/99	Carbon: InitUMemory: make call to MoreMasterPointers.
		09/23/99	Carbon: change #warning to #pragma message
		07/23/99	[C] Only call MoreMasters in InitUMemory.
		03/24/99	Update copyright notice.
		12/18/98	[W] Work around GZSaveHnd in IsHandleEligible.
		11/13/98	[2279271] Fixed call to ProgramReport_AC in CheckRsrcUsage.
		11/18/98	[Carbon] In InitUMemory, don't mess with moreMast field of applZone
		10/08/98	GetHandleSizeIfLocked. 
					MPurgeable. TotalSize is const. 
*/

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

// MacApp

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UNIVERSALSTARTUP__
#include "UniversalStartup.h"
#endif

#if !qMSWindows
	#ifndef __UPATCH__
	#include "UPatch.h"
	#endif
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __ResourceUtils_AC__
#include "ResourceUtils_AC.h"
#endif

// Toolbox

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#if !qProjectBuilder
	#ifndef __TRAPS__
	#include <Traps.h>
	#endif
#endif

// ANSI

#ifndef __LIMITS__
#include <limits.h>
#endif


typedef pascal void(* NotifyType)(Handle h);

enum
{
	kHeapOverhead = 8
};

//----------------------------------------------------------------------------------------
// Globals to this module and externally available.

#if qDebug
bool gCheckRsrcUsage = true;
#else
bool gCheckRsrcUsage;
#endif

short gRsrcCheck = kRsrcCheckInterval;

Size gMaxLockedRsrc;

#if !qMSWindows

// Memory hooks
CGrowZoneHook* CGrowZoneHook::fFirst;

CMMHandleList gApp1MemList;
//CSysMemList gSysMemList;
CMMHandleList gApp2MemList;

UniversalProcPtr gGZPurgeNotify;

#endif

long pTemporaryReserveShortfall;				// amt. that we are lacking in the
												// temporary reserve

static Handle pTemporaryReserve;				// Contains temporary (code) reserve.
static Handle pLowSpaceReserve;					// Allocates low memory reserve.
static Size pTotalTemporaryReserveSize;			// Attempt to reserve this much memory for
												// the temporary (code) reserve.
												// This is the total size necessary to
												// account for temporary requests,
												// NOT the size of the temporaryReserve
static Size pLowSpaceReserveSize;				// Attempt to reserve this much memory for
												// the low-memory reserve.

static long pLastBuildAllReservesFreeMem = -1;	// amount of freemem for which the reserves
												// are valid

static bool pInGrowZone;						// true when the growzoneproc has been entered

static bool pTemporaryAllocation = true;		// Controls behavior of the GrowZone proc.
												// true if it's ok to dip into the temp reserve

static bool pGotLowSpaceReserve;				// true if the low space reserve could be allocated

//========================================================================================
// GLOBAL Procedures
//========================================================================================

static bool IsHandleEligible(Handle h);

static void BuildTemporaryReserve(Size allocLim);
static void BuildTemporaryReserve(Size allocLim, Size tempInMemorySize);

#if !qMSWindows && !qCarbon

pascal long GrowZoneProc(Size needed);

static void InstallGrowZoneProc();

#endif

static Size ReleaseTemporaryReserve();

static Size ReleaseLowSpaceReserve();

static bool HasLowSpaceReserve();

//----------------------------------------------------------------------------------------
// TPermHandleHandler uses UMemory calls to differentiate temp vs. permanent memory allocations.
// It is installed into the ACS so calls to PermHandle_AC use MacApp's calls (an interim solution).
//----------------------------------------------------------------------------------------

class TPermHandleHandler : public CPermHandleHandler_AC
{
public:
	TPermHandleHandler();
	virtual ~TPermHandleHandler();
	
	virtual Handle DoNewHandle(Size size);
		// Calls NewPermHandle
		
	virtual void DoSetHandleSize(Handle h, Size newSize);
		// Calls SetPermHandleSize

};

//----------------------------------------------------------------------------------------
// TPermHandleHandler constructor:
//----------------------------------------------------------------------------------------

TPermHandleHandler::TPermHandleHandler()
{
}

//----------------------------------------------------------------------------------------
// TPermHandleHandler destructor:
//----------------------------------------------------------------------------------------

TPermHandleHandler::~TPermHandleHandler()
{
}
	
//----------------------------------------------------------------------------------------
// TPermHandleHandler::DoNewHandle:
//----------------------------------------------------------------------------------------

Handle TPermHandleHandler::DoNewHandle(Size size)
{
	return ::NewPermHandle(size);
}
		
//----------------------------------------------------------------------------------------
// TPermHandleHandler::DoSetHandleSize:
//----------------------------------------------------------------------------------------

void TPermHandleHandler::DoSetHandleSize(Handle h, Size newSize)
{
	::SetPermHandleSize(h, newSize);
}

//----------------------------------------------------------------------------------------
// IsHandleEligible: 
//----------------------------------------------------------------------------------------

static inline bool IsHandleEligible(Handle h)
{
#if qMSWindows
	#pragma message ("IsHandleEligible: Do we need substitute logic for GZSaveHnd.")
	return h && *h;
#else
	return h && *h  && h != ::GZSaveHnd();
#endif
}

//----------------------------------------------------------------------------------------
// Abs: 
//----------------------------------------------------------------------------------------

static inline long Abs(long x)
{
	return (x < 0) ? -x : x;
}

#if !qMSWindows

//========================================================================================
// CLASS MPurgeable
//========================================================================================

//----------------------------------------------------------------------------------------
// MPurgeable destructor
//----------------------------------------------------------------------------------------

MPurgeable::~MPurgeable()
{
}

//----------------------------------------------------------------------------------------
// MPurgeable::TotalSize: 
//----------------------------------------------------------------------------------------

Size MPurgeable::TotalSize(bool /*justLocked*/) const
{
	return 0;
}

//----------------------------------------------------------------------------------------
// MPurgeable::Purge: 
//----------------------------------------------------------------------------------------

Size MPurgeable::Purge(Size /*needed*/)
{
	return 0;
}


//========================================================================================
// CLASS CGrowZoneHook
//========================================================================================

//----------------------------------------------------------------------------------------
// CGrowZoneHook constructor: 
//----------------------------------------------------------------------------------------
CGrowZoneHook::CGrowZoneHook() :
fNext(NULL)
{
}

//----------------------------------------------------------------------------------------
// CGrowZoneHook destructor: 
//----------------------------------------------------------------------------------------
CGrowZoneHook::~CGrowZoneHook()
{
}

//----------------------------------------------------------------------------------------
// CGrowZoneHook::InsertFirst: 
//----------------------------------------------------------------------------------------
void CGrowZoneHook::InsertFirst()
{
	fNext = fFirst;
	fFirst = this;
}

//----------------------------------------------------------------------------------------
// CGrowZoneHook::InsertLast: 
//----------------------------------------------------------------------------------------
void CGrowZoneHook::InsertLast()
{
	if (!fFirst)
		fFirst = this;
	else
	{
		CGrowZoneHook* hook = fFirst;
		CGrowZoneHook* next;
		while ((next = hook->fNext) != NULL)
			hook = next;
		
		hook->fNext = this;
	}
}

//----------------------------------------------------------------------------------------
// CGrowZoneHook::TotalTempSize: 
//----------------------------------------------------------------------------------------
Size CGrowZoneHook::TotalTempSize(bool justLocked)
{
	Size total = 0;
	CGrowZoneHook* hook = fFirst;
	while (hook)
	{
		total += hook->TotalSize(justLocked);
		hook = hook->fNext;
	}
	return total;
}

//----------------------------------------------------------------------------------------
// CGrowZoneHook::EachPurge: 
//----------------------------------------------------------------------------------------
Size CGrowZoneHook::EachPurge(Size needed)
{
	Size purged = 0;
	CGrowZoneHook* hook = fFirst;
	while (hook && (purged < needed))
	{
		purged += hook->Purge(needed);
		hook = hook->fNext;
	}
	return purged;
}

//========================================================================================
// CLASS CMMHandleList
//========================================================================================

//----------------------------------------------------------------------------------------
// CMMHandleList constructor: 
//----------------------------------------------------------------------------------------
CMMHandleList::CMMHandleList() :
	fSize(0),
	fHandleList(NULL)
{
}

//----------------------------------------------------------------------------------------
// CMMHandleList destructor: 
//----------------------------------------------------------------------------------------
CMMHandleList::~CMMHandleList()
{
	fSize = 0;
	if (fHandleList)
		DisposeHandle((Handle)fHandleList);
	fHandleList = NULL;
}

//----------------------------------------------------------------------------------------
// CMMHandleList::AddAllRsrc: 
//----------------------------------------------------------------------------------------
void CMMHandleList::AddAllRsrc(ResType rType)
{
	enum
	{
		kROMResident = 1
	};

	ACS::CTempResLoad(false);

	short nResources = CountResources(rType);
	for (short i = 1; i <= nResources; ++i)
	{
		Handle h = GetIndResource(rType, i);

		if (h)
		{
			short theID;
			ResType theType;
			CStr255_AC theName;
			// •••  This might just be better as a plain ::GetResInfo.
			CMultiLocale_AC::GetReverseMappedResInfo(h, &theID, &theType, theName);

			// If there is a ROM resource for this type and ID, don't put it
			// on the list since it will not consume any memory.

			UseROMMap(false);
			Handle romHandle = GetResource(rType, theID);
			UseROMMap(true);
			if (romHandle && (HomeResFile(romHandle) != kROMResident) && !(GetResAttrs(h) & resSysHeap))
				AddHandle(romHandle);
		}
	}
}

//----------------------------------------------------------------------------------------
// CMMHandleList::AddHandle: 
//----------------------------------------------------------------------------------------
void CMMHandleList::AddHandle(Handle h)
{
	if (!fHandleList)
	{
		fHandleList = (HandleListHandle)NewHandle(0);
		::ThrowIfNULL_AC(fHandleList);
	}
	Munger((Handle)fHandleList, 0, NULL, 0, &h, sizeof(Handle));
	::ThrowIfMemError_AC();
	++fSize;
}

//----------------------------------------------------------------------------------------
// CMMHandleList::TotalSize: 
//----------------------------------------------------------------------------------------
Size CMMHandleList::TotalSize(bool justLocked) const
{
	Size total = 0;
	int i = GetSize();
	while (--i > 0)
	{
		Handle h = (*fHandleList)[i];
		if (h && !::IsHandlePurged_AC(h))	// in memory already
		{
			//HNoPurge(h);
			if (!justLocked || IsHandleLocked_AC(h))
				total += ::GetHandleSize(h) + kHeapOverhead;
		}
	}
	return total;
}

//----------------------------------------------------------------------------------------
// CMMHandleList::Purge: 
//----------------------------------------------------------------------------------------
Size CMMHandleList::Purge(Size needed)
{
	Size purged = 0;
	int i = GetSize();
	while (--i > 0)
	{
		Handle h = (*fHandleList)[i];
		if (::IsHandleEligible(h) && !IsHandleLocked_AC(h))
		{
			purged += ::GetHandleSize(h);
			EmptyAHandle(h);
			if (purged >= needed)
				break;
		}
	}
	return purged;
}

//========================================================================================
// CLASS CSysMemList
//========================================================================================

//----------------------------------------------------------------------------------------
// CSysMemList constructor: 
//----------------------------------------------------------------------------------------
CSysMemList::CSysMemList()
{
}

//----------------------------------------------------------------------------------------
// CSysMemList destructor: 
//----------------------------------------------------------------------------------------
CSysMemList::~CSysMemList()
{
}

//----------------------------------------------------------------------------------------
// CSysMemList::TotalSize: 
//----------------------------------------------------------------------------------------
Size CSysMemList::TotalSize(bool justLocked) const
{
	Size total = 0;

	int i = GetSize();
	while (--i > 0)
	{
		Handle h = (*fHandleList)[i];
		if (h && !::IsHandlePurged_AC(h))	// in memory already
		{
			// don't fool with system defprocs
			// don't HNoPurge(h);
			
			if (!justLocked || IsHandleLocked_AC(h))
				total += ::GetHandleSize(h) + kHeapOverhead;
		}
	}

	return total;
}

//----------------------------------------------------------------------------------------
// CSysMemList::Purge: 
//----------------------------------------------------------------------------------------
Size CSysMemList::Purge(Size needed)
{
	Size purged = 0;
	int i = GetSize();
	while (--i > 0)
	{
		Handle h = (*fHandleList)[i];
		if (::IsHandleEligible(h) && !IsHandleLocked_AC(h))
		{
			purged += ::GetHandleSize(h);
			EmptyAHandle(h);
			if (purged >= needed)
				break;
		}
	}
	return purged;
}

#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// BuildTemporaryReserve: 
//----------------------------------------------------------------------------------------
inline void BuildTemporaryReserve(Size allocLim)
{
#if !qMSWindows
	BuildTemporaryReserve(allocLim, CGrowZoneHook::TotalTempSize(false));
#else
	// ••• This is clearly not the proper solution.
	BuildTemporaryReserve(allocLim, 0);
#endif
}

//----------------------------------------------------------------------------------------
// BuildTemporaryReserve: 
//----------------------------------------------------------------------------------------
void BuildTemporaryReserve(Size allocLim, Size tempInMemorySize)
{
#if qDebug
	if (IsTemporaryAllocation())
		::ProgramBreak_AC("BuildTemporaryReserve called with IsTemporaryAllocation() = true");
#endif

	pTemporaryReserveShortfall = 0;

	// compute amt actually needed
	Size needed = Min_AC(pTotalTemporaryReserveSize - tempInMemorySize - kHeapOverhead, allocLim);

	if (needed > 0)
	{
		long tryThis = Min_AC(allocLim, needed);

		if (::IsHandlePurged_AC(pTemporaryReserve) || ::IsHandleEligible(pTemporaryReserve))
		{
			ReallocateHandle(pTemporaryReserve, tryThis);
			if (MemError() != noErr)
				ReleaseLowSpaceReserve();
		}

		if (!pInGrowZone)
		{
			if (::IsHandlePurged_AC(pTemporaryReserve))
			{
				//
				// Didn't get it before, now we try a little harder
				//
				PurgeMem(needed);
				long avail = CompactMem(needed);
	
				ReallocateHandle(pTemporaryReserve, Min_AC(avail, needed));
	
				if (!::IsHandlePurged_AC(pTemporaryReserve))
					pTemporaryReserveShortfall = pTotalTemporaryReserveSize - ::GetHandleSize(pTemporaryReserve);
				else
					pTemporaryReserveShortfall = pTotalTemporaryReserveSize - avail;
			}

			// Large handles are almost as obnoxious as nonrelocatable blocks. Try to get
      		// this guy out of the way, just in case.
			if (!::IsHandlePurged_AC(pTemporaryReserve))
				MoveHHi(pTemporaryReserve);
		}
	}
	else // free the current temporary reserve
		ReleaseTemporaryReserve();

}

//----------------------------------------------------------------------------------------
// BuildAllReserves: 
//----------------------------------------------------------------------------------------
void BuildAllReserves()
{
	//
	// The reserves are valid for a given amount of Free Memory. If the amount of free
	// memory hasn't changed then the state of the reserves hasn't really changed either.
	//
	enum
	{
		kSlopFactor = 64
	};

	if (Abs(FreeMem() - pLastBuildAllReservesFreeMem) > kSlopFactor)
	{
		// set the permanent flag to ensure that the temporary reserve is actually allocated and
		// not given up to the low space reserve
	
		bool priorTemp = TemporaryAllocation(false);// make sure temporary reserve is OK
	
		// reallocate the low space Reserve, if necessary
		if (!HasLowSpaceReserve())
		{
			pGotLowSpaceReserve = false;
	
			if (!pTemporaryReserveShortfall)
			{
				ReallocateHandle(pLowSpaceReserve, pLowSpaceReserveSize);
				pGotLowSpaceReserve = MemError() == noErr;
			}
		}
	
		TemporaryAllocation(priorTemp);
		
		pLastBuildAllReservesFreeMem = FreeMem();
	}
}

//----------------------------------------------------------------------------------------
// CheckReserve: 
//----------------------------------------------------------------------------------------
bool CheckReserve()
{
	BuildAllReserves();

	return !pTemporaryReserveShortfall;
}

//----------------------------------------------------------------------------------------
// CheckRsrcUsage: 
//----------------------------------------------------------------------------------------
void CheckRsrcUsage()
{
	if (gCheckRsrcUsage)
	{
#if !qMSWindows

		long sz = CGrowZoneHook::TotalTempSize(true);
		if (sz > gMaxLockedRsrc)
		{
			// In non debug mode, one can calculate seg! and mem! resources by loading the application
			// under with a debugger, setting the variable gCheckRsrcUsage to true, and setting a break
			// point on the following line. Everytime the debugger breaks on this line, you can 
			// look at your heap and loaded segments.

			gMaxLockedRsrc = sz;

#if qDebug
			if (gRsrcReport)
				::ProgramReportOrBreak_AC(gMemMgtBreak, "CheckRsrcUsage: New maximum resources usage: %d", gMaxLockedRsrc);
#endif

		}
#endif
	}
}

//----------------------------------------------------------------------------------------
// FailNoReserve: 
//----------------------------------------------------------------------------------------
void FailNoReserve()
{
#if !qMSWindows
	if (!CheckReserve())
		::ThrowException_AC(memFullErr, 0);
#endif
}

//----------------------------------------------------------------------------------------
// FailSpaceIsLow: 
//----------------------------------------------------------------------------------------
void FailSpaceIsLow()
{
#if !qMSWindows
	if (MemSpaceIsLow())
		::ThrowException_AC(memFullErr, 0);
#endif
}

//----------------------------------------------------------------------------------------
// GetReserveSize: 
//----------------------------------------------------------------------------------------
void GetReserveSize(Size& szTemporaryReserve,
					Size& szMemReserve)
{
	szTemporaryReserve = pTotalTemporaryReserveSize;
	szMemReserve = pLowSpaceReserveSize;
}


//----------------------------------------------------------------------------------------
// EmptyAHandle: 
//----------------------------------------------------------------------------------------
void EmptyAHandle(Handle h)
{
#if !qMSWindows
	if (gGZPurgeNotify)
		((NotifyType)gGZPurgeNotify)(h);
#endif

	EmptyHandle(h);
}

#if !qMSWindows && !qCarbon

//----------------------------------------------------------------------------------------
// GrowZoneProc: 
//----------------------------------------------------------------------------------------
pascal long GrowZoneProc(Size needed)
{
	long OldA5 = SetCurrentA5();				// Can be called from other worlds 
	long result = 0;							// default is to fail 

	if (!pInGrowZone)						// prevent re-entrane 
	{
		pInGrowZone = true;

		if (IsTemporaryAllocation())
		{
			result = CGrowZoneHook::EachPurge(needed);
		}
		else 
		{
			//
			// If this is a permanent request; see if the temporary reserve is too large 
			//
			if (::IsHandleEligible(pTemporaryReserve))
			{
				// compute size of resources currently in memory 
				Size tempInMemorySize = CGrowZoneHook::TotalTempSize(false);
				
				long tempReserveSize = ::GetHandleSize(pTemporaryReserve);
				if (tempInMemorySize + tempReserveSize + kHeapOverhead > pTotalTemporaryReserveSize)
				{
					// this should cut down the existing temporary reserve. 
					BuildTemporaryReserve(tempReserveSize, tempInMemorySize);
	
					// see if we succeeded in freeing some memory 
					long newTempReserveSize = ::GetHandleSize(pTemporaryReserve);
					if (::IsHandlePurged_AC(pTemporaryReserve))
						result = tempReserveSize;
					else if ((newTempReserveSize < tempReserveSize))
						result = tempReserveSize - newTempReserveSize;
				}
			}
	
			// Didn't free anything above. However, we may still be able to get someone
			// to purge something for us; only purge it if there is too much temp stuff
			// in memory already
			if (!result && ::IsHandlePurged_AC(pTemporaryReserve))
			{
				result = CGrowZoneHook::EachPurge(needed);
//				BuildTemporaryReserve(result);
				BuildTemporaryReserve(MaxBlock());
			}
	
			// last ditch attempt-free emergency reserve
			if (!result)
				result = ReleaseLowSpaceReserve();
		}

		pInGrowZone = false;
	}
	else
	{
#if qDebug
		DebugStr("\pGrowZoneProc has been re-entered.");
#endif
	}
	
	OldA5 = SetA5(OldA5);

	return result;
}
#endif

#if !qMSWindows && !qCarbon

//----------------------------------------------------------------------------------------
// InstallGrowZoneProc: Once called the grow zone proc's segment CANNOT be moved since
// we're passing a NON-JT address to SetGrowZone (so we can be called from "other worlds"
//----------------------------------------------------------------------------------------
void InstallGrowZoneProc()
{
	GrowZoneUPP gzUPP = NewGrowZoneProc(GrowZoneProc);
	::ThrowIfNULL_AC(gzUPP);
	SetGrowZone(gzUPP);
}

#endif

//----------------------------------------------------------------------------------------
// InitUMemory: 
//----------------------------------------------------------------------------------------
void InitUMemory(short callsToMoreMasters)
{
#if !qMSWindows
	MoreMasterPointers(callsToMoreMasters);
#endif
	//
	// Pickup the starting points 
	//
	Size heapSize = GetSizeObjectHeap();
#if qProjectBuilder
	(void) heapSize;
#endif
	Size heapIncrement = GetSizeHeapIncrement();
	Size temporaryReserve = GetSizeTempReserve();
	Size lowSpaceRes = GetSizeLowSpaceReserve() + heapIncrement;	// Include a heap block in our low
																	// space reserve to ensure that temporary 
																	// objects can still be allocated.

	// Initialize memory management globals

	pLowSpaceReserve = NewEmptyHandle();
	::ThrowIfNULL_AC(pLowSpaceReserve);

	pTemporaryReserve = NewEmptyHandle();
	::ThrowIfNULL_AC(pTemporaryReserve);

//		// init the gSysMemList 
//	#if !qMSWindows
//		gSysMemList.AddAllRsrc('LDEF');
//		gSysMemList.AddAllRsrc('CDEF');
//		gSysMemList.AddAllRsrc('MDEF');
//		gSysMemList.AddAllRsrc('WDEF');
//		gSysMemList.AddAllRsrc('PACK');
//	#endif

	gUMemoryInitialized = true;

	SetReserveSize(temporaryReserve, lowSpaceRes);

	if (pTemporaryReserveShortfall)					// couldn't get temporary reserve. Can't continue
		::ThrowException_AC(memFullErr, 0);

	// Memory hooks
#if !qMSWindows && !qCarbon
	gApp1MemList.InsertLast();
//	gSysMemList.InsertLast();
	gApp2MemList.InsertLast();

	InstallGrowZoneProc();
#endif

	SetPermHandleHandler_AC(TH_new TPermHandleHandler);
}

//----------------------------------------------------------------------------------------
// MoreMasterPointers:
//
// Here is a trick suggested by Jerome C.--it allocates several large blocks of master
// pointers. Now it's even approved in the new IM!
//----------------------------------------------------------------------------------------
#if !qCarbon && !qMSWindows
void MoreMasterPointers(UInt32 callsToMoreMasters)
{
	THz applZone = ApplicationZone();
	short oldMoreMast = applZone->moreMast;
	long numMasterPointersDesired = oldMoreMast * callsToMoreMasters;
	do
	{
		applZone->moreMast = Min_AC(numMasterPointersDesired, SHRT_MAX);
		MoreMasters();
		numMasterPointersDesired -= applZone->moreMast;
	} while (numMasterPointersDesired > 0);
	applZone->moreMast = oldMoreMast;
}
#endif

#if !qMSWindows

//----------------------------------------------------------------------------------------
// MemSpaceIsLow: 
//----------------------------------------------------------------------------------------
bool MemSpaceIsLow()
{
	BuildAllReserves();

	return !pGotLowSpaceReserve;
}

#endif

//----------------------------------------------------------------------------------------
// NewPermHandle: 
//----------------------------------------------------------------------------------------
Handle NewPermHandle(Size logicalSize)
{
	bool priorTemp = TemporaryAllocation(false);// make sure temporary reserve is OK
	Handle aHandle = NewHandle(logicalSize);
	TemporaryAllocation(priorTemp);

	::ThrowIfNULL_AC(aHandle);
#if qCoreDebug
	BlockSet_AC(*aHandle, logicalSize, kNewInitVal_AC);
#endif

	return aHandle;
}

//----------------------------------------------------------------------------------------
// NewPermHandleClear: 
//----------------------------------------------------------------------------------------
Handle NewPermHandleClear(Size logicalSize)
{
	bool priorTemp = TemporaryAllocation(false);// make sure temporary reserve is OK
	Handle aHandle = NewHandleClear(logicalSize);
	TemporaryAllocation(priorTemp);

	::ThrowIfNULL_AC(aHandle);

	return aHandle;
}

//----------------------------------------------------------------------------------------
// NewPermPtr: 
//----------------------------------------------------------------------------------------
Ptr NewPermPtr(Size logicalSize)
{
	bool priorTemp = TemporaryAllocation(false);// make sure temporary reserve is OK
	Ptr aPtr = NewPtr(logicalSize);
	TemporaryAllocation(priorTemp);

	::ThrowIfNULL_AC(aPtr);
#if qCoreDebug
	BlockSet_AC(aPtr, logicalSize, kNewInitVal_AC);
#endif

	return aPtr;
}

//----------------------------------------------------------------------------------------
// NewPermPtrClear: 
//----------------------------------------------------------------------------------------
Ptr NewPermPtrClear(Size logicalSize)
{
	bool priorTemp = TemporaryAllocation(false);// make sure temporary reserve is OK
	Ptr aPtr = NewPtrClear(logicalSize);
	TemporaryAllocation(priorTemp);

	::ThrowIfNULL_AC(aPtr);

	return aPtr;
}

//----------------------------------------------------------------------------------------
// TemporaryAllocation: 
//----------------------------------------------------------------------------------------
bool TemporaryAllocation(bool temporary)
{
	bool returnVal = pTemporaryAllocation;

	if (temporary != pTemporaryAllocation)
	{
		pTemporaryAllocation = temporary;
		if (pTemporaryAllocation)
			ReleaseTemporaryReserve();
		else
			BuildTemporaryReserve(kGZMaxAlloc);
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TemporaryAllocation: 
//----------------------------------------------------------------------------------------
bool IsTemporaryAllocation()
{
	return pTemporaryAllocation;
}

//----------------------------------------------------------------------------------------
// PermCopyHandle: 
//----------------------------------------------------------------------------------------
Handle PermCopyHandle(const Handle inHandle)
{
	Handle returnVal = NULL;

	bool priorTemp = TemporaryAllocation(false);// make sure temporary reserve is OK
	OSErr err = CopyHandle_AC(inHandle, returnVal);
	TemporaryAllocation(priorTemp);

	::ThrowIfOSErr_AC(err);
	
	return returnVal;
}


//----------------------------------------------------------------------------------------
// SetPermHandleSize: 
//----------------------------------------------------------------------------------------
void SetPermHandleSize(Handle h, Size newSize)
{
	Size oldSize = ::GetHandleSize(h);

	if (oldSize != newSize)
	{
		bool priorTemp = TemporaryAllocation(false);// make sure temporary reserve is OK
		SetHandleSize(h, newSize);
		OSErr theError = MemError();
		TemporaryAllocation(priorTemp);
	
		// This lets us be assured that no
		// operations have occurred that would invalidate
		// the MemErr flag thus the following call will
		// give a true result
		if (theError != noErr)
			::ThrowException_AC(theError, 0);
	
#if qCoreDebug
		if (oldSize < newSize)
			BlockSet_AC((Ptr) * h + oldSize, newSize - oldSize, kNewInitVal_AC);
#endif
	}
}

//----------------------------------------------------------------------------------------
// SetPermPtrSize: 
//----------------------------------------------------------------------------------------
void SetPermPtrSize(Ptr p, Size newSize)
{
	Size oldSize = GetPtrSize(p);
	
	if (oldSize != newSize)
	{
		bool priorTemp = TemporaryAllocation(false);// make sure temporary reserve is OK
		SetPtrSize(p, newSize);
		OSErr theError = MemError();
		TemporaryAllocation(priorTemp);
	
		// This lets us be assured that no
		// operations have occurred that would invalidate
		// the MemErr flag thus the following call will
		// give a true result
		if (theError != noErr)
			::ThrowException_AC(theError, 0);
	
#if qCoreDebug
		if (oldSize < newSize)
			BlockSet_AC((Ptr)p + oldSize, newSize - oldSize, kResizedPtrInitVal_AC);
#endif
	}
}

//----------------------------------------------------------------------------------------
// SetReserveSize: 
//----------------------------------------------------------------------------------------
void SetReserveSize(Size temporary,
					Size forOther)
{
	pTotalTemporaryReserveSize = temporary;
	pLowSpaceReserveSize = forOther;

	// Since the numbers have changed, make sure we start from scratch. 
	ReleaseTemporaryReserve();
	ReleaseLowSpaceReserve();

	BuildAllReserves();
}

//----------------------------------------------------------------------------------------
// ReleaseLowSpaceReserve: 
//----------------------------------------------------------------------------------------
Size ReleaseLowSpaceReserve()
{
	Size returnVal = 0;
	if (::IsHandleEligible(pLowSpaceReserve))
	{
		returnVal = ::GetHandleSize(pLowSpaceReserve);
		EmptyAHandle(pLowSpaceReserve);
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// ReleaseTemporaryReserve: 
//----------------------------------------------------------------------------------------
Size ReleaseTemporaryReserve()
{
	Size returnVal = 0;
	if (::IsHandleEligible(pTemporaryReserve))
	{
		returnVal = ::GetHandleSize(pTemporaryReserve);
		EmptyAHandle(pTemporaryReserve);
	}

	Size didRelease = ReleaseLowSpaceReserve();

	return returnVal + didRelease;
}

//----------------------------------------------------------------------------------------
// HasLowSpaceReserve: 
//----------------------------------------------------------------------------------------
bool HasLowSpaceReserve()
{
#if !qMSWindows
	return !::IsHandlePurged_AC(pLowSpaceReserve);
#else
	return true;
#endif
}

//----------------------------------------------------------------------------------------
// HasTemporaryReserve: 
//----------------------------------------------------------------------------------------
bool HasTemporaryReserve()
{
	return !::IsHandlePurged_AC(pTemporaryReserve) && !pTemporaryReserveShortfall;
}

//----------------------------------------------------------------------------------------
// WriteReserves: fprintf's the temporary reserve and low-memory reserves to stderr
//----------------------------------------------------------------------------------------

#if qDebug

void WriteReserves()
{
	WrLblPtr("Temporary reserve (pTemporaryReserve)", pTemporaryReserve);
	ProgramReport_AC("\n");
	
	WrLblPtr("Low-space reserve (pLowSpaceReserve)", pLowSpaceReserve);
	ProgramReport_AC("\n");
}

#endif

//----------------------------------------------------------------------------------------
// GetHandleSizeIfLocked
//----------------------------------------------------------------------------------------

Size GetHandleSizeIfLocked(const Handle h, bool justLocked)
{
	Size itsSize = 0;
	if (h)
	{
		if (!justLocked || IsHandleLocked_AC(h))
			itsSize = GetHandleSize(h);

		// ••• Should we add kHeapOverhead ???
	}

	return itsSize;
}


//----------------------------------------------------------------------------------------
// End of UMemory.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		05/21/96	Use accessors to retrieve globals in order to ensure initialization.
		 5/09/96	Added CopyHandle_AC: a better HandToHand replacement. And created
		 					PermCopyHandle a better PermHandToHand.
		 5/03/96	Removed all knowledge of the gObjectHeap to UPointerObject.cp/.h
		05/03/96	Remove creation of the object heap to MAOperatorNew so that it never
							gets created if the MANewAndDelete.cp file is omitted.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		----- R10 -----
		03/27/96	Switch last remaining Str255s to CStr255s_AC
		 2/13/96	Switch to MemHeap from ObjectHeap as part of upgrade to ODMemMgr

		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		 11/2/95	Fix to InlineIsHandlePurged got lost. 
		11/01/95	[1290068] (Memory) Memory allocated in GrowZoneProc. 
		10/31/95	Debugging. 
		10/31/95	Remove extraneous call to FreeMem in BuildTemporaryReserve. 
		10/30/95	Add CGrowZoneHook. TotalTempSize is now a method of CGrowZoneHook. 
							Split TotalTempSize into TotalSize and Purge methods. 
							Removed calls to make handles non-purgeable in TotalSize and
							Purge. It is bad performance to call lots of toolbox traps in
							the grow zone proc, and it really should be up to the
							application developer which handles are non-purgeable. 
							EmptyAHandle now is extern. 
							Add 2nd flavor of BuildTemporaryReserve so it doesn't have to
							call TotalTempSize when called by the GrowZoneProc. 
		10/17/95	Allow FreeMem to vary by +- kSlopFactor before forcing rebuild of reserves.
		----- 3.3b1 -----
		 8/30/95	InlineIsHandlePurged didn't declare return type.
		  8/4/95	Change to NewPermPtrClear and NewPermHandleClear. 
		  8/2/95	Added 'clear' default parameter to NewPermHandle and NewPermPtr
		 7/14/95	IsTemporaryAllocation must be in Main segment. 
		  7/6/95	Add cast to StringPtr to make PPCC happy. 
		  7/5/95	Rename canPurge to handleToPurge. Add TotalSize method to
		  					CMMHandleList, add CSysMemList. Add TotalCodeSize. 
		 6/29/95	Don't leave TemporaryReserve and LowSpaceReserve allocated during temp.. 
		 6/29/95	Use FreeMem to avoid calls to TotalTempSize. 
		 6/29/95	Switch to InlineGetHandleSize. 
		 6/18/95	canPurge parameter to TotalTempSize changed to a pointer to Handle. 
		 6/18/95	Changed pMemReserve to pLowSpaceReserve. 
		 					Always calcuate pReserveShortfall
		 6/18/95	CheckRsrcUsage is not conditioned on #qDebug anymore. It is
		 					conditioned internally by gCheckRsrcUsage. 
		 6/18/95	Create CMMHandleList move AddHandle and AddAllRsrc to it.
		 6/15/95	Fix off by one error in TotalTempSize. 
		05/17/95	Moved Segment management to a separate unit
		05/16/95	Added MAResLoad
		05/16/95	Adapted changes from CW6 copy of MA3.3
		05/08/95	Removed PreloadSegment, changed LoadMacAppSegment and PostLoadMacAppSegment
							to "C" calling conventions.
		05/08/95	Remove support for DA's. Unnecessary with process manager
		 5/16/95	More fixes...
		05/05/95	Use a structure to hold code seg info
		05/04/95	Move all the MAFoo Resource calls to UCoreUtilities.
		 4/27/95	CFM-68K fixes to GetSegNumber and DoUnloadAllSegments. 
							Forget the LoadSeg patch. 
		04/19/95	skip a useless blockmove
		04/24/95	remove heap expansion and SetStackSpace to UniversalStartup
		 4/11/95	Fix SetResidentSegment to call PreloadSegmentResource instead
		 					of PreloadSegment for CFM-68K. 
		  4/8/95	Use size limits from limits.h instead of MacAppTypes. 
		03/27/95	Use LockHandle_AC instead of LockHandleHigh wherever possible. 
		03/13/95	Should count segments in seg! entries once and only once
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		02/22/95	1184041 Change NULL to NULL
		 2/20/95	Make PostLoadMacAppSegment non-static. 
		 2/19/95	Make extern "private" globals non-static. 
		02/13/95	make "p" (private) globals static 
		02/13/95	Remove unnecessary initialization of static variables. See ARM §8.4 
		02/08/95	1160119 Remove use of kNoStaticLink. 
		02/08/95	replace usage of staticLink with yourDataPtr. 
		02/07/95	Create missing prototypes for static functions used internally. 
		 1/25/94	Added StripAddress to GetSegNumber to correct calculation
							of the start and stop addresses for segment 1 in MW 68k.
		----- 3.5d3 Release -----
		12/13/94	Turn off code that doesn't work with -modelCFM. 
		12/12/94	Latest MW fix moves logic from DoInitUMemory to
							GetSegNumber where it makes more sense. 
		 12/8/94	Always make InitUMemory's segment resident. 
		 12/8/94	Some of the support should also work with CW 4.5. 
		 12/7/94	Add support for segmentation with CodeWarrior 5.0. 
		 11/9/94	Define qUseRTLib to control whether we use RTLib pre-
							and post-load functions or just patch LoadSeg. 
							Don't need to lock segments high under Metrowerks because
							they do it too. Fix GetSegNumber to test for Metrowerks
							first. 
		 11/7/94	Added qSegments. Treat CFM-68K like model far. 
		 11/2/94	Add support for unloading segments with Metrowerks 68K,
							as per Mark Anderson. 
		10/25/94	Initialize gObjectHeap to nil. 
		 7/20/94	Get rid of pragma R-. 
		 7/14/94	Find the 32-bit bootstrap segment by name instead of
							assuming it is the last segment. 
		 7/13/94	Add support for 'ppc!' and '68k!' resources (supplements
							to 'mem!'). 
		 6/20/94	Make the TrapPatch structure an object. 
*/