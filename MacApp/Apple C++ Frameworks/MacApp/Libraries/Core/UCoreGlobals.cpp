//----------------------------------------------------------------------------------------
// UCoreGlobals.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/03/00	[PB] Don't include Traps.h.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		09/01/00	qNeedsSystem7_5 eliminated.  Minimum system is not 8.1.
		02/22/00	[W] Do not call InitUMemory.  Fix ValidConfiguration.
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		10/21/99	Add support for System 8.5-only code.
		03/24/99	Update copyright notice.
*/

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UNIVERSALSTARTUP__
#include "UniversalStartup.h"
#endif

#ifndef __UPATCH__
#include "UPatch.h"
#endif

// Toolbox

#ifndef __FOLDERS__
#include <Folders.h>
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

#if !qProjectBuilder
	#ifndef __TRAPS__
	#include <Traps.h>
	#endif
#endif

// ANSI

#ifndef __STDIO__
#include <stdio.h>
#endif

#ifndef __STDLIB__
#include <stdlib.h>
#endif

//========================================================================================
// GLOBAL Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// ValidateConfiguration: 
//----------------------------------------------------------------------------------------


bool ValidateConfiguration()
{
	// Run the gauntlet of support tests using the conditionally set constants. If any
    // single test fails then the app is considered unsupported on this machine.
	bool isSupported = true;

#if !qMSWindows
	// Minimum system version (System 8.1)
	isSupported = GetSystemVersion_AC() >= 0x810;

	// Minimum QD type (color QD)
	isSupported = isSupported && HasColorQD_AC();

	// System 8.5 Support 
	if (qNeedsSystem8_5)
		isSupported = isSupported && GetSystemVersion_AC() >= 0x850;
#endif

	return isSupported;
}

//----------------------------------------------------------------------------------------
// MAGestaltAttribute: 
//----------------------------------------------------------------------------------------


bool MAGestaltAttribute(OSType itsAttr, short itsBit)
{
	long response;

	return Gestalt(itsAttr, &response) == noErr && (response >> itsBit) & 1;
	
}

//----------------------------------------------------------------------------------------
// MAHasGestalt: 
//----------------------------------------------------------------------------------------


bool MAHasGestalt(OSType itsGestalt)
{
	long response;

	return Gestalt(itsGestalt, &response) == noErr;

}


//----------------------------------------------------------------------------------------
// InitCoreMacApp
//----------------------------------------------------------------------------------------


void InitCoreMacApp(short callsToMoreMasters)
{
#if !qMSWindows
	// Install MacApp's Memory management system 
	InitUMemory(callsToMoreMasters);
#endif
}

#if !qMSWindows

//----------------------------------------------------------------------------------------
// FindProcessBySignature: 
//----------------------------------------------------------------------------------------

OSErr FindProcessBySignature(OSType sig,
							 ProcessSerialNumber& psn,
							 CFSSpec_AC* fileSpec)
{
	OSErr err;
	
	ProcessInfoRec info;

	psn.highLongOfPSN = 0;
	psn.lowLongOfPSN  = kNoProcess;
	do
	{
		err= GetNextProcess(&psn);
		if( err == noErr )
		{

			info.processInfoLength = sizeof(ProcessInfoRec);
			info.processName = NULL;
			info.processAppSpec = fileSpec;

			err= GetProcessInformation(&psn, &info);
		}
	} while ((err == noErr) && info.processSignature != sig);

	if (err == noErr)
		psn = info.processNumber;

	return err;
}

#endif

//----------------------------------------------------------------------------------------
// End of UCoreGlobals.cp



/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		 5/08/96	Create and use CFSSpec_AC. You should search/replace in your code to switch to
		 					CFSSpec_AC.
		----- R10 -----
		03/19/96	Correct #ifndefs that have trailing whitespace or comments
		 12/8/95	Split off from UMacAppGlobals. 
		  5/7/95	Add code to initialize and shutdown CALib. 
		  					Implement HasOpenDoc. 
		----- 3.3 -----
		 11/2/95	Change signature of TDrawingEnvironment from 'SRF2' to
							kStdDrawingEnvironment. 
		10/30/95	Fix bug in LaunchBySignature that caused failure if an audio CD was mounted.
		10/19/95	1293874 Removed HasASLM due to ASLM removal vs. deinstall problems.
		----- 3.3b1 -----
		09/01/95	CTemporaryRegion:: operator new comment size parameter.
		09/01/95	CTemporaryRegion::operator new returns nil.
		07/30/95	Added MAHasGestalt
		 7/28/95	Add configuration functions to use instead of gConfiguration. 
		 7/22/95	Take out the call to InitUScripting from DoInitUMacApp. 
		  7/7/95	Call PBGetVInfoSync instead of PBGetVInfo.
		 6/18/95	Remove gStandardWindowMoveBounds, gStandardWindowSizeRect and
		 					gStandardWindowScreenRect. Change usage of fMoveBounds and fResizeLimits
							to be used only if non-zero. Otherwise, values are dynamically calculated
							in the new functions: GetDynamicMoveBounds and GetDynamicResizeLimits.
							This is because monitor location, resolution and size is now dynamic since
							System 7.5.
		 5/17/95	#Include for USegments
		 6/12/95	Support TOSADispatcher::fgDispatcher
		 5/16/95	DialogRef
		 5/16/95	ControlRef, WindowRef
		  5/5/95	Test for qNeedsSystem7_5 in ValidateConfiguration
		 4/14/95	Load segment in LockSegment
		 4/24/95	remove heap expansion and SetStackSpace to UniversalStartup
		 3/20/95	Move all Universal code required to Vet the hardware together
		 					And reduce the "universal" code to a bare minimum
							Eliminate extern visibility of InitToolBox. 
		 					Changed CWLockSegment to LockSegmentLow and call it in all cases.
		  4/6/95	Add inclusion of <Errors.h> back.
		 3/30/95	Change old includes (GestaltEQU, OSEvents) to new equivalents. 
		 					Add hack to get around CFront problems with Traps.h. 
		 3/22/95	Comment out unnecessary includes. 
							Compatibility hacks for 2.0f1 headers. 
		 3/18/95	Include UDrawingEnvironment. 
		 3/17/95	Register a signature for TDrawingEnvironment. 
		 					Don't call SetEventMask to get key up events; this is now
							under the control of the application. 
		 3/15/95	Clear gApplication before freeing so nobody can 
							refer to the object while it is being destructed. 
		 3/10/95	Include Traps.h. 
		  3/9/95	Changed ClassDesc NewByXXX functions to return a void* 
							instead of a TObject*. 
		  3/6/95	Include UDialog.h.
		 2/28/95	Move gSignatures to be a member of ClassDesc. 
							Use MA_REGISTER_CLASS and MA_REGISTER_SIGNATURE instead of
							macroDontDeadStrip and RegisterStdType. 
		02/22/95	1222784 set various const usage globals to const attribute
		 2/21/95	Fix UPP definitions to work with OLDROUTINENAMES=0. 
		 					Use kUnresolvedCFragSymbolAddress. 
							Add compatibility hack so we can compile with the 1.0 headers. 
		02/20/95	Update for USESOLDROUTINENAMES=0. 
		 2/19/95	Undo change to ParseTitleTemplate -- windows came up without
		 					titles. 
		02/13/95	make "p" (private) globals static 
		02/13/95	Remove unnecessary initialization of static variables. See ARM §8.4 
		02/07/95	1143831 Allow empty window titles via ParseTitleTemplate. 
		02/07/95	Create missing prototypes for static functions used internally. 
		 1/26/95	Add hasAppleScript to configuration. 
		12/14/94	Fix backwards #if qModelCFM for call to unload _DataInit. 
		12/13/94	Turn off code that doesn't work with -modelCFM. 
		 12/8/94	Some of the support should also work with CW 4.5. 
		 12/7/94	Always define qd except under Metrowerks. This is
							the direction things are going and it works ok
							with the old libraries too. 
							Conditionalized Metrowerks support code that is
							needed only for CodeWarrior 4.5. 
		11/18/94	Conditionalize includes of Drag and OCEStandardMail. 
		11/17/94	Include Drag and OCEStandardMail. 
		11/17/94	Cast instances of kUnresolvedSymbolAddress to Ptr
							for compatibility w/pre-release headers.
		11/17/94	Fix CWLockSegment to not release the CODE resource.
							It may be in use. 
		11/14/94	We have to define qd for -modelCFM. 
		11/13/94	Call dontDeadStrip(TDragDropBehavior).
		11/11/94	Test for qPowerPC || qModelCFM. 
		11/11/94	Change qNeedsDrag to qDrag. Change qNeedsPowerTalk to
							qPowerTalk.  In PowerPC environment, we were verifying
							that routines that may exist in shared system libraries
							was present. We now test for qModelCFM.
		 11/9/94	Add MW fix to lock down Main. 
		 11/8/94	DefineConfiguration determines whether or not shared 
							libraries for Thread, AEOM, DragAndDrop are present
							on a PowerPC.  Added support for qNeedsDrag,
							qNeedsPowerTalk, and qNeedsThreads.
							This makes it safe to weak link these libraries and
							determine if they are present at runtime.
		 11/7/94	Added qSegments. 
		 11/2/94	Add mods to support unloading segments with Metrowerks
							68K, as per Mark Anderson. 
		10/27/94	Compile with ETO 15 prerelease headers. 
		10/21/94	Call InitUTEView so the performance monitor dialog
							will work. 
		 9/23/94	Add disposal of global TScriptEventDispatcher
							to CleanUpMacApp.  Support move of
							gMacAppAppleEventIdleProc to UScripting.
		 6/22/94	Add back patch to ExitToShell. 
		 5/26/94	Add cleanup proc. 
*/