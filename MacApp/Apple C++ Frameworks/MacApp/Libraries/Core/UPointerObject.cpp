//----------------------------------------------------------------------------------------
// UPointerObject.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/19/01	Use BlockZero_AC, instead of BlockSet_AC(,,0)
		03/01/01	Need to include CReporter_AC. 
		01/02/01	Update copyright.
		11/29/00	No need to include UClassDesc.h or UniversalStartup.h.
		11/29/00	[X] Use default malloc and free implementations.
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
		01/18/99	Moved in definition of gObjectHeap since it’s only used
					locally.
*/

#ifndef __UPOINTEROBJECT__
#include "UPointerObject.h"
#endif

#if TARGET_RT_MAC_MACHO

// ANSI

#ifndef __cstdlib__
#include <cstdlib>
#endif

#else

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

// ACS

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef _MEMMGR_
#include "MemMgr.h"
#endif

#if qDebug && !qMSWindows
	#ifndef __ThreadUtilities_AC__
	#include "ThreadUtilities_AC.h"
	#endif
#endif

// ANSI

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STDLIB_H
#include <stdlib.h>
#endif

//----------------------------------------------------------------------------------------
// Local declarations.
//----------------------------------------------------------------------------------------

MemoryHeap* gObjectHeap = NULL;	// Our own heap for object allocations.

#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// MAOperatorNew: 
//----------------------------------------------------------------------------------------

void* MAOperatorNew(size_t size)
{
#if TARGET_RT_MAC_MACHO
	// Use standard memory manager.
	void* blk = std::malloc(size);
#else
	// Use MacApp's custom memory manager.
#if qDebug && !qMSWindows
	// Verify we're not being called from an MP task.
	::AssertToolboxSafeMPTask_AC();
#endif
	// Create the default object heap the first time we are invoked. If the overloads
	// of operator new/delete are omitted this code will be omitted as well and the
	// development system's new/delete will be used instead.
	
	if (!gObjectHeap)
	{
		gObjectHeap = MMNewHeap(kMMAppMemory, (size_t)GetSizeObjectHeap(), (size_t)GetSizeHeapIncrement(),
				"Default MacApp Heap");

		// Set the default heap if none has been set yet
		if (!MMGetDefaultHeap())
			MMSetDefaultHeap(gObjectHeap);
	}
	
	void* blk = MMAllocateIn(size, gObjectHeap);
#endif
	::ThrowIfNULL_AC(blk);
#if qDebug
	BlockSet_AC(blk, size, 0x33); // enhanced bug finding
#else
	BlockZero_AC(blk, size); // enhanced stability
#endif
	return blk;
}

//----------------------------------------------------------------------------------------
// MAOperatorDelete: 
//----------------------------------------------------------------------------------------
void MAOperatorDelete(void* obj)
{
#if TARGET_RT_MAC_MACHO
	// Use standard memory manager.
	std::free(obj);
#else
	// Use MacApp's custom memory manager.
#if qDebug
	if (!gObjectHeap)
		::ProgramBreak_AC("operator delete invoked prior to gObjectHeap being created!");

	if (obj && ::Odd_AC(obj))
		::ProgramBreak_AC("In MAOperatorDelete: Not handed a valid object. NULL is ok but odd is not");

#if !qMSWindows
	// Verify we're not being called from an MP task.
	::AssertToolboxSafeMPTask_AC();
#endif
#endif

	MMFree(obj);
#endif
}

//----------------------------------------------------------------------------------------
// End of UPointerObject.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		05/21/96	Use accessors to retrieve globals in order to ensure initialization.
		 5/03/96	Removed all knowledge of the gObjectHeap to UPointerObject.cp/.h
		 5/03/96	Replace TObject* parameters with void* in preparation for
		 					removal of TObject ancestry. Removed FailNonObject, IsObject,
							VerboseIsObject as well
		 4/26/96	Made C/CCoordPoint_AC/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CCoordPoint_AC/Rects.
		 4/20/96	Put overloads of new/delete into separate file for ease of use/disuse
		----- R10 -----
		 2/13/96	Switch to MemHeap from ObjectHeap as part of upgrade to ODMemMgr

		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		----- 3.3b1 -----
		 8/10/95	Made IsPointer inline. 
		  7/5/95	Cosmetic. 
		03/07/95	1226587 MacApp has a SIZE_T, but should use size_t
		02/22/95	1184041 Change NULL to NULL
		02/07/95	Create missing prototypes for static functions used internally. 
		10/24/94	Add back global new and delete, but make
							it possible to turn them off. 
		10/19/94	Move operators new and delete to TObject. 
							Rename DoOperatorNew to MAOperatorNew. 
							Add MAOperatorDelete. 
*/