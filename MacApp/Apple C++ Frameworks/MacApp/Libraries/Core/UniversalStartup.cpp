//----------------------------------------------------------------------------------------
// UniversalStartup.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		06/07/01	Make 8.5 window manager calls conditional on qPowerPC. 
		06/06/01	Call InitFloatingWindows instead of InitWindows in InitToolBox.
					Strip dead code.
		05/07/01	Comment out pragma messages for Carbon. 
		05/02/01	Set gApplicationRefNum to LMGetCurApRefNum in InitToolBox.
		01/02/01	Update copyright.
		12/21/00	Include stdio to get stprintf. 
		11/28/00	Don’t MemBang if qCarbon.
		11/27/00	Always set gDidUniversalStartup in case the processor isn't 
					valid or UniversalStartup recurses. Separate getting the memory 
					configuration from expanding the heap, and make sure the
					accessors return the real configuration. 
		11/09/00	Remove undefined FailedInitToolBox. 
		11/06/00	[C] ExpandHeap not needed.
		10/23/00	InitToolBox was looking awfully complex so I broke it up
					into separate sections for each environment.  [C] Always valid
					in ValidateProcessor.  Do not include Traps.h and SegLoad.h.
		09/20/00	[W] Don't initialize QTML in InitToolBox when qCoreDebug.
		09/01/00	Changed pragma warning to pragma message.  Cosmetic cleanup.
					Stripped dead code.
		07/31/00	[W] Reworked initialization.
		03/02/00	Did some cleanup in InitToolBox to separate the Windows code out
					better and make the whole thing more readable.  Added a
					ThrowIfOSErr_AC around call to InitializeQTML.
		02/22/00	[W] Do not ExpandHeap in UniversalStartup.  Do not StripAddress in
					InitToolbox.  Use alternate technique for locating resource file
					in InitToolbox.
		11/11/99	Carbon: Allow use of ExpandHeap().
					Carbon: MaxApplZone isn't in Carbon.
		03/24/99	Update copyright notice.
		02/04/99	[C] Can’t use InitFonts, InitMenus, InitGraf, InitWindows, TEInit and InitDialogs.
		12/18/98	[W] Can’t call MaxApplZone in ExpandHeap.
		12/17/98	[W] Can’t use InitFonts, InitWindows, TEInit and InitDialogs.
		11/13/98	Carbon - don’t use StripAddress
		10/29/98	No longer need to include QTMLMapNames.h.
		10/26/98	Carbonize: no ExpandHeap, SetStackSpace
*/


#ifndef __UNIVERSALSTARTUP__
#include "UniversalStartup.h"
#endif

// MacApp

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UERRORMGR__
#include "UErrorMgr.h"
#endif

// QTML

#if qMSWindows
	#ifndef __QTML__
	#include <QTML.h>
	#endif
#endif

// Toolbox

#ifndef __DIALOGS__
#include <Dialogs.h>
#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#if !qCarbon
	#ifndef __TRAPS__
	#include <Traps.h>
	#endif
	
	#ifndef __SEGLOAD__
	#include <SegLoad.h>
	#endif
#endif

// ANSI

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STDLIB
#include <stdlib.h>
#endif

#ifndef _STDDEF
#include <stddef.h>
#endif

//••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••
// B E G I N   U N I V E R S A L   C O D E
//
// The following is universal code. That is, code that must be compiled to run on any
// processor. This is because this is the code that is called during startup, but after
// we've checked for PPC so this can be PPC code. This code will properly initialize the
// toolbox, thus an alert can be shown if necessary. It must not make any calls into code
// that is not "universal" code. 
//
//••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••

static bool gHasProcessMgr;				// saved from InitToolBox for configuration info
static bool gIsOnlyBackground;			// saved from InitToolBox for configuration info
static bool gIsHighLevelEventAware;		// saved from InitToolBox for configuration info
static short gProcessor;				// saved from ValidateHardware for configuration info
static bool gHasFPU;					// saved from ValidateHardware for configuration info

static Size gSizeObjectHeap;
static Size gSizeHeapIncrement;
static Size gSizeTempReserve;
static Size gSizeLowSpaceReserve;
static Size gStackTot;

//========================================================================================
// GLOBAL Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// ClearTheFPU: Essential one-time initialization
//
//	INLINE 0x42A7,										// CLR.L -(A7) 
//		   0x42A7,										// CLR.L -(A7) 
//		   0xF21F, 0x9800;								// FMOVEM (A7)+, FPCR/FPSR 
//----------------------------------------------------------------------------------------

#if q68K
static void ClearTheFPU() = { 0x42A7, 0x42A7, 0xF21F, 0x9800 };
#endif

static void InitToolBox();
//static void FailedInitToolBox();

#if !qCarbon
static void ExpandHeap();
static void SetStackSpace(long numBytes);
#endif
static void MemBang();

//----------------------------------------------------------------------------------------
// UniversalStartup
//----------------------------------------------------------------------------------------

void UniversalStartup()
{
	static bool gDidUniversalStartup;

	if (!gDidUniversalStartup)
	{
		gDidUniversalStartup = true; // Don't come back

		bool validProcessor = ValidateProcessor();

#if q68K
		// the main procedure is always compiled with universal code so, the FPU must be
		// reset before it is used. We could get spurious crashes or worse.
		//  Remember: 2 + 2 = 4... every time!
		if (gHasFPU)
			ClearTheFPU();
#endif

		InitToolBox();

		if (validProcessor)
		{
#if !qMSWindows && !qCarbon
			ExpandHeap();
#endif
		}
		else
			AlertUnsupportedConfiguration(); // exits, won't come back
	}
}

//----------------------------------------------------------------------------------------
// ValidateProcessor: 
//----------------------------------------------------------------------------------------

bool ValidateProcessor()
{
	bool isSupported = true;
	
#if !qMSWindows && !qCarbon
	// this is the first use of Gestalt. Ensure that gestalt is available.
	//
	if (TrapExists(_Gestalt))
	{
		long response;
		OSErr err = Gestalt(gestaltProcessorType, &response);
		gProcessor = static_cast<short>(response);
		
		err = Gestalt(gestaltFPUType, &response);
		gHasFPU = response != gestaltNoFPU;
	
	
		// Run the gauntlet of hardware support tests using the conditionally set constants. If any
	    // single test fails then the app is considered unsupported on this machine.
	
		if (qNeedsMC68020)
			isSupported = isSupported && (gProcessor != gestalt68000 &&
							gProcessor != gestalt68010);
	
		if (qNeedsMC68030)
			isSupported = isSupported && (gProcessor != gestalt68000 &&
							gProcessor != gestalt68010 &&
							gProcessor != gestalt68020);
	
		if (qNeedsMC68040)
			isSupported = isSupported && (gProcessor != gestalt68000 &&
							gProcessor != gestalt68010 &&
							gProcessor != gestalt68020 &&
							gProcessor != gestalt68030);
		
		if (qNeedsFPU)
			isSupported = isSupported && gHasFPU;
	}
	else
		isSupported = false;

#endif
	return isSupported;
}

//----------------------------------------------------------------------------------------
// UnsupportedConfiguration: 
//----------------------------------------------------------------------------------------

void AlertUnsupportedConfiguration()
{
	::BailOutAlert(phUnsupportedConfiguration);
}

//----------------------------------------------------------------------------------------
// InitToolBox: 
//----------------------------------------------------------------------------------------

void InitToolBox()
{
#if qCarbon
	// •-•-• Implementation of InitToolBox for Carbon.  •-•-•
	if (!gToolBoxInitialized)
	{		
		gToolBoxInitialized = true;

		// Check for process mgr then check for background only mode
		long response;
		OSErr err = Gestalt(gestaltOSAttr, &response);
		bool launchcontrol = ((response >> gestaltLaunchControl) & 1);
		gHasProcessMgr = true;				// save it for later
		ProcessSerialNumber psn;
		psn.highLongOfPSN = 0;
		psn.lowLongOfPSN = kCurrentProcess;
		
		ProcessInfoRec info;
		info.processInfoLength = sizeof(ProcessInfoRec);
		info.processName = NULL;
		info.processAppSpec = NULL;
		if (err == noErr && launchcontrol)
		{

			if (::GetProcessInformation(&psn, &info) == noErr)
			{
				gIsOnlyBackground = (info.processMode & modeOnlyBackground) != 0;
				gIsHighLevelEventAware = (info.processMode & modeHighLevelEventAware) != 0;
			}
		}

		gIsHighLevelEventAware = true;

		// _DON'T_ flush disk-inserted or os events or you'll be sorry! 
		::FlushEvents(everyEvent - diskMask - osMask, 0);

		// Are we background only?  Don't initialize the cursor if we are.
		if (!gIsOnlyBackground)
			::InitCursor();
		
		// The refnum where the application's resources should be found .
		// LMGetCurMap not supported in Carbon
		gApplicationRefNum = LMGetCurApRefNum();	// •••  Valid substitute?
		gCodeRefNum = LMGetCurApRefNum();	// Not necessarily the same as gApplicationRefNum under some IDE's
		// -1 == 0xFFFFFFFF, the largest 32 bit address. Our routine StripLong uses a
		// pre-stripped address gStrippedAddress to avoid the yucky MPW glue. 
		gStrippedAddress = (Ptr) -1;

		// This ends the Mac OS initialization code section.
	}
#elif !qMSWindows
	// •-•-• Implementation of InitToolBox for Mac OS 9. •-•-• 
	if (!gToolBoxInitialized)
	{		
		gToolBoxInitialized = true;

		// Check for process mgr then check for background only mode
		long response;
		bool trapexists = TrapExists(_Gestalt);
		OSErr err = Gestalt(gestaltOSAttr, &response);
		bool launchcontrol = ((response >> gestaltLaunchControl) & 1);
		gHasProcessMgr = true;				// save it for later
		ProcessSerialNumber psn;
		psn.highLongOfPSN = 0;
		psn.lowLongOfPSN = kCurrentProcess;
		
		ProcessInfoRec info;
		info.processInfoLength = sizeof(ProcessInfoRec);
		info.processName = NULL;
		info.processAppSpec = NULL;

		if (::GetProcessInformation(&psn, &info) == noErr)
		{
			gIsOnlyBackground = (info.processMode & modeOnlyBackground) != 0;
			gIsHighLevelEventAware = (info.processMode & modeHighLevelEventAware) != 0;
		}

		// init the toolbox managers
		::InitGraf(&qd.thePort);
	
		// Are we background only?
		if (gIsOnlyBackground)
			// _DON'T_ flush disk-inserted or os events or you'll be sorry! 
			::FlushEvents(everyEvent - diskMask - osMask, 0);
		else
		{
			::InitFonts();
#if qPowerPC
			if (HasWindowManager85_AC())
				::InitFloatingWindows();
			else
#endif
				::InitWindows(); 

			// _DON'T_ flush disk-inserted or os events or you'll be sorry! 
			::FlushEvents(everyEvent - diskMask - osMask, 0);
			
			::InitMenus();
			::TEInit();
			::InitDialogs(NULL);
			
			::InitCursor();
		}
		
		// The refnum where the application's resources should be found 
		gApplicationRefNum = LMGetCurApRefNum();	// We're no longer using IDEs that would have
													// different app resource and code resources.
		gCodeRefNum = LMGetCurApRefNum();	// Not necessarily the same as gApplicationRefNum under some IDE's
		// -1 == 0xFFFFFFFF, the largest 32 bit address. Our routine StripLong uses a
		// pre-stripped address gStrippedAddress to avoid the yucky MPW glue. 
		gStrippedAddress = StripAddress((Ptr) - 1);
	
		// This ends the Mac OS initialization code section.
	}
#else
	// •-•-• Implementation of InitToolBox for Windows. •-•-•
	if (!gToolBoxInitialized)
	{		
		gToolBoxInitialized = true;

	gIsOnlyBackground = false;
	gIsHighLevelEventAware = false;

#if !qCoreDebug
	// Initialize QTML except for qCoreDebug when this
	// will be done in dout initialization instead.
	OSErr err = InitializeQTML(0);
	if (err != noErr)
	{
		::MessageBox(HWND_DESKTOP, "QuickTime could not be initialized.  Be sure QuickTime for Windows 4.0 or later is installed on this computer.", "Error", MB_OK+MB_ICONINFORMATION);
		::ThrowIfOSErr_AC(err);
	}
#endif

	// _DON'T_ flush disk-inserted or os events or you'll be sorry! 
	::FlushEvents(everyEvent - diskMask - osMask, 0);

	::InitMenus();
	::InitCursor();

	char				myFileName[MAX_PATH];
	DWORD				myLength;

	// get the application's resource file, if it exists
	myLength = GetModuleFileName(NULL, myFileName, MAX_PATH);		// NULL means: the current process
	if (myLength != 0)
	{
		FSSpec			myFSSpec;
		NativePathNameToFSSpec(myFileName, &myFSSpec, 0L);
		gApplicationRefNum = FSpOpenResFile(&myFSSpec, fsRdPerm);

		// this is temporary to save having to run RezWack every build...
		if (gApplicationRefNum == -1)
		{
				// Change the path to the path of the resource fork for the app you are building..
#if qDebug
				NativePathNameToFSSpec("c:\\qtr\\BoAPPC14cw5_d.qtr", &myFSSpec, 0L);
				//NativePathNameToFSSpec("c:\\qtr\\DemoDialogs_ppc_d.qtr", &myFSSpec, 0L);
				//NativePathNameToFSSpec("c:\\qtr\\Nothing_ppc_d.qtr", &myFSSpec, 0L);
				//NativePathNameToFSSpec("c:\\qtr\\Skeleton_ppc_d.qtr", &myFSSpec, 0L);
#else
				NativePathNameToFSSpec("c:\\qtr\\BoAPPC14cw5_nd.qtr", &myFSSpec, 0L);
				//NativePathNameToFSSpec("c:\\qtr\\DemoDialogs_ppc_n.qtr", &myFSSpec, 0L);
				//NativePathNameToFSSpec("c:\\qtr\\Nothing_ppc_n.qtr", &myFSSpec, 0L);
				//NativePathNameToFSSpec("c:\\qtr\\Skeleton_ppc_n.qtr", &myFSSpec, 0L);
#endif
			gApplicationRefNum = FSpOpenResFile(&myFSSpec, fsRdPerm);
		}
		
		if (gApplicationRefNum != -1)
		{
			UseResFile(gApplicationRefNum);
		}
		else
		{
			char message[100];
			OSErr error = ::ResError();
			sprintf(message, "%d error", error);
			::MessageBox(HWND_DESKTOP,message,"Note",MB_OK+MB_ICONINFORMATION) ;
		}
	}

	// why is this even needed in Windows?
	gStrippedAddress = (Ptr) -1;
	gCodeRefNum = gApplicationRefNum;
	}
#endif
}

#if !qCarbon

//----------------------------------------------------------------------------------------
// ExpandHeap: 
//----------------------------------------------------------------------------------------

void ExpandHeap()
{
	// Expand the heap while preserving the requested stack space
	
	SetStackSpace(GetStackTot());

#if !qMSWindows
	::MaxApplZone();
#endif
}

#endif  // !qCarbon

#if !qCarbon

//----------------------------------------------------------------------------------------
// SetStackSpace: 
//----------------------------------------------------------------------------------------

void SetStackSpace(long numBytes)
{
	// Make sure numBytes is even (don't use the "odd" macro in case it outlines
	if (Odd_AC(numBytes))
		++numBytes;

#if !qMSWindows
	// ••• This needs to be reviewed for Windows.

	// Check that we aren't running with a corrupt heap. If we are,
	// fix the problem. This was a bug with FBA's before System 7.5.5.
	// With System Software later than 7.5.5, this "fix" is harmless.
	if (gIsOnlyBackground)
	{
		THz myZone = ::GetZone();
		if (myZone->bkLim != LMGetHeapEnd())
			LMSetHeapEnd(myZone->bkLim);
	}
	ptrdiff_t newLimit = reinterpret_cast<ptrdiff_t>(LMGetCurStackBase()) - numBytes;
	if (reinterpret_cast<ptrdiff_t>(::GetApplLimit()) > newLimit)
		::SetApplLimit((Ptr)newLimit);
#endif
}

#endif  // !qCarbon

//----------------------------------------------------------------------------------------
// MemBang: 
//----------------------------------------------------------------------------------------

void MemBang()
{
	// We can get called from static constructors, so call UniversalStartup
	// just in case. It has a recursion guard so it's safe. 

	UniversalStartup();

#if !qCarbon

	// Sum up the standard memory requirements
	// and add on the processor dependent memory requirements
#if qPowerPC
	const ResType memResType[2] = { 'mem!', 'ppc!' };
#elif q68K
	const ResType memResType[2] = { 'mem!', '68k!' };
#elif qMSWindows
	const ResType memResType[2] = { 'mem!', 'wn32' };
#endif
	
#if qDebug
	int checkMemResourceCount = 0;
#endif
	for (int whichType = 0; whichType < 2; ++whichType)
	{
		ResType whichResType = memResType[whichType];
		ResNumber rsrcCnt = ::CountResources(whichResType);
		for (ResNumber i = 1; i <= rsrcCnt; ++i)
		{
			Handle h = ::GetIndResource(whichResType, i);
#if qDebug
			if (GetHandleSize(h) != sizeof(Mem))
				DebugStr("\pI found a 'mem!' resource which is either corrupt or old style!");
#endif
			{
				const Mem &memH = **((MemHandle)h);
	
				gSizeObjectHeap += memH.objectHeap;
				gSizeHeapIncrement += memH.heapIncrement;
				gSizeTempReserve += memH.codeVal;
				gSizeLowSpaceReserve += memH.lowSpaceVal;
				gStackTot += memH.stackVal;
			}

#if qDebug
			++checkMemResourceCount;
#endif
			::ReleaseResource(h);
		}
	}

#if qDebug
	if (!checkMemResourceCount)
		DebugStr("\pCould not find any 'mem!' resources!");
#endif
	
	if (!gSizeObjectHeap && !gSizeHeapIncrement)
	{
#if qDebug
		DebugStr("\pFixing memory configuration!");
#endif
		gSizeObjectHeap = 32 * 1024;		// Pointer-based object allocation heap size (initial)
		gSizeHeapIncrement = 30 * 1024;		// Min size by which to grow object heap
		gSizeTempReserve = 6 * 1024;		// Add to temporary reserve (code reserve)
		gSizeLowSpaceReserve = 6 * 1024;	// Add to permanent reserve
		gStackTot = 32 * 1024;				// Base stack size. 
	}
#else
	// The Carbon settings.
	gSizeObjectHeap = 32 * 1024;		// Pointer-based object allocation heap size (initial)
	gSizeHeapIncrement = 30 * 1024;		// Min size by which to grow object heap
	gSizeTempReserve = 6 * 1024;		// Add to temporary reserve (code reserve)
	gSizeLowSpaceReserve = 6 * 1024;	// Add to permanent reserve
	gStackTot = 32 * 1024;				// Base stack size. 
#endif
}

//----------------------------------------------------------------------------------------
// Accessors: 
//----------------------------------------------------------------------------------------

Size GetSizeObjectHeap()
{
	if (!gSizeObjectHeap)
		MemBang();

	return gSizeObjectHeap;
}

Size GetSizeHeapIncrement()
{
	if (!gSizeHeapIncrement)
		MemBang();

	return gSizeHeapIncrement;
}

Size GetSizeTempReserve()
{
	if (!gSizeTempReserve)
		MemBang();

	return gSizeTempReserve;
}

Size GetSizeLowSpaceReserve()
{
	if (!gSizeLowSpaceReserve)
		MemBang();

	return gSizeLowSpaceReserve;
}

Size GetStackTot()
{
	if (!gStackTot)
		MemBang();

	return gStackTot;
}

bool GetHasProcessMgr()
{
	UniversalStartup();
	
	return gHasProcessMgr;
}

bool IsOnlyBackground()
{
	UniversalStartup();
	
	return gIsOnlyBackground;
}

bool IsHighLevelEventAware()
{
	UniversalStartup();
	
	return gIsHighLevelEventAware;
}

short GetProcessor()
{
	UniversalStartup();
	
	return gProcessor;
}

bool HasFPU()
{
	UniversalStartup();
	
	return gHasFPU;
}

//••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••
// E N D   U N I V E R S A L   C O D E
//••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••••

//----------------------------------------------------------------------------------------
// End of UniversalStartup.cpp


/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/25/96	[1345531] Added #include "SegLoad.h" && "stddef.h" for noload buids
		05/24/96	move gDidUniversalStartup to inside of UniversalStartup
		05/21/96	Replace calls to the ToolBox function ExitToShell with the standard C/C++ function exit.
							While eliminating another ToolBox dependency it also ensures static destructors get called.
		05/21/96	Use accessors to retrieve globals in order to ensure initialization.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		----- R10 -----
		03/30/96	Don't set the watchcursor on launch. Our launches are fast enough
							now that the user perception is better if the cursor doesn't change unless
							the app will be busy for a while, and then the cursor will change automatically
							with the busycursor unit.
		03/09/96	Keep LockSegment from causing the resource map to get modified.
		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		10/25/95	Changed ClearTheFPU to have direct inline of opcodes
							rather than FOURWORDINLINE.
		10/17/95	Removed obsolete use of __CW5__.
		10/12/95	Conditionalize #pragma processor 68000 on !qPowerPC.
		----- 3.3b1 -----
		09/05/95	Use FOURWORDINLINE macro for hex inlines.
		07/28/95	Update comments. 
		06/13/95	gCodeRefNum. 
		05/24/95	Include ErrorMgr.h, UCoreUtilities. 
							Change creator from MWorks to MPW
							Change toolbox include syntax to from "..." to <...>
*/