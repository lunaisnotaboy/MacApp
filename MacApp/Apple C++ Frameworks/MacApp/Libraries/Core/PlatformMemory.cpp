// PlatformMemory.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.

/*
	Change History
		01/02/01	Update copyright.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef PLATFORMMEMORY_H
#include "PlatformMemory.h"
#endif

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

// ANSI

//========================================================================================
// Global variable definitions
//========================================================================================

static bool pAllocateObjectsFromTemp = false;				// Used to track whether to
                                                            // allocate objects from
                                                            // temporary memory or not.

//----------------------------------------------------------------------------------------
// PlatformAllocateBlock
//----------------------------------------------------------------------------------------

Handle MAAllocateHandle(size_t size)
{
	bool heapTemp;
	if (gUMemoryInitialized)
		heapTemp = TemporaryAllocation(pAllocateObjectsFromTemp);

	Handle h = ::NewHandle(size);

	if (gUMemoryInitialized)
		TemporaryAllocation(heapTemp);		// Reset temp flag before possible Failure
	
	::ThrowIfNULL_AC(h);
		
	return h;
}

//----------------------------------------------------------------------------------------
// PLATFORM_ASSERT
//----------------------------------------------------------------------------------------


void PLATFORM_ASSERT(bool condition)
{
	if (!condition)
		::ProgramBreak_AC("Assertion failed.");
}

//----------------------------------------------------------------------------------------
// PLATFORM_PRINT_STRING
//----------------------------------------------------------------------------------------


void PLATFORM_PRINT_STRING(const char* string)
{
#if qDebugMsg
	ProgramReport_AC(string);
#else
	::ProgramBreak_AC(string);
#endif
}

//----------------------------------------------------------------------------------------
// GetTempObjectAllocationState: 
//----------------------------------------------------------------------------------------

bool GetTempObjectAllocationState()
{
	return pAllocateObjectsFromTemp;
}

//----------------------------------------------------------------------------------------
// TempObjectAllocation: 
//----------------------------------------------------------------------------------------

bool TempObjectAllocation(bool allocateFromTemp)
{
	bool previousState = pAllocateObjectsFromTemp;
	pAllocateObjectsFromTemp = allocateFromTemp;

	return previousState;
}

//----------------------------------------------------------------------------------------
// End of PlatformMemory.cp



/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		----- R10 -----
		 2/13/96	Switch to MemHeap from ObjectHeap as part of upgrade to ODMemMgr

		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		----- 3.3b1 -----
		 4/12/95	Change PLATFORM_PRINT_STRING to fo to the debugger for
		 					nodebug so we don't pull in printf. 
		03/07/95	1226587 MacApp has a SIZE_T, but should use size_t
		 11/9/94	Make print string non-inline. This way it is
							easier for different compilers to have their
							own implementations. Also made assert non-inline,
							this time to save memory. 
*/