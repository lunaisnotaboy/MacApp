// UCoreUtilities.h
// Copyright © 1984-2001 by Apple Computer. All rights reserved. 

/*
	Change History
		02/28/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		09/01/00	Simplified StripLong.
		06/14/00	Eliminated MASetResLoad.  Use CTempResLoad instead.
		03/16/00	Use EXPORT_CLASS_MA.
		11/03/99	GENERATINGCFM now TARGET_RT_MAC_CFM (3.2 and 3.3 compatible).
		03/24/99	Update copyright notice.
		10/28/98	[W] Don't compile GetTrapType for Windows.
		10/26/98	Carbonize - no GetTrapType in Carbon
*/

#ifndef __UCOREUTILITIES__
#define __UCOREUTILITIES__

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __Configuration_AC__
#include "Configuration_AC.h"
#endif

#ifndef __Debug_AC__
#include "Debug_AC.h"
#endif

#ifndef __ResFileUtils_AC__
#include "ResFileUtils_AC.h"
#endif

// ACS Includes for Forward/Exports

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

// MacApp

#ifndef __MACAPPTYPES__
#include "MacAppTypes.h"
#endif

#ifndef __UNIVERSALSTARTUP__
#include "UniversalStartup.h"
#endif

// Toolbox

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

typedef void(* DoWithResFileType)(void* scopeLink);

//----------------------------------------------------------------------------------------
// Global constants declarations. Build options.
//----------------------------------------------------------------------------------------

EXPORT_MA extern const char* kCopyright;

//----------------------------------------------------------------------------------------
// Global variable declarations.
//----------------------------------------------------------------------------------------

EXPORT_MA extern  short gApplicationRefNum;

EXPORT_MA extern  short gCodeRefNum; 
	// Reference to where to find code segments (note this is the application
	// for PowerPCs)

EXPORT_MA extern  bool gToolBoxInitialized;

EXPORT_MA extern  bool gUMemoryInitialized;

EXPORT_MA extern  Ptr gStrippedAddress;

//----------------------------------------------------------------------------------------
// Global assembly inline function definitions.
//----------------------------------------------------------------------------------------

#if !qPowerPC && !qMSWindows
#ifdef __MWERKS__
	#pragma d0_pointers on
#endif

long GetParmBlockPtr() = {0x2008};				// MOVE.L A0,D0
												// Return the value of register A0.
												// Useful for getting the pointer
												// to the parameter block from a
												// VBL task or a completion routine.

long GetA5() = {0x200D};						// MOVE.L A5,D0
												// Return the value of register A5.
												// Useful for getting the immediate
												// value of A5 which is not always
												// the same as CurrentA5.  Generally
												// a pointer to the program's global
												// area and jump table.	

#if qDebug
Ptr GetCurStackFramePtr() = {0x200E};			// MOVE.L A6,D0
												// Return the value of register A6.
												// Usually a pointer to the local
												// stack frame.  Most often used to
												// find out the caller's name when
												// invoking a debugging routine.
	
Ptr GetCurStackTop() = {0x200F};				// MOVE.L A7,D0
												// Return the value of register A7.
												// Usually the top of the stack.
												// Useful for stack sniffing (not
												// a crime).
#endif

#ifdef __MWERKS__
	#pragma d0_pointers reset
#endif
#endif

//----------------------------------------------------------------------------------------
// Global function declarations that need to always be compiled for 68000.
//----------------------------------------------------------------------------------------

#if	!qMSWindows && !qCarbon
EXPORT_MA TrapType GetTrapType(short theTrap);
#endif

EXPORT_MA bool TrapExists(short theTrap);

//----------------------------------------------------------------------------------------
// Global function declarations
//----------------------------------------------------------------------------------------

#if TARGET_RT_MAC_CFM
#define DisposeIfRoutineDescriptor(p) ((p) ? (DisposeRoutineDescriptor(p), (UniversalProcPtr)nil) : (UniversalProcPtr)nil)
#else
#define DisposeIfRoutineDescriptor(p) NULL
#endif

EXPORT_MA bool EqualBlocks(const void* first, const void* second, size_t theSize);

inline bool IsHandlePurged(Handle h) { return (!*h); }

inline SignedByte LockHandleHigh(Handle h) { return LockHandle_AC(h, eMoveHi); }

inline long StripLong(void* address) { return reinterpret_cast<long>(address); }

EXPORT_MA unsigned char UprChar(unsigned char ch, short inScript = smCurrentScript);

EXPORT_MA void UprStr255(CStr255_AC& s, short inScript = smCurrentScript);

EXPORT_MA void UprMAName(MAName& s, short inScript = smCurrentScript);

EXPORT_MA unsigned char LowerChar(unsigned char ch, short inScript = smCurrentScript);

EXPORT_MA void LowerStr255(CStr255_AC& s, short inScript = smCurrentScript);

EXPORT_MA void UseROMMap(bool resLoad);

#if qDebug
inline bool VerboseIsHandle(Handle h) { return VerboseIsHandle_AC(h); }

EXPORT_MA void WriteHandleContents(Handle theHandle);

EXPORT_MA void WrLblHandleContents(const CStr255_AC& aLabel, Handle theHandle);
								
EXPORT_MA void WritePtr(void* val);

EXPORT_MA void WrLblPtr(const CStr255_AC& aLabel, void* val);

EXPORT_MA void WriteBoolean(bool b);

EXPORT_MA void WrLblBoolean(const CStr255_AC& aLabel, bool b);

EXPORT_MA void WriteSig(IDType theID);

EXPORT_MA void WrLblSig(const CStr255_AC& theLabel, IDType theID);

EXPORT_MA void WriteHexInt(short theInt);

EXPORT_MA void WrLblHexInt(const CStr255_AC& theLabel, short theInt);

EXPORT_MA void WriteHexLongint(long theLongint);

EXPORT_MA void WrLblHexLongint(const CStr255_AC& theLabel, long theLongint);
#endif

//	These "MAFoo" functions were originally for THINKª Pascal compatibility (but useful in the larger
//	problem of multiple open resource maps in general); when running under the THINKª environment,
//	CODE resources are not found in the same resource file as other application resources, so a
//	UseResFile call needs to be made to bring the project resource file into the search path.
//	"gCodeRefNum" is set up at initialization time.
//	!!! A much more general solution to "the resource problem" appears to be warranted.

EXPORT_MA void WithCodeResFileDo(DoWithResFileType DoWithResFile, void* yourDataPtr);
	// Ensure that the resource call is done against gCodeRefNum
	
EXPORT_MA void MAAddResource(Handle theData, ResType theType, short theID, const CStr255_AC& name, short inDesiredScript = smCurrentScript);

EXPORT_MA Handle MAGetResource(ResType rType, short rID, short inDesiredScript = smCurrentScript);

EXPORT_MA Handle MAGet1Resource(ResType rType, short rID, short inDesiredScript = smCurrentScript);

EXPORT_MA Handle MAGetNamedResource(ResType rType, const CStr255_AC& name);
								 
EXPORT_MA Handle MAGet1NamedResource(ResType rType, const CStr255_AC& name);

EXPORT_MA short MACountResources(ResType rType);

EXPORT_MA short MACount1Resources(ResType rType);

EXPORT_MA Handle MAGetIndResource(ResType rType, short index);

EXPORT_MA Handle MAGet1IndResource(ResType rType, short index);

EXPORT_MA /*const*/ CStr255_AC* MANewStringPtr(const CStr255_AC& fromString);
	// Allocates a heap block just big enough to contain the string,
	// or returns NULL if the string is empty. Returned string can be modified,
	// but it is not safe to increase its length. 

EXPORT_MA CStr255_AC MAEvalStringPtr(const CStr255_AC* fromString);
	// Returns a copy of the string pointed to, or an empty
	// string if the pointer is NULL. 

//----------------------------------------------------------------------------------------
// MacApp emulation of auto_ptr that uses operator delete
//----------------------------------------------------------------------------------------
#define __MEMBER_TEMPLATES__ 0

template <class T> class stl_operator_delete_auto_ptr
{
public:
	/* explicit */ stl_operator_delete_auto_ptr(T* p = NULL) : pointee(p) { }
	~stl_operator_delete_auto_ptr() { operator delete(get()); }

#if FALSE && __MEMBER_TEMPLATES__
	template <class U> stl_operator_delete_auto_ptr(const stl_operator_delete_auto_ptr<U>& rhs) : pointee(rhs.release()) { }

	template <class U> stl_operator_delete_auto_ptr &operator=(const stl_operator_delete_auto_ptr<U>& rhs) { if (pointee != rhs.pointee) reset(rhs.release()); return *this; }
#else
	stl_operator_delete_auto_ptr(const stl_operator_delete_auto_ptr& rhs) : pointee(rhs.release()) { }

	stl_operator_delete_auto_ptr& operator=(const stl_operator_delete_auto_ptr& rhs) { if (pointee != rhs.pointee) reset(rhs.release()); return *this; }
#endif

	T& operator*() const { return *get(); }

	T* operator->() const { return get(); }

	T* get() const { return pointee; }

	T* release() const { T* oldPointee = pointee; const_cast<stl_operator_delete_auto_ptr*>(this)->pointee = NULL; return oldPointee; }

	void reset(T* p = NULL) { if (pointee != p) { operator delete(get()); pointee = p; } }

protected:
	T* pointee;
};

// MA_operator_delete_auto_ptr adds assignment and coercion operators
template <class T> class MA_operator_delete_auto_ptr : public stl_operator_delete_auto_ptr<T>
{
public:
	typedef T* TPtr;

	/* explicit */ MA_operator_delete_auto_ptr(T* p = NULL) : stl_operator_delete_auto_ptr<T>(p) { }
	~MA_operator_delete_auto_ptr() { }

#if FALSE && __MEMBER_TEMPLATES__
	template <class U> MA_operator_delete_auto_ptr(const MA_operator_delete_auto_ptr<U>& rhs) : stl_operator_delete_auto_ptr<T>(rhs.release()) { }

	template <class U> MA_operator_delete_auto_ptr &operator=(const MA_operator_delete_auto_ptr<U>& rhs) { if (pointee != rhs.pointee) reset(rhs.release()); return *this; }
#else
	MA_operator_delete_auto_ptr(const MA_operator_delete_auto_ptr& rhs) : stl_operator_delete_auto_ptr<T>(rhs.release()) { }

	MA_operator_delete_auto_ptr& operator=(const MA_operator_delete_auto_ptr& rhs) { if (pointee != rhs.pointee) reset(rhs.release()); return *this; }
#endif

	MA_operator_delete_auto_ptr& operator=(T* rhs) { pointee = rhs; return *this; }

	operator T*() const { return get(); }
};

#define SubClassResponsibility SubClassResponsibility_AC
	// Called from functions that MUST be overridden in a subclass.

//----------------------------------------------------------------------------------------
// ACS Symbols that must be exported by MacApp.
//----------------------------------------------------------------------------------------

EXPORT_CLASS_MA(CAutoPtr_AC<CList_AC>)
EXPORT_CLASS_MA(CAutoPtr_AC<CSortedList_AC>)

#endif // __UCOREUTILITIES__

/*
	Historical Change Record:
		----- R13 -----
		06/22/97	Minor changes for .
		06/22/97	Minor changes for VC++. (qMSWindows condition, static to reinterpret_cast)
		06/05/97	EXPORT_AC, EXPORT_MA, no-load fixes, Memory_AC, Windows_AC, no CW11orLATER, removed segmentation, etc...
		04/14/97	Update for real xxx_cast operators.
		04/09/97	In stl_operator_delete_auto_ptr:
							made copy constructor argument const, made release const, made
							assignment (from stl_operator_delete_auto_ptr) operator argument const.
		03/25/97	AC_ to _AC Name change.
		03/20/97	Removed include for BlockMove_AC.h.
		03/17/97	Updated IsHandlePurged for the debug case.
		03/11/97	Fix CW11 errors.
		03/07/97	Massive Changes: Use Exceptions_AC, new to TH_new, use Blah_AC,
							Update Copyright, Moved Obsolete APIs into Compatibility.h, etc..
		03/07/97	Moved a bunch of stuff to Compatibility.h.
		03/04/97	Removed dependency on algobase.h by using Utils_AC.h min and max.
		01/28/97	Moved MacApp casting operator macros here and defined them as (almost) same as those
							in Utils_AC.h
		01/25/97	Switch Min_AC, Max and MinMax to use min/max/minmax templates for their implementations.
		01/20/97	Added conditional for system 7.6 (allows elimination of 24-32 conversion on 68k.
		12/18/96	Split out elements to ACS.
		09/20/96	Make EqualBlocks take void* parameters
		08/10/96	Fixed -noload compiles, made more datamembers auto_ptrs, FreeIfObject->delete
		08/07/96	Goodbye TObject!
		07/17/96	Enhance all CTempxxx classes to work better with native exceptions. Added
							MA_operator_delete_auto_ptr for auto_ptr's that use operator delete.
		07/16/96	Goodbye MAVirtual
		07/16/96	Goodbye MDestructo
		07/16/96	Now include UExceptions.h instead of UFailure.h
		07/15/96	Boolean->bool
		07/15/96	Boolean->bool for global/non-virtual functions/variables parm/results that won't affect developers
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/24/96	BlockSet should take a void*
		06/21/96	[1117870] (2-BYTE) TTEView and Left&Right Arrow
							[1115111] (2-BYTE) TTEView::GetNumberOfChars returns 0 after 1 character has been typed
							[1353017] (Double-byte) Second Character Lost
		05/21/96	Use accessors to retrieve globals in order to ensure initialization.
		 5/09/96	Added CopyHandle: a better HandToHand replacement. And created
		 					PermCopyHandle a better PermHandToHand.
		05/07/96	Use enums for parameters of CTempHandleLock_AC constructor.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/24/96	No need for overloads of operator new for classes that derive from MDestructo.
							It takes care of that itself.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Moved all the CTempxxx classes to UCoreUtilities
		----- R10 -----
		04/10/96	Change Wr[Lbl]Ptr to take a void*
		03/26/96	put #if qDebug around the WrLblxxx calls and IsFreeHandle/IsHandle/Verbosexxx diagnostics.
							Inlined MinMax.
		03/07/96	put #pragma d0_pointers on around _ALL_ the inline 68K assembly
		03/05/96	[1326221] Move HasDragManager, HasAOCEToolBox here
		02/15/96	[1184448] Add HasQuickDraw3D, HasQuickDraw3DViewer,
							HasAppleGuide.	Change Copyright to 1996.
		12/13/95	Add back upper/lower string utilities. 
		 12/8/95	Split off from UMacAppUtilities. 
		  5/7/95	Add HasOpenDoc. 
		----- 3.3 -----
		11/01/95	MAInteractWithUser calls gApplication->InteractWithUser (used
							to work the other way).
							Include "UDispatcher.h"
		10/31/95	Add MACurResFile, Fix MAUseResFile to avoid unnecessary UseResFile calls.
		10/25/95	CFM doesn't handle INLINE macros very well so have to inline
							the opcodes directly.  See GetA5.
		10/19/95	1293874 Removed HasASLM due to ASLM removal vs. deinstall problems.
		10/03/95	1154871 Add IsCapsLockKeyDown
		----- 3.3b1 -----
		09/05/95	Use ONEWORDINLINE macro for hex inlines.
		  8/2/95	Add ShowGlobalRegion, ShowViewRegion. Forward define TClass.
		 7/28/95	Add configuration functions to use instead of gConfiguration. 
		 7/18/95	PRAGMA_ALIGN_SUPPORTED. 
		 6/13/95	Change DisposeIfRoutineDescriptor to a macro so it will
		 					work with all types of UPPs. 
		 5/23/95	Make several functions inline esp. when they are simple
							wrapper functions.
		 5/18/95	Added MASetResLoad
		 5/16/95	WindowRef
		05/04/95	Move all the MAFoo Resource calls to UCoreUtilities.
		  4/8/95	Add LockHandle_AC. 
		 3/15/95	PowerPC NOP version of StripLong should cast to long. 
		03/14/95	1153499	(SPEED) StripLong() can be inline/macro
		 3/3/95		GSF		Add StreamToHandle.
		02/22/95	1222784 set various const usage globals to const attribute
		02/22/95	1185932 add kBestSystemLocation for -1,-1 window locations
		02/07/95	1202992 Fix structure alignment for PPC. 
		 2/17/95	Add MAAddResource. 
		11/17/94	Remove include of UScripting (was commented out). 
		 11/2/94	Add pragmas for Metrowerks as per Mark Anderson. 
		 9/22/94	Added include of "UScripting.h"
		 7/18/94	Move GetRandom here from UScriptableObject (as per
							Ken Ryall). 
*/