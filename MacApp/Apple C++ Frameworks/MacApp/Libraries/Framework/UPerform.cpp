//----------------------------------------------------------------------------------------
// UPerform.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		03/24/99	Update copyright notice.
*/

#ifndef __UPERFORM__
#include "UPerform.h"
#endif

// MacApp

#ifndef __UDIALOG__
#include "UDialog.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UNUMBERTEXT__
#include "UNumberText.h"
#endif

#ifndef __UCHECKBOX__
#include "UCheckbox.h"
#endif

#ifndef __UEDITTEXT__
#include "UEditText.h"
#endif

// Toolbox

// ANSI

#ifndef __STDIO__
#include <stdio.h>
#endif

// Apple Specials
	
#if qPerform
	#ifndef __PERF__
	#include "Perf.h"
	#endif
#endif

//----------------------------------------------------------------------------------------
// Static variable definitions.
//----------------------------------------------------------------------------------------

#if qPerform

static TP2PerfGlobals pTP2PerfGlobals;			// Pointer to performance globals record
                                                // Non-nil if tools are inited

static bool pPerfMonitorEnabled;				// Is the performance monitor enabled or
                                                // disabled.
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================
#if qPerform

//----------------------------------------------------------------------------------------
// PerfMonitorInitiated: Are we currently doing performance monitoring.
//----------------------------------------------------------------------------------------
bool PerfMonitorInitiated()
{
	return pTP2PerfGlobals != NULL;
}


//----------------------------------------------------------------------------------------
// InitiatePerfMonitor: Initiate performance monitoring from the initialize performance
// monitor dialog box.
//----------------------------------------------------------------------------------------
void InitiatePerfMonitor(TWindow* aWindow)
{
#if q68K
	bool aBool;
	
	short timerCount = static_cast<short>(dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('tmct'))->GetValue());
	short codeAndROMBucketSize = static_cast<short>(dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('cbsz'))->GetValue());
	bool doROM = dynamic_cast_or_throw_AC(TCheckBox*,aWindow->FindSubView('mrcd'))->IsOn();
	bool doAppCode = dynamic_cast_or_throw_AC(TCheckBox*,aWindow->FindSubView('macd'))->IsOn();
	CStr255_AC appCodeType;
	dynamic_cast_or_throw_AC(TEditText*,aWindow->FindSubView('acrs'))->GetText(appCodeType);
	short romID = static_cast<short>(dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('rmid'))->GetValue());
	CStr255_AC romName;
	dynamic_cast_or_throw_AC(TEditText*,aWindow->FindSubView('rmnm'))->GetText(romName);
	bool doRAM = dynamic_cast_or_throw_AC(TCheckBox*,aWindow->FindSubView('mout'))->IsOn();
	long ramLow = dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('from'))->GetValue();
	long ramHigh = dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('to  '))->GetValue();
	short ramBucketSize = static_cast<short>(dynamic_cast_or_throw_AC(TNumberText*,aWindow->FindSubView('otsz'))->GetValue());
		
	aBool = InitPerf(&pTP2PerfGlobals, timerCount, codeAndROMBucketSize, doROM, doAppCode,
					 appCodeType, romID, romName, doRAM, ramLow, ramHigh, ramBucketSize);
	
	if (!aBool)
		pTP2PerfGlobals = NULL;
	else
		EnablePerfMonitor(true);
#else
	pTP2PerfGlobals = NULL;
#endif
}


//----------------------------------------------------------------------------------------
// DumpPerfMonitor:
//----------------------------------------------------------------------------------------
void DumpPerfMonitor(const CFSSpec_AC& fileSpec)
{
#if q68K
	if (pTP2PerfGlobals)
	{
		// Create a TFile to get the pathname.
		
		TFile aFile(kTextType_AC, 'MPS ', kUsesDataFork, noResourceFork, kDataOpen, !kRsrcOpen);
		aFile.Specify(fileSpec);

		CStr255_AC pathName;
		aFile.GetPathName(pathName);

		PerfDump(pTP2PerfGlobals, pathName + (const CStr255_AC&) fileSpec.name, true, 80);
	}
#endif
}


//----------------------------------------------------------------------------------------
// EnablePerfMonitor: Enable or disable performance monitoring, assuming already its
// initiated.
//----------------------------------------------------------------------------------------
void EnablePerfMonitor(const bool enable)
{
#if q68K
	if (pTP2PerfGlobals && enable != pPerfMonitorEnabled)
	{
		PerfControl(pTP2PerfGlobals, enable);
		pPerfMonitorEnabled = enable;
	}
#endif
}


//----------------------------------------------------------------------------------------
// PerfMonitorEnabled: Is the performance monitor enabled?
//----------------------------------------------------------------------------------------
bool PerfMonitorEnabled()
{
	return pPerfMonitorEnabled;
}


//----------------------------------------------------------------------------------------
// TerminatePerfMonitor: Shut down the performance monitoring tools.
//----------------------------------------------------------------------------------------
void TerminatePerfMonitor()
{
#if q68K
	if (pTP2PerfGlobals)
	{
		TermPerf(pTP2PerfGlobals);
		pTP2PerfGlobals = NULL;
	}
#else
	pTP2PerfGlobals = NULL;
#endif
}

#endif	// qPerform

//----------------------------------------------------------------------------------------
// DebugTerminate:
//----------------------------------------------------------------------------------------
#if qDebug

void DebugTerminate()
{
#if qPerform
	// Make sure the performance tools are shut down if they are initialized 
	if (pTP2PerfGlobals)
		TerminatePerfMonitor();
#endif
}

#endif	// qDebug

//----------------------------------------------------------------------------------------
// End of UPerform.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		05/08/96	Create and use CFSSpec_AC. You should search/replace in your code to switch to
		 					CFSSpec_AC.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		----- R10 -----
		11/29/95	Move performance monitor dialog from UDebug to UPerform. 
		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		11/04/95	1299300	(Build -nocplusload) Missing includes
		11/04/95	SADE, SourceBug and VoodooMonkey. 
		11/02/95	Add qDebug tracking of segments in memory at max resource usage.
		10/30/95	TotalTempSize is now a method of CGrowZoneHook. 
		10/19/95	Use SysBreakFunc only with Jasik's -- not with any other
							debuggers. 
		10/18/95	Use SysBreakFunc with Jasik's. 
		10/17/95	1288845	(Segments) gCodeSegs treated as a handle
		10/17/95	Remove includes not needed with Metrowerks. 
		10/06/95	Simplify debug output code. 
							Split output on new lines. 
		09/19/95	Split off Jasik's The Debugger support to its own unit. 
		10/12/995	GSF		Add back includes of FCntl.h, IOCtl.h, DisAsmLookup.h
							for non-CW builds.
	    10/10/95	pDebuggerProcess wasn't defined if qDebug was false, but
	    					qTheDebugger was true.
		10/04/95	Include CWMacAppFCntl.h, CWMacAppIOCtl.h
		 					Remove includes of FCntl.h, IOCtl.h, DisAsmLookup.h
		----- 3.3b1 -----
		08/31/95	Incorporate Jasik's modified TheDbgr_Adjust_ClassDescr_Ids.
		07/18/95	PRAGMA_ALIGN_SUPPORTED. 
		07/11/95	TWB's CW debugging fixes.
		07/07/95	CW6 Update.
		06/18/95	CheckRsrcUsage is not conditioned on #qDebug anymore. It is
							conditioned internally by gCheckRsrcUsage. 
		05/17/95	#Include for USegments
		05/16/95	Remove support for pre-system 7. 
		05/05/95	Use a structure to hold code seg info
		04/08/95	Don't need to take address of functions. 
		04/04/95	Update support for The Debugger. 
		03/30/95	Include UDialog and UWindow for qPerform. 
		03/21/95	Don't include Unmangler with Rainbow. 
		03/06/96	Include UCoreGlobals.h
		02/27/95	Move view to UDebugView. Move don't dead strip of TDebugFlagsView
		 					to UApplication. 
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		02/22/95	1184041 Change NULL to NULL
		02/13/95	Remove unnecessary initialization of static variables. See ARM §8.4 
		02/08/95	replace usage of staticLink with yourDataPtr. 
		02/07/95	Create missing prototypes for static functions used internally. 
		12/15/94	Close and reopen standard I/O around the call to
							_addDevHandler. Required to work safely with both
							the new and old versions of console I/O support in
							StdCLib. 
		12/07/94	Add support for debug output with CodeWarrior 5.0. 
		11/09/94	Metrowerks now supports _addDevHandler. 
		11/07/94	Added qSegments. 
		10/05/94	Put back includes of FCntl and IOCtl. 
		07/12/94	Don't use _addDevHandler with Metrowerks. 
		07/12/94	Change the constructor CStackFrame(long framePtr = 1)
							to CStackFrame() so it doesn't conflict with
							CStackFrame(ptrdiff_t);
*/