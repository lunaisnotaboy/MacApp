//----------------------------------------------------------------------------------------
// UEventHandler.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/11/00	Fixed inconsistency in how NextIdle and HandleIdle treated
					fLastIdle, which gave a sleep time of 0 for large values of 
					fIdleFreq. Now SetIdleFreq sets fLastIdle to now, and NextIdle
					always returns fLastIdle + fIdleFreq. 
		11/10/00	Cosmetic.
		09/06/00	Added embedded documentation.
		06/14/00	Eliminated GetRegionCode.
		05/23/00	[2279264] Remove false from ProgramReport_AC.
		12/08/99	Scope DeleteCommand in PostCommand.
		03/24/99	Update copyright notice.
		03/19/99	Rename GetMessage to GetEventMessage
					since it conflicts with a Windows define.
		11/12/98	[2279244] Replaced dynamic_cast with dynamic_cast_AC.
		10/08/98	Add DeleteEvent.
					Undo handler's Abort method now deletes all the commands in the
					transaction. This prevents a leak of the other commands.
					Change FindTransaction to Contains.
					PerformCommand and PerformCommandAppleEvent are now static
					functions in TCommand.
					Undo context.
					Simplify PostCommand.
					Merge TCommandHandler into TEventHandler.
					Remove PostAnEvent.
*/

#ifndef __UEVENTHANDLER__
#include "UEventHandler.h"
#endif

// MacApp

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __UCOMMAND__
#include "UCommand.h"
#endif

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UEVENT__
#include "UEvent.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#if qAppleEventAware
	#ifndef __USCRIPTING__
	#include "UScripting.h"
	#endif
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UUNDO__
#include "UUndo.h"
#endif

// Toolbox

#ifndef __RESOURCES__
#include <Resources.h>
#endif

// ANSI

#ifndef __STDLIB__
#include <stdlib.h>
#endif

//----------------------------------------------------------------------------------------
// static data members
//----------------------------------------------------------------------------------------

CPoint_AC		TEventHandler::fgStdHysteresis(4, 4);
TEventHandler*	TEventHandler::fgTarget;

//========================================================================================
// CLASS CHandlerIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CHandlerIterator::Reset:
//----------------------------------------------------------------------------------------

CHandlerIterator::CHandlerIterator(const TEventHandler* chainHead)
	:	fCurrent(NULL),
		fFirstHandler(NULL),
		fNextHandler(NULL)
// CHandlerIterator initializes this iterator object to iterate over the specified
// chain of event handlers.
//
// chainHead:	specifies a pointer to the head of the chain of event handlers
// 				for this iteration.
//
// Call?		As needed.
// Override?	Seldom.
{
	fFirstHandler = chainHead;

	First();
}

//----------------------------------------------------------------------------------------
// CHandlerIterator::First:
//----------------------------------------------------------------------------------------

TEventHandler* CHandlerIterator::First()
{
	fCurrent = const_cast<TEventHandler*>(fFirstHandler);
	if (fFirstHandler)
		fNextHandler = fFirstHandler->GetNextHandler();

	return fCurrent;
}

//----------------------------------------------------------------------------------------
// CHandlerIterator::Next:
//----------------------------------------------------------------------------------------

TEventHandler* CHandlerIterator::Next()
{
	if (fCurrent)
	{
		fCurrent = fNextHandler;
		if (fCurrent)
			fNextHandler = fCurrent->GetNextHandler();
	}

	return fCurrent;
}

//========================================================================================
// CLASS TEventHandler
//========================================================================================

MA_DEFINE_CLASS(TEventHandler);

//----------------------------------------------------------------------------------------
// TEventHandler constructor
//----------------------------------------------------------------------------------------

TEventHandler::TEventHandler(TEventHandler* itsNextHandler) :
	fNextHandler(itsNextHandler),
	fIdentifier(kNoIdentifier),
	fIdleFreq(kMaxIdleTime),
	// Assume it never wants idle time
	fLastIdle(0),
	fEnabled(true)								// Default to taking events
{
}

//----------------------------------------------------------------------------------------
// TEventHandler::BecameWindowTarget:
//----------------------------------------------------------------------------------------

void TEventHandler::BecameWindowTarget()
// BecameWindowTarget is intended to perform the required actions when a window
// becomes the current target. TEventHandler::BecameWindowTarget does not specify any actions.
//
// Call?		Seldom.
// Override?	As needed; for example, to highlight a selection
//				in a view.
{
}

//----------------------------------------------------------------------------------------
// TEventHandler::BecameTarget:
//----------------------------------------------------------------------------------------

void TEventHandler::BecameTarget()
// BecameTarget is intended to perform required actions after this object
// becomes the application’s target. TEventHandler::BecameTarget notifies
// its successors in the target chain that this event handler has become the
// target, which allows other event handlers to adjust their targets if necessary.
//
// Call?		Seldom.
// Override?	As needed, to perform required actions such as
//				activating a window. Your override method must
// 				call its inherited BecameTarget.
{
	HandleEvent(mBecameTarget, this, NULL);
}

//----------------------------------------------------------------------------------------
// TEventHandler::BecomeTarget:
//----------------------------------------------------------------------------------------

bool TEventHandler::BecomeTarget()
// BecomeTarget makes this object be the current target. The method returns
// true if the object did become the target, or false if the old target did not
// resign. For example, a dialog box that contains invalid data might not resign.
//
// Call?		As needed, if you want to set the target programatically
//				rather than with a view resource. Call your application’s
// 				SetTarget method if you want to change the target whether
// 				or not the old target is willing to resign.
// Override?	Seldom.
{
	bool returnVal = true;

	TEventHandler* currentTarget = GetTarget();
	if (this != currentTarget)
	{
		long reason = currentTarget->WillingToResignTarget();

		if (reason)
		{
			currentTarget->TargetValidationFailed(reason);
			returnVal = false;
		}
		else
		{
			currentTarget->TargetValidationSucceeded();
			SetTarget(this);
		}
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TEventHandler::ResignTarget:
//----------------------------------------------------------------------------------------

bool TEventHandler::ResignTarget()
{
	bool returnVal = false;

	TEventHandler* currentTarget = GetTarget();
	long reason = currentTarget->WillingToResignTarget();

	if (reason)
		currentTarget->TargetValidationFailed(reason);
	else
	{
		currentTarget->TargetValidationSucceeded();

		SetTarget(gDispatcher);
		returnVal = true;
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TEventHandler::SetEnable:
//----------------------------------------------------------------------------------------

void TEventHandler::SetEnable(bool state)
{
	fEnabled = state;
}

//----------------------------------------------------------------------------------------
// TEventHandler::Free:
//----------------------------------------------------------------------------------------

TEventHandler::~TEventHandler()
{
	if (gDispatcher && gDispatcher != this && GetTarget() == this)
		SetTarget(fNextHandler ? fNextHandler : gDispatcher);

	fNextHandler = NULL;
}

//----------------------------------------------------------------------------------------
// TEventHandler copy constructor
//----------------------------------------------------------------------------------------

TEventHandler::TEventHandler(const TEventHandler& inEventHandler)
	:	MDependable_AC(inEventHandler),
		MStreamable_AC(inEventHandler),
		fNextHandler(NULL),			// Was: inEventHandler.fNextHandler
		fIdentifier(inEventHandler.fIdentifier),
		fIdleFreq(inEventHandler.fIdleFreq),
		fLastIdle(inEventHandler.fLastIdle),
		fEnabled(inEventHandler.fEnabled)
// TEventHandler copy constructor.  NOTE: You must attach this event handler to
// an event handling hierarchy by calling SetNextHandler (or BeInSuperview for
// views) in order for events to be handled correctly.
{
	for (CBehaviorIterator iter(&inEventHandler); iter; ++iter)
		AddBehavior(static_cast<TBehavior*>(iter->Clone()));
}

//----------------------------------------------------------------------------------------
// TEventHandler::AddHandler:
//----------------------------------------------------------------------------------------

TEventHandler* TEventHandler::AddHandler(TEventHandler* headOfChain)
// AddHandler adds itself to the chain of handlers starting at the specified
// handler, and returns itself as the new head of the chain.
// For example, MacApp calls AddHandler when it adds an event handler to a
// cohandler chain.
//
// headOfChain:	Specifies the handler that is the current head of the chain
//				which becomes the next handler.
//
// Call?		Seldom.
// Override?	NEVER. It is not virtual.
{
	// add headOfChain to the end of the chain
	if (fNextHandler)
		fNextHandler->AddHandler(headOfChain);
	else
		fNextHandler = headOfChain;

	return this;								// new head of chain
}

//----------------------------------------------------------------------------------------
// TEventHandler::RemoveHandler:
//----------------------------------------------------------------------------------------

TEventHandler* TEventHandler::RemoveHandler(TEventHandler* headOfChain)
{
	TEventHandler* prevCohandler = NULL;
	TEventHandler* currCohandler = headOfChain;
	TEventHandler* newHeadOfChain = headOfChain;

	while (currCohandler)
	{
		if (currCohandler == this)				// found it
		{
			if (!prevCohandler)			// I was the head of the chain, so there
			// will be a new head of chain
				newHeadOfChain = fNextHandler;
			else
				prevCohandler->fNextHandler = fNextHandler;// take me out of the link
			fNextHandler = NULL;				// remember that i'm not in the chain
			// anymore
			currCohandler = NULL;				// So loop will end
		}
		else
		{
			prevCohandler = currCohandler;
			currCohandler = currCohandler->fNextHandler;
		}
	}

	return newHeadOfChain;
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoCommandKeyEvent:
//----------------------------------------------------------------------------------------

void TEventHandler::DoCommandKeyEvent(TToolboxEvent* event)
{
	if (fNextHandler)
		fNextHandler->HandleCommandKey(event);
}

//----------------------------------------------------------------------------------------
// TEventHandler::HandleCommandKey:
//----------------------------------------------------------------------------------------

void TEventHandler::HandleCommandKey(TToolboxEvent* event)
{
	TBehavior* aBehavior = GetFirstEnabledBehavior();
	if (aBehavior)
		aBehavior->DoCommandKeyEvent(event);
	else
		DoCommandKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoCoHandlerEvent:
//----------------------------------------------------------------------------------------

bool TEventHandler::DoCoHandlerEvent(TEvent* event)
{
	#pragma unused (event)
	return false;
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoHelp:
//----------------------------------------------------------------------------------------

void TEventHandler::DoHelp(TToolboxEvent* event,
						   long& message)
{
	if (fNextHandler)
		fNextHandler->DoHelp(event, message);
}

//----------------------------------------------------------------------------------------
// TEventHandler::NextIdle:
//----------------------------------------------------------------------------------------

unsigned long TEventHandler::NextIdle()
// NextIdle computes the next time, in ticks, when the event handler or one of its
// behaviors would like to have its DoIdle method called. 
//
// return:		Next time to idle. kMaxIdleTime means never. 
//
// Call?		Unlikely. TDispatcher::GetWaitTicks calls NextIdle for all the eligible
//				event handlers. 
{
	// first compute the next needed idle time based on myself
	unsigned long returnVal = kMaxIdleTime;

	if (IsEnabled() && fIdleFreq != kMaxIdleTime)// Does it idle at all?
		returnVal = fLastIdle + fIdleFreq;

	// then bound it by the attached behaviors
	for (CBehaviorIterator iter(this); iter; ++iter)
		returnVal = Min_AC(returnVal, iter->NextIdle());

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TEventHandler::HandleIdle:
//----------------------------------------------------------------------------------------

void TEventHandler::HandleIdle(IdlePhase phase)
// HandleIdle gives attached behaviors a chance to idle, and ensures that the DoIdle 
// methods are called only at the idle frequency or slower. 
//
// phase:		The IdlePhase. idleContinue means this is a true idle. idleBegin and
//				idleEnd are notifications that before and after idling. 
//
// Call?		Unlikely. The dispatcher calls HandleIdle for you. Use SetIdleFreq to 
//				control when idling happens. 
{
	TBehavior* aBehavior = GetFirstEnabledBehavior();
	if (aBehavior)
		aBehavior->HandleIdle(phase);

	// Does it idle at all?
	// idleBegin and idleEnd don't respect fIdleFreq because they are
	// notifications that the application is beginning/ending idle.
	// idleContinues, however, are parceled out at the fIdleFreq.

	if ((IsEnabled() && fIdleFreq != kMaxIdleTime) &&
		(phase != idleContinue || (TickCount() - fLastIdle >= fIdleFreq)))
	{
		// ALSO: don't store the fLastIdle if I freed myself or
		// the idlePhase is not idleContinue
		if (!DoIdle(phase) && phase == idleContinue)
			fLastIdle = TickCount();
	}
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoIdle:
//----------------------------------------------------------------------------------------

bool TEventHandler::DoIdle(IdlePhase phase)
// DoIdle is an empty method that you can override to do things at idle time. 
//
// phase:		The IdlePhase. idleContinue means this is a true idle. idleBegin and
//				idleEnd are notifications that before and after idling. Generally
//				your DoIdle method should do nothing if the phase is not idleContinue. 
// return:		A boolean value that used to indicate whether the event handler 
//				deleted itself during idle processing. Your DoIdle method should 
//				always return false (and should never delete itself). 
//
// Call?		Unlikely. Call SetIdleFreq to control when idling happens. 
// Override?	As needed. 
{
#pragma unused (phase)
	return false;								// Did not free myself
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoKeyEvent:
//----------------------------------------------------------------------------------------

void TEventHandler::DoKeyEvent(TToolboxEvent* event)
{
	if (fNextHandler)
		fNextHandler->HandleKeyCommand(event);
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoKeyUp:
//----------------------------------------------------------------------------------------

void TEventHandler::DoKeyUp(TToolboxEvent* event)
{
	if (fNextHandler)
		fNextHandler->HandleKeyUp(event);
}

//----------------------------------------------------------------------------------------
// TEventHandler::HandleKeyCommand:
//----------------------------------------------------------------------------------------

void TEventHandler::HandleKeyCommand(TToolboxEvent* event)
{
	TBehavior* aBehavior = GetFirstEnabledBehavior();
	if (aBehavior)
		aBehavior->DoKeyEvent(event);
	else
		DoKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TEventHandler::HandleKeyUp:
//----------------------------------------------------------------------------------------

void TEventHandler::HandleKeyUp(TToolboxEvent* event)
{
	TBehavior* aBehavior = GetFirstEnabledBehavior();
	if (aBehavior)
		aBehavior->DoKeyUp(event);
	else
		DoKeyUp(event);
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoMenuCommand:
//----------------------------------------------------------------------------------------

void TEventHandler::DoMenuCommand(CommandNumber aCommandNumber)
{
	if (fNextHandler)
		fNextHandler->HandleMenuCommand(aCommandNumber);
#if qDebugMsg
	else
		ProgramReport_AC("No one handled the command %1d\n", aCommandNumber);
#endif
}

//----------------------------------------------------------------------------------------
// TEventHandler::HandleMenuCommand:
//----------------------------------------------------------------------------------------

void TEventHandler::HandleMenuCommand(CommandNumber aCommandNumber)
{
	TBehavior* aBehavior = GetFirstEnabledBehavior();
	if (aBehavior)
		aBehavior->DoMenuCommand(aCommandNumber);
	else
		DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoMultiClick:
//----------------------------------------------------------------------------------------

bool TEventHandler::DoMultiClick(CPoint_AC lastDownPt, CPoint_AC newDownPt)
{
	return fNextHandler ? fNextHandler->DoMultiClick(lastDownPt, newDownPt) :
	(abs(lastDownPt.h - newDownPt.h) <= GetStdHysteresis().h && abs(lastDownPt.v - newDownPt.v) <= GetStdHysteresis().v);
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoSetupMenus:
//----------------------------------------------------------------------------------------

void TEventHandler::DoSetupMenus()
{
	if (fNextHandler)
		fNextHandler->HandleSetupMenus();
}

//----------------------------------------------------------------------------------------
// TEventHandler::HandleSetupMenus:
//----------------------------------------------------------------------------------------

void TEventHandler::HandleSetupMenus()
{
	TBehavior* aBehavior = GetFirstEnabledBehavior();
	if (aBehavior)
		aBehavior->DoSetupMenus();
	else
		DoSetupMenus();
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoKeySelection:
//----------------------------------------------------------------------------------------

void TEventHandler::DoKeySelection(const CStr255_AC& selectionString)
{
	#pragma unused (selectionString)
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TEventHandler::SetIdleFreq:
//----------------------------------------------------------------------------------------

void TEventHandler::SetIdleFreq(unsigned long newIdleFreq)
// SetIdleFreq sets the idle frequency for the event handler. Technically, it sets the 
// idle duration, the time in ticks between idles, which is the inverse of the frequency. 
// It also updates the last idle time so the next idle will be at least newIdleFreq 
// ticks from now. 
//
// newIdleFreq:		The new idle frequency for the event handler. 
//
// Call?			Whenever you feel like it. 
// Override?		Seldom. 
{
#if qDebugMsg && 0
	// Enable this code to get warnings about objects that may be idling too fast. 
	// An idle frequency of 0 is okay if the object is going to idle only once, but
	// if it is going to idle repeatedly, the idle frequency should be at least 1. 
	if ((fIdleFreq != newIdleFreq) && (newIdleFreq == 0))
		ProgramReport_AC("SetIdleFreq(%d) for event handler '%.4s'", newIdleFreq, (char*)&fIdentifier);
#endif

	// Set the idle frequency. 
	fIdleFreq = newIdleFreq;
	
	// The next idle will occur fIdleFreq ticks from now. 
	fLastIdle = TickCount();
}

//----------------------------------------------------------------------------------------
// TEventHandler::RemoveBehavior:
//----------------------------------------------------------------------------------------

void TEventHandler::RemoveBehavior(TBehavior* theBehavior)
{
	if (fBehavior)
	{
		if (fBehavior == theBehavior)
		{
			fBehavior.release();
			fBehavior = theBehavior->GetNextBehavior();
			if (fBehavior)
				fBehavior->SetPreviousBehavior(NULL);

			// remove theBehavior from the linked list
			theBehavior->SetNextBehavior(NULL);
			theBehavior->SetPreviousBehavior(NULL);
			theBehavior->SetOwner(NULL);
		}
		else
			fBehavior->RemoveBehavior(theBehavior);
	}
}

//----------------------------------------------------------------------------------------
// TEventHandler::InsertBehavior:
//----------------------------------------------------------------------------------------

void TEventHandler::InsertBehavior(TBehavior* theBehavior, TBehavior* beforeBehavior)
{
	if (theBehavior)
	{
#if qDebug
		for (CBehaviorIterator iter(this); iter; ++iter)
			if (iter == theBehavior)
				::ProgramReport_AC("AddBehavior: Attempting to add a behavior that has already been added.");
#endif
		if (beforeBehavior)
		{
			if (beforeBehavior == GetFirstBehavior())
			{
				fBehavior.release(); 			// release current ref so it doesn't get deleted
				fBehavior = theBehavior;
			}
			beforeBehavior->InsertBefore(theBehavior, beforeBehavior);
		}
		else
		{
			if (fBehavior)
				fBehavior->AppendBehavior(theBehavior);
			else
				fBehavior = theBehavior;
		}
		theBehavior->SetOwner(this);			// make this object its owner
	}
}

//----------------------------------------------------------------------------------------
// TEventHandler::GetFirstEnabledBehavior:
//----------------------------------------------------------------------------------------

TBehavior* TEventHandler::GetFirstEnabledBehavior() const
{
	return fBehavior ? (fBehavior->IsEnabled() ? fBehavior.get() : fBehavior->GetNextEnabledBehavior()) : NULL;
}

//----------------------------------------------------------------------------------------
// TEventHandler::GetBehaviorWithIdentifier:
//----------------------------------------------------------------------------------------

TBehavior* TEventHandler::GetBehaviorWithIdentifier(IDType itsIdentifier) const
{
	TBehavior* returnVal = NULL;

	for (CBehaviorIterator iter(this); iter; ++iter)
		if (iter->GetIdentifier() == itsIdentifier)
		{
			returnVal = iter;
			break;
		}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TEventHandler::SelectOwner:
//----------------------------------------------------------------------------------------

void TEventHandler::SelectOwner(bool select)
{
	for (CBehaviorIterator iter(this); iter; ++iter)
		iter->SelectOwner(select);
}

//----------------------------------------------------------------------------------------
// TEventHandler::IsSelected:
//----------------------------------------------------------------------------------------

bool TEventHandler::IsSelected()
{
	TBehavior* firstBehavior = GetFirstBehavior();

	return firstBehavior ? firstBehavior->IsOwnerSelected() : false;
}

//	//----------------------------------------------------------------------------------------
//	// TEventHandler::PostAnEvent:
//	//----------------------------------------------------------------------------------------
//	void TEventHandler::PostAnEvent(TEvent* event)
//	{
//		if (fNextHandler)
//			fNextHandler->PostAnEvent(event);
//		else
//		{
//	#if qDebug
//			WrLblHexLongint("No one posted the event ", reinterpret_cast<long>(event));
//	#endif
//			DeleteEvent(event);
//		}
//	}

//----------------------------------------------------------------------------------------
// TEventHandler::PostCommand:
//----------------------------------------------------------------------------------------

void TEventHandler::PostCommand(TCommand* command)
{
	if (command)
	{
		// Go directly to the dispatcher; do not pass Go, do not call 500 objects
		if (gDispatcher)
			gDispatcher->PostCommand(command);
		else
		{
#if qDebug
			WrLblHexLongint("No one posted the command ", reinterpret_cast<long>(command));
			ProgramReport_AC("\n");
#endif
			TCommand::DeleteCommand(command);
		}
	}
}

//----------------------------------------------------------------------------------------
// TEventHandler::ResignedWindowTarget:
//----------------------------------------------------------------------------------------

void TEventHandler::ResignedWindowTarget()
{
	HandleEvent(mResignedWindowTarget, this, NULL);
}

//----------------------------------------------------------------------------------------
// TEventHandler::GetWindow:
//----------------------------------------------------------------------------------------

TWindow* TEventHandler::GetWindow() const
{
	return NULL;
}

//----------------------------------------------------------------------------------------
// TEventHandler::ResignedTarget:
//----------------------------------------------------------------------------------------

void TEventHandler::ResignedTarget()
{
	HandleEvent(mResignedTarget, this, NULL);
}

//----------------------------------------------------------------------------------------
// TEventHandler::SetTargetSelection:
//----------------------------------------------------------------------------------------

void TEventHandler::SetTargetSelection(bool	redraw)
{
	#pragma unused (redraw)
}

//----------------------------------------------------------------------------------------
// TEventHandler::SetTarget:
//----------------------------------------------------------------------------------------

void TEventHandler::SetTarget(TEventHandler* newTarget)
{
	if (!newTarget)
	{
		newTarget = gDispatcher;
#if qDebug
		::ProgramBreak_AC("In TEventHandler::SetTarget…  you're setting the global target to NULL!");
#endif
	}

	if (newTarget != fgTarget)
	{
		TEventHandler* oldTarget = fgTarget;
		fgTarget = newTarget;

		if(oldTarget)
			oldTarget->ResignedTarget();
		fgTarget->BecameTarget();

		if (gDispatcher)
			gDispatcher->InvalidateMouseRegions();	// Must re-calc cursor and help regions
	}
}

//----------------------------------------------------------------------------------------
// TEventHandler::Terminate:
//----------------------------------------------------------------------------------------

void TEventHandler::Terminate()
{
}

//----------------------------------------------------------------------------------------
// TEventHandler::ReadFrom:
//----------------------------------------------------------------------------------------

void TEventHandler::ReadFrom(CStream_AC* aStream)
{
	MStreamable_AC::ReadFrom(aStream);

	fIdentifier = aStream->ReadIDType();
	fEnabled = aStream->ReadBoolean();
	fIdleFreq = aStream->ReadUnsignedLong();

	short numBehaviors = aStream->ReadInteger();
	for (short count = 0; count < numBehaviors; ++count)
	{
		bool wasValid;
		TBehavior* aBehavior = dynamic_cast_AC(TBehavior*,aStream->ReadStreamObject(wasValid));
		if (wasValid && aBehavior)
			AddBehavior(aBehavior);
#if qDebugMsg
		else
			::ProgramBreak_AC("###Unknown behavior in TEventHandler::ReadFrom: Attempting to create a TBehavior.");
#endif
	}
}

//----------------------------------------------------------------------------------------
// TEventHandler::WriteTo:
//----------------------------------------------------------------------------------------

void TEventHandler::WriteTo(CStream_AC* aStream) const
{
	MStreamable_AC::WriteTo(aStream);

	aStream->WriteIDType(fIdentifier);
	aStream->WriteBoolean(fEnabled);
	aStream->WriteUnsignedLong(fIdleFreq);

	short numBehaviors = 0;
	long numPosition = aStream->GetWritePosition();	// Remember the position of the
	// count in the stream.
	aStream->WriteInteger(numBehaviors);		// Write initial num behaviors.
	TBehavior* aBehavior = GetFirstBehavior();
	while (aBehavior)
	{
		++numBehaviors;
		aStream->WriteStreamObject(aBehavior, kStandardObject);
		aBehavior = aBehavior->GetNextBehavior();
	}

	if (numBehaviors)							// if there were any behaviors...
	{
		long currentPosition = aStream->GetWritePosition();// Remember where we are.
		aStream->SetWritePosition(numPosition);		// Go back to position of count.
		aStream->WriteInteger(numBehaviors);	// Write the count.
		aStream->SetWritePosition(currentPosition);	// Go back to where we were.
	}
}

//----------------------------------------------------------------------------------------
// TEventHandler::WantsToBeTarget:
//----------------------------------------------------------------------------------------

bool TEventHandler::WantsToBeTarget()
{
	return false;
}

//----------------------------------------------------------------------------------------
// TEventHandler::WillingToResignTarget:
//----------------------------------------------------------------------------------------

long TEventHandler::WillingToResignTarget()
{
	return 0;									// kValidValue
}

//----------------------------------------------------------------------------------------
// TEventHandler::KeyEventToComponents:
//----------------------------------------------------------------------------------------

void TEventHandler::KeyEventToComponents(TToolboxEvent* event)
{
	if (fNextHandler)
		fNextHandler->KeyEventToComponents(event);
	else if (event->GetWhat() == keyDown || event->GetWhat() == keyUp || event->GetWhat() == autoKey)
	{
		// Default extractions
		event->SetKeyCode(static_cast<unsigned short>((event->GetEventMessage() & keyCodeMask)) >> 8);

		CStr2_AC newText(static_cast<unsigned char>(event->GetEventMessage() & charCodeMask));
		if (MACharacterByteType((Ptr) & newText[1], 0, event->GetKeyScript()) == smFirstByte)
			newText += static_cast<unsigned char>(event->GetEventMessage(1) & charCodeMask);
		event->SetText(newText);
	}
}

//----------------------------------------------------------------------------------------
// TEventHandler::TargetValidationSucceeded:
//----------------------------------------------------------------------------------------

void TEventHandler::TargetValidationSucceeded()
{
}

//----------------------------------------------------------------------------------------
// TEventHandler::TargetValidationFailed:
//----------------------------------------------------------------------------------------

void TEventHandler::TargetValidationFailed(long	reason)
{
	#pragma unused (reason)
}

//----------------------------------------------------------------------------------------
// TEventHandler::DoEvent:
//----------------------------------------------------------------------------------------

void TEventHandler::DoEvent(EventNumber		eventNumber,
							TEventHandler*	source,
							TEvent*			event)
{
	if (fNextHandler)
		fNextHandler->HandleEvent(eventNumber, source, event);
#if qDebugMsg
	else if (gIntenseDebugging)
	{
		ProgramReport_AC("in TEventHandler.DoHandleEvent: no one handled the event: %1d\n", eventNumber);
		WrLblHexLongint(" From source: ", reinterpret_cast<long>(source));
		ProgramReport_AC("\n");
		WrLblHexLongint(" Event object: ", reinterpret_cast<long>(event));
		ProgramReport_AC("\n");
	}
#endif
}

//----------------------------------------------------------------------------------------
// TEventHandler::HandleEvent:
//----------------------------------------------------------------------------------------

void TEventHandler::HandleEvent(EventNumber		eventNumber,
								TEventHandler*	source,
								TEvent*			event)
{
	TBehavior* aBehavior = GetFirstEnabledBehavior();
	if (aBehavior)
		aBehavior->DoEvent(eventNumber, source, event);
	else
		DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// Command Handling
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TEventHandler::GetContext:
//----------------------------------------------------------------------------------------

TEventHandler* TEventHandler::GetContext(CommandNumber aCommandNumber)
{
	#pragma unused (aCommandNumber)
	return this;
}

//----------------------------------------------------------------------------------------
// TEventHandler::PerformCommand:
//----------------------------------------------------------------------------------------

void TEventHandler::PerformCommand(TCommand* command)
{
	TCommand::PerformCommand(command);
}

//----------------------------------------------------------------------------------------
// TEventHandler::GetUndoHandler:
//----------------------------------------------------------------------------------------

TUndoHandler* TEventHandler::GetUndoHandler()
{
	TUndoHandler* undoHandler = dynamic_cast_AC(TUndoHandler*, GetBehaviorWithIdentifier(kStdUndoBehavior));

	if (!undoHandler)
	{
		TEventHandler* context = GetContext(cUndo);
		if (context && (context != this))
			undoHandler = context->GetUndoHandler();
	}

	return undoHandler;
}

//----------------------------------------------------------------------------------------
// TEventHandler::GetLastCommand:
//----------------------------------------------------------------------------------------

TCommand* TEventHandler::GetLastCommand()
{
	// ••• We could look for commands relating to us in the undo history •••
	// ••• Maybe we don't have to •••

	return NULL;	// fLastCommand;
}

//----------------------------------------------------------------------------------------
// TEventHandler::CommitLastCommand:
//----------------------------------------------------------------------------------------

void TEventHandler::CommitLastCommand()
{
	// Clear the action history for this context
	TUndoHandler* undoHandler = GetUndoHandler();
	if (undoHandler)
		undoHandler->ClearActionHistory();
}

//----------------------------------------------------------------------------------------
// TEventHandler::PrepareForUndoRedo:
//----------------------------------------------------------------------------------------

void TEventHandler::PrepareForUndoRedo(TCommand* command)
{
	#pragma unused (command)

	if (WantsToBeTarget())
		BecomeTarget();
}

//----------------------------------------------------------------------------------------
// TEventHandler::RevealUndoRedo:
//----------------------------------------------------------------------------------------

void TEventHandler::RevealUndoRedo(TCommand* command)
{
	#pragma unused (command)
}

//----------------------------------------------------------------------------------------
// End of UEventHandler.cpp

/*
	Historical Change Record:
		----- R13 -----
		07/16/97	Changed ProgramBreak_AC to ProgramReport_AC in DoMenuCommand, AddBehavior, PostCommand, and DoEvent
		07/13/97	[1385305] (Printing) Problems printing non-visible views
		07/13/97	[1615633] (TTEView -Clone) Clone crashed at mouse click
		07/08/97	[1616218] (TDispatcher -GetWaitTicks) Return very large value
		06/30/97	[1353169] fprinf(stderr, blah) to ProgramBreak_AC(blah)
		05/05/97	Changes for new streaming.
		04/22/97	Calculations for sleepticks was overflowing and causing apps to sleep too long.
		04/14/97	Update for real xxx_cast operators.
		04/13/97	Update List and Dependency names for ACS.
		04/11/97	Moved SetTarget/GetTarget/fTarget to TEventHandler (as statics), IsTarget a simple
							Inline and removed the need for TEditText to lie in a (former) override of IsTarget.
							Instead, TEditText::WantsToBeTarget only wants to be the target if its fTEView isn't
		04/09/97	properly use dynamic casting for all down/side casts
		04/08/97	Update for TToolBoxEvent protected fields.
		04/08/97	Update for TAdorner/TBehavior/TEventHandler/TCommandHandler/TCommand/
							TFileBasedDocument/TSection/TEditionDocument protected fields.
		03/25/97	AC_ to _AC Name change.
		01/17/97	In TEventHandler::RemoveBehavior release fNextBehavior before assigning to it.
		03/07/97	Massive Changes: Use Exceptions_AC, new to TH_new, use Blah_AC,
							Update Copyright, Moved Obsolete APIs into Compatibility.h, etc..
		02/15/97	Fleshed out copy constructor.
		09/30/96	Fix cloning by turning clone methods into copy constructors
		09/12/96	[1380648] Remove empty DoUpdate override.
		08/16/96	Use constructors for all TView descendents
		08/10/96	Fixed -noload compiles, made more datamembers auto_ptrs, FreeIfObject->delete
		08/07/96	Goodbye TObject!
		07/26/96	[1372385] Changed MDependable_AC* changedBy parameters and member to
							void* changeData.
		07/18/96	Use CAutoPtr_AC based pointers for many instance variables.
		07/17/96	define template CAutoPtr_AC and use it in place of CTempObject
		07/16/96	Removed MAVolatile
		07/16/96	Now include UExceptions.h instead of UFailure.h
		07/15/96	Boolean->bool
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/25/96	[1345531] Added #include "UMacAppUtilities.h" for noload buids
		06/24/96	Restored mResignedTarget message in TEventHandler::ResignedTarget since it was being used by TTargetBorderView
		06/21/96	[1117870] (2-BYTE) TTEView and Left&Right Arrow
							[1115111] (2-BYTE) TTEView::GetNumberOfChars returns 0 after 1 character has been typed
							[1353017] (Double-byte) Second Character Lost
		06/19/98	[1357587] ResignedWindowTarget no longer sends on an
							mResignedWindowTarget.
		06/13/96	Removed R11 marker
		06/13/96	[1354891] Added optomization to Become target.
		06/12/96	Removed the code that was pound-if 0 in DoUpdate.
		06/09/96	Removed UStreamable to a separate file from UObject
		04/24/96	Removed call to TBehavior::DoBehaviorUpdate from TEventHandler
							::DoUpdate.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Update iterators to be OD stylish.
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		04/15/96	Made TEventHandler MDependable_AC
		----- R10 -----
		03/31/96	Made some judicious inlining for CHandlerIterator
		03/25/96	Restored inline hints for compiler. Made TEventHandler::GetIdentifier/
		 					GetNextHandler/IsEnabled/GetFirstEnabledBehavior/RemoveBehavior/AddBehavior
							non virtual
		03/25/96	TToolboxEvent::fCharacter is obsolete
							Made empty UAdorners constructors inline
		03/23/96	Made TEventHandler::KeyEventToComponents aware of TToolboxEvent::AddSecondaryKeyEvent
		03/07/96	Removed more gratuitous inlining.
		03/01/96	Re-arranged data members, natural alignment results in
		 					reduced storage size.
							Grouped some globals and global functions as static members.
		01/18/95	Made GetWindow const.
		12/8/95	Split up includes for modular MacApp.
		----- 3.3 -----
		----- 3.3b1 -----
		04/12/95	Conditionalize printf on qDebugMsg.
		03/17/95	MAVolatile.
		03/15/95	Don't call methods of gDispatcher while it is being destructed.
		03/13/95	Change Free methods to destructors.
		01/04/95	TEventHandler::AddBehavior now appends the behavior being
							added to the behavior list before calling TBehavior::SetOwner.
							This allows TDragDropBehavior to dispose itself when SetOwner
							is called.
		----- 3.5d2 Release -----
		 9/14/94	Remove DoAppleCommand and HandleAppleCommand.
							Support for AEOM makes them obsolete.
*/