//----------------------------------------------------------------------------------------
// UScriptableObject.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		11/09/00	Remove unused variable containerForm. 
		03/10/00	DonÕt FreeOSAScript in ~MScriptableObject if not attachable.
		02/23/00	MScriptableObjectÕs dtor is now always present and virtual.
		07/16/99	GetContainedObject was adding NULL as a temporary token instead
					of the list result for kAEAll. 
		03/24/99	Update copyright notice.
		02/04/99	[C] Replace GetDataHandle with GetDataAsHandle in 2 places.
		01/15/99	CAEDesc_AC is now in ACS. 
		10/29/98	GetCommandContext can't be const since it might return 'this'.
		10/08/98	Merge TCommandHandler into TEventHandler. 
*/

#ifndef __USCRIPTABLEOBJECT__
#include "UScriptableObject.h"
#endif

#if qAppleEventAware

// ACS

#ifndef __CListIterator__
#include "CListIterator_AC.h"
#endif

// MacApp

#ifndef __UBEHAVIOR__
#include "UBehavior.h"
#endif

#ifndef __UCOMMANDHANDLER__
#include "UCommandHandler.h"
#endif

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#if qAttachable
	#ifndef __UOSASCRIPT__
	#include "UOSAScript.h"
	#endif
#endif

#ifndef __USCRIPTING__
#include "UScripting.h"
#endif

// Toolbox

#ifndef __AEPACKOBJECT__
#include <AEPackObject.h>
#endif

#ifndef __ASDEBUGGING__
#include <ASDebugging.h>
#endif

#ifndef __ASREGISTRY__
#include <ASRegistry.h>
#endif

#ifndef __OSAGeneric__
#include <OSAGeneric.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

//========================================================================================
// CLASS MScriptableObject
//========================================================================================
//----------------------------------------------------------------------------------------
// MScriptableObject constructor
//----------------------------------------------------------------------------------------

MScriptableObject::MScriptableObject()
	: fOMClassID(typeNull)
{
}

MScriptableObject::MScriptableObject(DescType myClassID)
	: fOMClassID(myClassID)
{
}

//----------------------------------------------------------------------------------------
// MScriptableObject destructor
//----------------------------------------------------------------------------------------

MScriptableObject::~MScriptableObject()
{
#if qAttachable
	FreeOSAScript();
#endif
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetOMClass
//----------------------------------------------------------------------------------------

DescType MScriptableObject::GetOMClass()
{
	return fOMClassID;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetSpecifierForm
//----------------------------------------------------------------------------------------

DescType MScriptableObject::GetSpecifierForm()
{
	return formAbsolutePosition;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::CountContainedObjects
//----------------------------------------------------------------------------------------

long MScriptableObject::CountContainedObjects(DescType/* desiredType */ )
{
	// Returns the number of objects ofType that this object contains.
	return 0;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::CompareScriptableObjects
//----------------------------------------------------------------------------------------

bool MScriptableObject::CompareScriptableObjects(DescType operation,
													const CAEDesc_AC& thingToCompare)
{
	// Compares this object to something else. This default version compares to another
	// object for direct object equality. Override this for more detailed comparisons.
	MScriptableObject* compareWith = GetObject(thingToCompare);

	return operation == kAEEquals ? compareWith == this : false;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::CompareProperties
//----------------------------------------------------------------------------------------

bool MScriptableObject::CompareProperties(DescType whichProperty,
											 DescType operation,
											 const CAEDesc_AC& thingToCompare)
{
	// Compares a property of this object to something else. This is a generic comparison routine
	// Designed to handle the most common comparison requests.

	bool result = false;
	CTempDesc_AC theProperty;
	if (GetObjectProperty(theProperty, whichProperty, CAEDesc_AC::fgNullDesc))
		result = theProperty.CompareDesc(thingToCompare, operation);
	return result;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::MakeObjectSpecifier
//----------------------------------------------------------------------------------------

bool MScriptableObject::MakeObjectSpecifier(CAEDesc_AC& theObjectSpecifier,
											   DescType preferredForm)
// Creates an object specifier describing this object. This calls GetObjectProperty and
// GetObjectsContainer to support formName, formAbsolutePosition, and formUniqueID.
// You'll only need to override this method if you want to make other forms of
// object specifiers.
{
	CAEDesc_AC containerSpec;
	//DescType containerForm = preferredForm;
	MScriptableObject * theContainer = GetObjectsContainer();
	theContainer->MakeObjectSpecifier(containerSpec, theContainer->GetSpecifierForm());
	DescType myClass = GetOMClass();
	CAEDesc_AC formDesc;
	bool createSpecifier = false;
	if (preferredForm == formName)
	{
		if (GetObjectProperty(formDesc, pName, CAEDesc_AC::fgNullDesc))
			createSpecifier = true;
		else
			preferredForm = formAbsolutePosition; // no name, try absolute position.
	}
	if (preferredForm == formUniqueID)
	{
		if (GetObjectProperty(formDesc, pID, CAEDesc_AC::fgNullDesc))
			createSpecifier = true;
		else
			preferredForm = formAbsolutePosition; // no unique ID, try absolute position.
	}
	if (preferredForm == formAbsolutePosition)
	{
		createSpecifier = GetObjectProperty(formDesc, pIndex, CAEDesc_AC::fgNullDesc);
	}
	if (createSpecifier)
		::ThrowIfOSErr_AC(CreateObjSpecifier(myClass, containerSpec, preferredForm, formDesc, true, theObjectSpecifier));

	return createSpecifier;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetCommandContext
//----------------------------------------------------------------------------------------

TEventHandler* MScriptableObject::GetCommandContext(const CommandNumber aCommandNumber)
{
	MScriptableObject* castFrom = const_cast<MScriptableObject*>(this);
	TEventHandler *commandHandler = dynamic_cast_AC(TEventHandler*, castFrom);
	if (commandHandler)
		commandHandler = commandHandler->GetContext(aCommandNumber);
	
	if (!commandHandler)
	{
		MDefaultScriptableObject *defaultTarget = TOSADispatcher::fgDispatcher->GetDefaultTarget();
		
		if (defaultTarget)
		{
			commandHandler = dynamic_cast_AC(TEventHandler*, defaultTarget);
			if (commandHandler)
				commandHandler = commandHandler->GetContext(aCommandNumber);
		}
	}
	
	if (!commandHandler)	// getting desperate...
		commandHandler = gDispatcher;
		
	return commandHandler;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::HandleScriptCommand:
//----------------------------------------------------------------------------------------

void MScriptableObject::HandleScriptCommand(CommandNumber	aCommandNumber,
											TAppleEvent* 	message,
											TAppleEvent*	reply)
{
	bool wasHandled = false;
	
	TEventHandler* commandHandler = dynamic_cast_AC(TEventHandler*, this);
	if (commandHandler)
	{
		TBehavior *aBehavior = commandHandler->GetFirstEnabledBehavior();
		if (aBehavior)
			wasHandled = aBehavior->DoScriptCommand(aCommandNumber, message, reply);
	}
	
	if (!wasHandled)
		DoScriptCommand(aCommandNumber, message, reply);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoScriptCommand
//----------------------------------------------------------------------------------------

void MScriptableObject::DoScriptCommand(CommandNumber 	aCommandNumber,
										TAppleEvent* 	message,
										TAppleEvent* 	reply)
// Aftering resolving an object specifier into an object this method is called.
// Based on the command number in the refCon it dispatches the event to
// one of the Core event support routines defined below.
// Override this method if this object supports events beyond the core suite.
{

	switch (aCommandNumber)
	{
		case cAEClone:
			DoAEClone(message, reply);
			break;

		case cAEQuit:
		case cAEClose:
			DoAEClose(message, reply);
			break;

		case cAECountElements:
			DoAECountElements(message, reply);
			break;

		case cAECreateElement:
			DoAECreateElement(message, reply);
			break;

		case cAEDoObjectsExist:
			DoAEDoObjectsExist(message, reply);
			break;

		case cAEGetClassInfo:
			DoAEGetClassInfo(message, reply);
			break;

		case cAEGetEventInfo:
			DoAEGetEventInfo(message, reply);
			break;

		case cAEMove:
			DoAEMove(message, reply);
			break;

		case cAESetData:
			DoAESetData(message, reply);
			break;

		case cAEGetData:
			DoAEGetData(message, reply);
			break;

		case cAEGetDataSize:
			DoAEGetDataSize(message, reply);
			break;

		case cAEDelete:
			DoAEDelete(message, reply);
			break;

		case cAESave:
			DoAESave(message, reply);
			break;

		case cAEOpen:
			DoAEOpen(message, reply);
			break;

		case cAEPrint:
		case cPrint:
			DoAEPrint(message, reply);
			break;

		default:
			::ThrowIfOSErr_AC(errAEEventNotHandled);
			break;
	}
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEOnContainedObjects
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEOnContainedObjects(TScriptableObjectList* theObjectList,
											   CommandNumber aCommandNumber,
											   TAppleEvent* message,
											   TAppleEvent* reply)
{
	// If the AppleEvent's object specifier resolves into a list of objects, MacApp first gives
	// their container object a shot at handling the event.

	// If this is a list of TPropertyAccessors and its a SetData AppleEvent, create a TSetPropertyCommand
	// To do the work on all the objects
	if ((aCommandNumber == cAESetData) && theObjectList->IsPropertyList())
	{
		CList_AC theCmdObjectList;
		bool emptyList = true;

		DescType theProperty;
		for (TemplateIterator_AC<TPropertyAccessor*> iter(theObjectList); iter; ++iter)
		{
			theProperty = (*iter).fWhichProperty;
			theCmdObjectList.InsertLast(iter);
			emptyList = false;
		}

		if (!emptyList)
		{
			CAutoPtr_AC<TSetPropertyCommand> theCmd(TH_new TSetPropertyCommand(theProperty, &theCmdObjectList, message, reply));
			theCmd->Process();
			theCmd.release();
		}
#if qDebugMsg
		else
			ProgramReport_AC("MScriptableObject::DoAEOnContainedObjects: cAESetData AppleEvent with empty ObjectList.");
#endif
	}
	else
		theObjectList->DoScriptCommand(aCommandNumber, message, reply);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEClone
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEClone(TAppleEvent*	/* message */ ,
								  TAppleEvent* /* reply */)
{
	// Handle the Clone AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantClone);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEClose
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEClose(TAppleEvent*	/* message */ ,
								  TAppleEvent* /* reply */)
{
	// Handle the Close AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantClose);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAECountElements
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAECountElements(TAppleEvent* message,
										  TAppleEvent* reply)
{
	// Handle the Count Elements AppleEvent from the Core Suite.
	DescType theClass = dynamic_cast_or_throw_AC(TAppleEvent*,message)->ReadType(keyAEObjectClass);
	long numObjects = CountContainedObjects(theClass);
	reply->WriteLong(keyAEResult, numObjects);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAECreateElement
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAECreateElement(TAppleEvent* /* message */  ,
										  TAppleEvent* /* reply */)
{
	// Handle the Create Element AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantCreate);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEDelete
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEDelete(TAppleEvent*	/* message */ ,
								   TAppleEvent* /* reply */)
{
	// Handle the Delete AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantDelete);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEDoObjectsExist
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEDoObjectsExist(TAppleEvent* /* message */  ,
										   TAppleEvent* reply)
{
	// Handle the DoObjectsExist AppleEvent from the Core Suite.
	// Of course I exist, otherwise I couldn't do this:
	dynamic_cast_or_throw_AC(TAppleEvent*,reply)->WriteBoolean(keyAEResult, true);
	// If I didn't exist AccessContainedObjects would fail and that's handled 
	// in TScriptEventDispatcher:DispatchAppleEvent.
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEGetClassInfo
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEGetClassInfo(TAppleEvent* /* message */  ,
										 TAppleEvent* /* reply */)
{
	// Handle the DoGetClassInfo AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantGetClassInfo);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEGetEventInfo
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEGetEventInfo(TAppleEvent* /* message */  ,
										 TAppleEvent* /* reply */)
{
	// Handle the DoGetEventInfo AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantGetEventInfo);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEGetData
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEGetData(TAppleEvent* /* message */  ,
									TAppleEvent* reply)
{
	// Handle the GetData AppleEvent from the Core Suite.
	CTempDesc_AC theSpecifier;
	MakeObjectSpecifier(theSpecifier, GetSpecifierForm());
	reply->WriteParameter(keyAEResult, theSpecifier);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEGetDataSize
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEGetDataSize(TAppleEvent* /* message */  ,
										TAppleEvent* /* reply */)
{
	// Handle the GetDataSize AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantGetDataSize);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEMove
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEMove(TAppleEvent*	/* message */ ,
								 TAppleEvent*	/* reply */)
{
	// Handle the Move AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantMove);
}


//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEOpen
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEOpen(TAppleEvent*	/* message */ ,
								 TAppleEvent*	/* reply */)
{
	// Handle the Open AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantOpen);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAEPrint
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAEPrint(TAppleEvent*	/* message */ ,
								  TAppleEvent*	/* reply */)
{
	// Handle the Print AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantPrint);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAESave
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAESave(TAppleEvent*	/* message */ ,
								 TAppleEvent*	/* reply */)
{
	// Handle the Save AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantSave);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::DoAESetData
//----------------------------------------------------------------------------------------

void MScriptableObject::DoAESetData(TAppleEvent*	/* message */  ,
									TAppleEvent*	/* reply */)
{
	// Handle the SetData AppleEvent from the Core Suite.
	::ThrowIfOSErr_AC(errAECantSetData);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetContents
//----------------------------------------------------------------------------------------

bool MScriptableObject::GetContents(CAEDesc_AC& /*theContents*/,
										const CAEDesc_AC& /*desiredType*/,
										long /*propertyFlags*/)
{
	// Override to return the contents of this object.
	// Default is "not found". 
	return false;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::SetContents
//----------------------------------------------------------------------------------------

void MScriptableObject::SetContents(const CAEDesc_AC& theContents)
{
	// Sets the contents of this object. If theContents is an AERecord,
	// SetObjectProperty will be called for each property key.
	if (theContents.GetDescriptorType() == typeAERecord)
	{
		long numProps = 0;
		::ThrowIfOSErr_AC(AECountItems(theContents, &numProps));
		for (long index = 1; index <= numProps; ++index)
		{
			CTempDesc_AC thePropData;
			DescType theKey;
			if (AEGetNthDesc(theContents, index, typeWildCard, &theKey, thePropData) == noErr)
				SetObjectProperty(thePropData, theKey);
		}
	}
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetObjectProperty
//----------------------------------------------------------------------------------------

bool MScriptableObject::GetObjectProperty(CAEDesc_AC& thePropertyValue,
											 DescType whichProperty,
											 const CAEDesc_AC& desiredType)
{
	bool hasProperty = true;

	try
	{
		// Returns default property values for this object.
		switch (whichProperty)
		{
			case pContents:
				hasProperty = GetContents(thePropertyValue, desiredType);
				break;
				
			case pClass:
				thePropertyValue.PutType(GetOMClass());
				break;
	
#if qAttachable
			case pScript:
				GetOSAScript(thePropertyValue, desiredType);
				break;
#endif
			case pIndex:
				{
					hasProperty = false;
					DescType myType = GetOMClass();
					MScriptableObject * itsContainer = GetObjectsContainer();
					long numObjects = itsContainer->CountContainedObjects(myType);
					for (long myIndex = 1; myIndex <= numObjects; ++myIndex)
					{
						MScriptableObject * indexedObject = itsContainer->GetIndContainedObject(myType, myIndex);
						CTempDesc_AC objectDesc;
						PutObject(objectDesc, indexedObject);
						if (CompareScriptableObjects(kAEEquals, objectDesc))
						{
							thePropertyValue.PutLong(myIndex);
							hasProperty = true;
							break;
						}
					}
				}
				break;
	
			default:
				hasProperty = false;
				break;
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		hasProperty = false;
	}
	

	return hasProperty;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::SetObjectProperty
//----------------------------------------------------------------------------------------

void MScriptableObject::SetObjectProperty(const CAEDesc_AC& thePropertyValue,
										  DescType whichProperty)
{
	// Override this method to set property values for this object.
	switch (whichProperty)
	{
#if qAttachable
		case pScript:
			SetOSAScript(thePropertyValue);
			break;
#endif
		case pContents:
			SetContents(thePropertyValue);
			break;

		case pClass:
		case pIndex:
			::ThrowIfOSErr_AC(errAECantSetReadOnly);
			break;

		default:
			::ThrowIfOSErr_AC(errAENoSuchObject);
			break;
	}
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetSetPropertyInfo
//----------------------------------------------------------------------------------------

void MScriptableObject::GetSetPropertyInfo(DescType /*whichProperty*/ ,
										   CommandNumber& cmdNum,
										   bool& canUndo,
										   bool& causesChange,
										   TEventHandler* &theContext)
{
	// When an AppleEvent is received that will set a property for this object a TSetPropertyCommand
	// will be created to do it. You can override this method to provide the command number and the
	// canUndo and causesChange flags for the command.
	cmdNum = cAESetData;
	canUndo = true;
	causesChange = true;
	theContext = GetCommandContext(cmdNum);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetContainedObject
//----------------------------------------------------------------------------------------

MScriptableObject* MScriptableObject::GetContainedObject(DescType desiredType,
														 DescType selectionForm,
														 const CAEDesc_AC& selectionData)
{
	// Returns an object contained within this one. If the desiredType is a property
	// of this object, we create a TPropertyAccessor and return it.
	// Later on, the TPropertyAccessor can act on the properties of this object.
	// For other types we try to return an object. If you would really like to reference
	// something else you can create an object class that references it and return one of those.
	// For each keyform this routine figures out which contained object is needed and gets it
	// by calling GetIndContainedObject. If you just want to provide the OSL with access to 
	// contained objects you should override GetIndContainedObject.
	MScriptableObject *result = NULL;
	CAEDesc_AC theDataDesc = selectionData;
	if (desiredType == cApplication)
		result = gDispatcher;
	else if (desiredType == cProperty)
	{
		DescType whichProperty = theDataDesc.GetType();
		TPropertyAccessor * theAccessor = TH_new TPropertyAccessor(this, whichProperty);
		TOSADispatcher::fgDispatcher->AddTemporaryToken(theAccessor);
		result = theAccessor;
	}
	else
	{
		// Now we switch on the key forms to find the correct contained object.
		switch (selectionForm)
		{
			case formName:
				{
					// Search through all the objects of this type and look at their pName property.
					// This is hardly the most efficient way to do this, but works in a very generic fashion.
					// If you have a lot of contained objects you can override this to look at the contained
					// objects directly.
					CStr255_AC keyNameStr;
					CStr255_AC objectNameStr;
					keyNameStr = theDataDesc.GetString();
					long numObjects = CountContainedObjects(desiredType);
					for (long myIndex = 1; myIndex <= numObjects; ++myIndex)
					{
						CTempDesc_AC theNameDesc;
						MScriptableObject *indexedObject = GetIndContainedObject(desiredType, myIndex);
						if (indexedObject && indexedObject->GetObjectProperty(theNameDesc, pName, CAEDesc_AC::fgNullDesc))
						{
							objectNameStr = theNameDesc.GetString();
							if (keyNameStr == objectNameStr)
							{
								result = indexedObject;
								break;
							}
						}
					}
					break;
				}

			case formRelativePosition:
				{
#if qCarbon
					TemplateTempHandle<DescType**> aHandle(reinterpret_cast<DescType**>(theDataDesc.GetDataAsHandle()));
					DescType whichPosition = **aHandle;
#else
					DescType whichPosition = **(DescType * *)theDataDesc.GetDataHandle();
#endif
					result = GetAdjacentObject(desiredType, whichPosition);
					break;
				}

			case formRange:
				{
					CTempDesc_AC rangeStart;
					CTempDesc_AC rangeStop;
					CTempDesc_AC rangeRecord;
					MScriptableObject * startObj = NULL;
					MScriptableObject * stopObj = NULL;
					::ThrowIfOSErr_AC(AECoerceDesc(theDataDesc, typeAERecord, rangeRecord));
					rangeRecord.GetKeyDesc(keyAERangeStart, typeObjectSpecifier, rangeStart);
					rangeRecord.GetKeyDesc(keyAERangeStop, typeObjectSpecifier, rangeStop);
					startObj = TOSADispatcher::fgDispatcher->ResolveObjectSpecifier(rangeStart);
					stopObj = TOSADispatcher::fgDispatcher->ResolveObjectSpecifier(rangeStop);
					::ThrowIfNULL_AC(startObj);
					::ThrowIfNULL_AC(stopObj);
					// Now we have the bounding objects in the range
					// Call the accessor function to get the range of contained objects
					result = GetObjectsWithinRange(desiredType, startObj, stopObj);
					break;
				}

			case formUniqueID:
				{
					CStr255_AC theKeyStr;
					CStr255_AC uniqueIDStr;
					theKeyStr = theDataDesc.GetString();
					long numObjects = CountContainedObjects(desiredType);
					for (long myIndex = 1; myIndex <= numObjects; ++myIndex)
					{
						CTempDesc_AC theIDDesc;
						MScriptableObject *indexedObject = GetIndContainedObject(desiredType, myIndex);
						if (indexedObject && indexedObject->GetObjectProperty(theIDDesc, pID, CAEDesc_AC::fgNullDesc))
						{
							uniqueIDStr = theIDDesc.GetString();
							if (theKeyStr == uniqueIDStr)
							{
								result = indexedObject;
								break;
							}
						}
					}
					break;
				}

			case formAbsolutePosition:
				{
					// Gets a contained object by index. Also supports typeAbsoluteOrdinal for getting
					// objects by first, last, some, middle, and every.
					long numObjects = CountContainedObjects(desiredType);
					long objectIndex = 1;
					if (theDataDesc.GetDescriptorType() == typeAbsoluteOrdinal)
					{
#if qCarbon
						TemplateTempHandle<DescType**> aHandle(reinterpret_cast<DescType**>(theDataDesc.GetDataAsHandle()));
						DescType whichType = **aHandle;
#else
						DescType whichType = **(DescType * *)theDataDesc.GetDataHandle();
#endif
						switch (whichType)
						{
							case kAEFirst:
								objectIndex = 1;
								break;
							case kAELast:
								objectIndex = numObjects;
								break;
							case kAEMiddle:
								objectIndex = (numObjects + 1) / 2;
								break;
							case kAEAny:
								objectIndex = GetRandom(1, numObjects);
								break;
							case kAEAll:
								{
									CAutoPtr_AC<TScriptableObjectList> theList(TH_new TScriptableObjectList(this));

									for (long myIndex = 1; myIndex <= numObjects; ++myIndex)
									{
										MScriptableObject *indexedObject = GetIndContainedObject(desiredType, myIndex);
										if (indexedObject)
											theList->InsertLast(indexedObject);
									}
									
									result = theList.release();
									TOSADispatcher::fgDispatcher->AddTemporaryToken(result);
								}
								break;
						}
					}
					else
					{
						objectIndex = theDataDesc.GetLong();
						if (objectIndex < 0)
							objectIndex = objectIndex + numObjects + 1;
					}
					if (!result)				// If the result has not been set previously
						result = GetIndContainedObject(desiredType, objectIndex);
					break;
				}

			default:
				::ThrowIfOSErr_AC(errAEEventNotHandled); 	//whose clauses need errAEEventNotHandled
		}
	}

	return result;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetIndContainedObject
//----------------------------------------------------------------------------------------

MScriptableObject* MScriptableObject::GetIndContainedObject(DescType/*desiredType*/ ,
															long/*index*/)
// Returns an object contained within this one based on its absolute
// position within the container. If you override this method to return
// contained objects MScriptableObject::GetContainedObject will use this to get
// one or more objects required by the different reference forms.
{
	return NULL;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetObjectsWithinRange
//----------------------------------------------------------------------------------------

MScriptableObject* MScriptableObject::GetObjectsWithinRange(DescType desiredType,
															MScriptableObject* startBounds,
															MScriptableObject* endBounds)
// Returns an object or list of objects contained within this one
// that lie within the startBounds object and the endBounds object.
// The default method assumes that the startBounds and endBounds objects
// are of the desiredType.
// You can override this to provide custom range access.
{
	long numObjects = CountContainedObjects(desiredType);
	bool addObjects = false;

	CAutoPtr_AC<TScriptableObjectList> theList(TH_new TScriptableObjectList);

	for (long myIndex = 1; myIndex <= numObjects; ++myIndex)
	{
		MScriptableObject *indexedObject = GetIndContainedObject(desiredType, myIndex);
		CTempDesc_AC objectDesc;
		PutObject(objectDesc, indexedObject);
		addObjects = (addObjects || (startBounds->CompareScriptableObjects(kAEEquals, objectDesc)));
		if (addObjects)
		{
			theList->InsertLast(indexedObject);
			addObjects = !endBounds->CompareScriptableObjects(kAEEquals, objectDesc);
		}
	}
	TOSADispatcher::fgDispatcher->AddTemporaryToken(theList);
	
	return theList.release();
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetObjectsContainer
//----------------------------------------------------------------------------------------

MScriptableObject* MScriptableObject::GetObjectsContainer()
{
	// By default we'll return the application.
	return gDispatcher;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetAdjacentObject
//----------------------------------------------------------------------------------------

MScriptableObject* MScriptableObject::GetAdjacentObject(DescType desiredType,
														DescType position)
// When the OSL resolves relative reference forms it first specifies an object
// then asks that object for the one before or after it. This method returns
// an object of the desiredType before or after it. 
// You can override this method by to provide custom access.
{
	MScriptableObject * result = NULL;
	CTempDesc_AC myIndex;
	if (GetObjectProperty(myIndex, pIndex, CAEDesc_AC::fgNullDesc))
	{
		long relativeIndex = myIndex.GetLong();
		if (position == kAENext)
			++relativeIndex;
		else if (position == kAEPrevious)
			--relativeIndex;
		MScriptableObject * itsContainer = GetObjectsContainer();
		result = itsContainer->GetIndContainedObject(desiredType, relativeIndex);
	}

	return result;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::MakeNewMarkingList
//----------------------------------------------------------------------------------------

TScriptableObjectList* MScriptableObject::MakeNewMarkingList()
{
	// Returns a TScriptableObjectList to use for marking objects contained within this one. 
	TScriptableObjectList * theList = TH_new TScriptableObjectList(this);
	TOSADispatcher::fgDispatcher->AddTemporaryToken(theList);

	return theList;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::SetProperties:
//----------------------------------------------------------------------------------------

void MScriptableObject::SetPropertiesFromEvent(TAppleEvent* theEvent)
{
	// Sets the properties of an object based on the data in the keyAEPropData parameter
	// of the event.
	if (theEvent)
	{
		CTempDesc_AC propListDesc;
		if (AEGetParamDesc(theEvent, keyAEPropData, typeAERecord, propListDesc) == noErr)
			SetContents(propListDesc);
	}
}

#if qAttachable

//----------------------------------------------------------------------------------------
// Attached Scripts
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// MScriptableObject::HasOSAScript:
//----------------------------------------------------------------------------------------

bool MScriptableObject::HasOSAScript()
{
	return HasAppleScript_AC() && fOSAScript && fOSAScript->HasOSAScript();
}

//----------------------------------------------------------------------------------------
// MScriptableObject::FreeOSAScript:
//----------------------------------------------------------------------------------------

void MScriptableObject::FreeOSAScript()
{
	if (fOSAScript)
	{
		TOSADispatcher::fgDispatcher->ScriptDetached();
		fOSAScript = NULL;	// This will free the rep object
							// if its ref count drops to 0.
	}
}

//----------------------------------------------------------------------------------------
// MScriptableObject::SetOSAScript:
//----------------------------------------------------------------------------------------

void MScriptableObject::SetOSAScript(const CAEDesc_AC& scriptDesc)
{
	if (HasAppleScript_AC())
	{
		if (!fOSAScript)
		{
			fOSAScript = COSAScriptCntPtr::NewOSAScript();
			TOSADispatcher::fgDispatcher->ScriptAttached();
		}
		fOSAScript->SetOSAScript(scriptDesc);
	}
}

//----------------------------------------------------------------------------------------
// MScriptableObject::GetOSAScript:
//----------------------------------------------------------------------------------------

void MScriptableObject::GetOSAScript(CAEDesc_AC& scriptDesc,
										const CAEDesc_AC& desiredType)
{
	if (HasAppleScript_AC() && fOSAScript)
		fOSAScript->GetOSAScript(scriptDesc, desiredType);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::HandleOSAEvent:
//----------------------------------------------------------------------------------------

bool MScriptableObject::HandleOSAEvent(CommandNumber aCommandNumber,
										  TAppleEvent* message,
										  TAppleEvent* reply)
{
	bool handled = false;
	COSAScriptCntPtr tempOSAScript(fOSAScript);	// Temporary to prevent script
												// from an early death.
	if (HasAppleScript_AC() && fOSAScript)
		handled = tempOSAScript->HandleOSAEvent(aCommandNumber, message, reply);
	
	return handled;
}

//----------------------------------------------------------------------------------------
// MScriptableObject::ReadOSAScript:
//----------------------------------------------------------------------------------------

void MScriptableObject::ReadOSAScript(CStream_AC* aStream)
{
	if (HasAppleScript_AC())
	{
		if (!fOSAScript)
		{
			fOSAScript = COSAScriptCntPtr::NewOSAScript();
			TOSADispatcher::fgDispatcher->ScriptAttached();
		}
		fOSAScript->ReadOSAScript(aStream);
	}
}

//----------------------------------------------------------------------------------------
// MScriptableObject::WriteOSAScript:
//----------------------------------------------------------------------------------------

void MScriptableObject::WriteOSAScript(CStream_AC* aStream,
									   DescType asType)
{
	if (HasAppleScript_AC() && fOSAScript)
		fOSAScript->WriteOSAScript(aStream, asType);
}

//----------------------------------------------------------------------------------------
// MScriptableObject::IdleOSAScript:
//----------------------------------------------------------------------------------------

void MScriptableObject::IdleOSAScript()
{
	COSAScriptCntPtr tempOSAScript(fOSAScript);	// Temporary to prevent script
												// from an early death.
	if (HasAppleScript_AC() && fOSAScript)
		tempOSAScript->IdleOSAScript();
}

#endif // qAttachable

//========================================================================================
// CLASS MDefaultScriptableObject
//========================================================================================
//----------------------------------------------------------------------------------------
// MDefaultScriptableObject::MDefaultScriptableObject
//----------------------------------------------------------------------------------------

MDefaultScriptableObject::MDefaultScriptableObject()
	: MScriptableObject(),
	  fRecording(false)
{
}

//----------------------------------------------------------------------------------------
// MDefaultScriptableObject::MDefaultScriptableObject
//----------------------------------------------------------------------------------------

MDefaultScriptableObject::MDefaultScriptableObject(DescType myClassID)
	: MScriptableObject(myClassID),
	  fRecording(false)
{
}

//----------------------------------------------------------------------------------------
// MDefaultScriptableObject destructor
//----------------------------------------------------------------------------------------

MDefaultScriptableObject::~MDefaultScriptableObject()
{
}

//----------------------------------------------------------------------------------------
// MDefaultScriptableObject::DoScriptCommand
//----------------------------------------------------------------------------------------

void MDefaultScriptableObject::DoScriptCommand(CommandNumber aCommandNumber,
											   TAppleEvent* message,
											   TAppleEvent* reply)
{
	switch (aCommandNumber)
	{
		case cAERecordingOn:
			fRecording = true;
			break;
		
		case cAERecordingOff:
			fRecording = false;
			break;
			
		default:
			MScriptableObject::DoScriptCommand(aCommandNumber, message, reply);
			break;
	}
}

#endif	// #if qAppleEventAware

//----------------------------------------------------------------------------------------
// End of UScriptableObject.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		05/07/96	Made TAppleEvent derive from CAEDesc_AC as well as TObject.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/19/96	Added destructor for MDefaultScriptableObject so the compilers would quit
							dropping generated destructors for it everywhere
		02/19/96	[1323091] GetContainedObject now returns errAEEventNotHandled
							rather than errAEWrongDataType. Without this change, whose 
							clauses whould not work. (Thanks, Greg!) Changed copyright.
		 12/8/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		11/02/95	Add MScriptableObject::GetCommandContext
							GetSetPropertyInfo calls GetCommandContext
							DoAEOnContainedObject processes SetPropertyCommand instead of posting.
							Add qOptimizeSelfSendAevt.
		 11/1/95	Make drag cursor and script idle code resident. 
		10/31/95	cPrint script commands cause DoAEPrint to get called.
		10/31/95	Replaced many WriteOSErrors with FailOSErr.
		10/25/95	Removed failure block from MScriptableObject::HandleScriptCommand.
		10/25/95	MakeObjectSpecifier gets containers form by calling
							GetSpecifierForm.
		10/24/95	Replace calls to GetBestType with GetSpecifierForm.
							Remove support for pBestType, pDefaultType.
		10/21/95	Add MScriptable::GetBestType and GetDefaultType.
							Use GetBestType() in calls to MakeObjectSpecifier.
							Getting the bestType or the default type returns a descType
							instead of an object specifier.
		 9/27/95	1284865	(Build) MrC and fOSAScript when -attachable
		 9/26/95	[1276050] Check for read-only items [pBestType, pDefaultType,
		 					pClass, pIndex] in MScriptableObject::SetObjectProperty.
		 9/22/95	GetContainedObject tests for nil.
		 9/20/95	Removed unused local disposalFlag from GetContainedObject.
		----- 3.3b1 -----
		  9/5/95	TOSAScriptCntPtr -> COSAScriptCntPtr.
		 8/14/95	Modified fOSAScript to use the reference counting mechanism.
		 8/14/95	SetPropertiesFromEvent is void, non-virtual, and calls SetContents.
		 8/10/95	Notify the dispatcher when we create or delete an attached
							OSA script. Include UErrorMgr to get errAExxx. 
		 8/10/95	Attached scripts were being lost upon reading.  Now calling
		 					TOSAScript::ReadOSAScript instead of ReadObject in 
							MScriptableObject::ReadOSAScript. #1275538.
		  8/8/95	Added error handling to HandleScriptCommand so that errors
		  					can be reported to an AE client using the 'errs' resource.
		  8/7/95	Removed DoAERevert and put into the document class.
		 7/31/95	Add dispatching of cAERevert, DoAERevert function, and
		 					error of kCantRevert.
		 7/28/95	Add configuration functions to use instead of gConfiguration. 
		 7/28/95	Add destructor to free attached script. 
		 7/27/95	Conditionalize attachability support. 
		 7/25/95	Move COSAScript to its own unit, UOSAScript. Move attached
							script functionality from MScriptableObject to new class
							TOSAScript. Remove methods GetScriptingComponent, 
							ExecuteOSAScript and GetOSAParent. 
		 6/28/95	Reorder scripting method params.
		 6/16/95	HandleOSAEvent returns false if it gets ANY error
		 6/14/95	IsPendingAction returns false if actionID is 0
		 6/13/95	Make the script class globals non-pointers. 
		 6/12/95	Support TOSADispatcher::fgDispatcher, CAEDesc_AC::fgNullDesc,
		  					TAppleEvent::WriteError.
		 					Add COSAScript::fgGlobalScript, fgSharedScript, fgEmptyScript.
		  					Added inline accessors for all three.
		  					Add MDefaultScriptableObject.
		  					Change HandleBehaviorScriptCommand to HandleScriptCommand.
		  					HandleScriptCommand calls DoScriptCommand.
							Add MScriptableObject::IsPendingAction.
							Fix MScriptableObject::MakeObjectSpecifier bug: function always returned true.
							Use CAEDesc_AC::CompareDesc. Script dispatcher can no longer compare AEDescs.
							Changed MScriptableObject::fCommandHander from TEventHandler to TCommandHandler.
		 5/14/95	save/lock and restore handle state instead of lock and unlock
		  4/4/95	Fix IdleOSAScript so commands are created and initialized
		  					at the same time (so we don't get "someone forgot to call
		  					IObject"). 
		 3/30/95	ARM 8.4.3 x& cannot be initialized with volatile x. 
		 3/17/95	MAVolatile. 
		 3/10/95	Add ClassDesc. 
		  3/3/95	Changed prototye of COSAScript::SetScript to take
		  					a "const CAEDesc_AC& scriptDesc" instead of
		  					"const CAEDesc_AC scriptDesc" to fix CW complaints about
		  					calls to ambiguous overloaded func when passing
		  					a CAETempDesc.
		 2/24/95	Add \s to '????' so it will compile with PPCC. 
		 2/21/95	Use FailNULLResource instead of FailResError. 
		 2/19/95	Suppress warning messages. 
		 2/17/95	Integration fixes, plus more attachability stuff from Ken. 
		 2/14/95	Restore res file before returning. 
		 2/14/95	Second batch of attachability changes. Bracket OSA calls
							with CurResFile / UseResFile in COSAScript:: GetScript. 
		 1/26/95	Add COSAScript and support for attached scripts. 
		 2/14/95	MScriptableObject::MakeObjectSpecifier returns a bool.
		 2/13/95	MScriptableObject::GetObjectProperty returns a bool.
		----- 3.5d3 Release -----
		11/17/94	Change NULL to nil. 
		 9/30/94	Add MScriptableObject::HandleBehaviorScriptCommand to
							support passing apple events to behaviors.
		 9/30/94	Add fEventHandler member and constructor
							support to MScriptableObject.
		 9/23/94	Add support for new TScriptEventDispatcher.
		 9/14/94	Fixed context problem in SetProperty events that
							prevented them from being undone.
		 8/22/94	If MScriptableObject::GetContainedObject is passed
							cApplication as the desiredType, the global application
							reference is now returned. (per Ken Ryall)
		 7/18/94	Move GetRandom to UMacAppUtilities. 
							Change NULL to nil. 
		 7/14/94	Merged with Ken Ryall's MAScript changes. 
*/