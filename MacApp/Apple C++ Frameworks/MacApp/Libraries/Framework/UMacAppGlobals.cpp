//----------------------------------------------------------------------------------------
// UMacAppGlobals.cpp
// Copyright � 1984-2001 by Apple Computer, Inc. All rights reserved.
// Portions Copyright � 1997 by Trygve Isaacson.
//
//	Our sincere thanks to George Varga & Juergen A. Mayrbaeurl of ARTMA Biomedical who
//  allowed us to pattern MacApp's Navigation Services support on their recommendations.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/09/01	Removed unused FindPos function. 
		03/19/01	Use template version of BlockZero_AC
		03/19/01	Use BlockZero_AC, instead of BlockSet_AC(,,0)
		03/01/01	Don't include Threads_AC, Windows_AC. 
		01/11/01	Removed ParseTitleTemplate and SubstituteInTitle--they are
					now functions of CString_AC (with different names).
		01/19/01	Put back the change, as Threads_AC.h actually brings in
					qWantsThreadManager.
		01/19/01	Don�t include Threads_AC.h if !qWantsThreadManager.
		01/02/01	Make the callbacks really match the toolbox procptr definitions. 
		01/02/01	Update copyright.
		11/27/00	Back out casting of gEmptyString--no longer needed.
		11/06/00	[C] Reinclude Sound.h.
		11/04/00	Use qEmulateStandardControls instead of qGrayscaleAppearance. 
		11/03/00	[C] Don�t include Traps.h.  Cast gEmptyString for NewCWindow.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		09/13/00	[C] Reenable Beep.
		07/31/00	[W] Don�t call DrawDefaultProc in MinimalAlertFilter.  Don�t
					call TerminateQTML in CleanupMacApp.
		07/13/00	Enclose SysBeep message in qCarbon.
		06/22/00	dynamic_cast TPrintHandler in InstallIfPrintHandler.
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Include CMultiLocal.h.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		05/03/00	[C] Took out SysBeep for building framework.
		04/18/00	Include UPrintMgr.h instead of UPrintHandler.h.
		04/14/00	Do not initialize TPrintHandler::gPrintHandler in DoInitUMacApp.
					The application should do this.
		02/22/00	[W] Gray not available.  Cannot check for presence of
					UndoRedo menu so assume multi-level for Windows.
		12/08/99	Do not define qd for qCarbon.
		10/18/99	Remove "DefineConfiguration", as the structure that it was based on
					"Configuration" no longer exists.
		10/11/99	Put comment around GetIndVolume, do BlockSet(0) for parameter block,
					and for both implementations, only assign vRefNum if call works.
		10/01/99	Non-Carbon version of GetIndVolume was not calling the File 
					Manager. Brought back the old implementation. 
		09/30/99	GetIndVolume: In Carbon, use XVolumeParam; clear param block
					and return a vRefNum of 0 if error for both compiles.
		08/09/99	Changed MA_REGISTER_CLASS to REGISTER_CLASS_AC.  Changed 
					MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/29/99	Rename Patterns_AC to CPattern_AC to avoid confusion with the
					include file. 
		03/24/99	Update copyright notice.
		03/23/99	Do not directly refer to qd.gray.
		03/19/99	[W] De-pascalize MacAppStandardFileFilter, MacAppAlertFilter,
					MinimalAlertFilter.
		02/08/99	Change WindowRef to WindowPtr, DialogRef to DialogPtr.
		11/16/98	[2284718] Conditionalize pWorkPortStorage allocation based
					on qMAGlobalNew in DoInitUMacApp.
		11/13/98	[2279272] Remove const in MacAppNavigationEventFilter.
		11/05/98	Carbon - use SetCursorToArrow_AC
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.
					Use SetPort_AC, SetCursor_AC.  Include ImagingUtils_AC.h.
		10/28/98	Include Navigation stuff only if qNavigation.
		10/26/98	Carbonize
		10/08/98	Undo context. 
*/

#include "MacAppRequired.h"

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

// ACS

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#if qEmulateStandardControls
#	ifndef __CDialog_AC__
#	include "CDialog_AC.h"
#	endif
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#if qWantsThreadManager	&& !qMSWindows
	#ifndef __ThreadUtilities_AC__
	#include "ThreadUtilities_AC.h"
	#endif
#endif

#ifndef __WindowUtils_AC__
#include "WindowUtils_AC.h"
#endif

// MacApp

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __UCONTROL__
#include "UControl.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

// always include for TDragDropBehavior stub
#if qDrag
	#ifndef __UDRAGDROBEHAVIOR__
	#include "UDragDropBehavior.h"
	#endif
#endif

#ifndef __UDRAWINGENVIRONMENT__
#include "UDrawingEnvironment.h"
#endif

#ifndef __UERRORMGR__
#include "UErrorMgr.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UNIVERSALSTARTUP__
#include "UniversalStartup.h"
#endif

#ifndef __UPATCH__
#include "UPatch.h"
#endif

#ifndef __UPOINTEROBJECT__
#include "UPointerObject.h"
#endif

#ifndef __UPrintMgr__
#include "UPrintMgr.h"
#endif

#ifndef __UReporter__
#include "UReporter.h"
#endif

#if qAppleEventAware
	#ifndef __USCRIPTING__
	#include "UScripting.h"
	#endif
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

#ifndef __UUNDO__
#include "UUndo.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UTEVIEW__
#include "UTEView.h"
#endif

// Toolbox

#ifndef __FOLDERS__
#include <Folders.h>
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MACWINDOWS__
#include <MacWindows.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __SOUND__
#include <Sound.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

#if !qCarbon
	#ifndef __TRAPS__
	#include <Traps.h>
	#endif
#endif

// QTML

#if qMSWindows
	#ifndef __QTML__
	#include <QTML.h>
	#endif
#endif

// ANSI


#ifndef __STDLIB__
#include <stdlib.h>
#endif

//----------------------------------------------------------------------------------------
#if !qCarbon && !defined(__MWERKS__)
QDGlobals qd;
#endif

const CTextStyle_AC& gSystemStyle = CTextStyle_AC::kSystemStyle;
const CTextStyle_AC& gApplicationStyle = CTextStyle_AC::kApplicationStyle;
const CTextStyle_AC& gApplicationStyle9 = CTextStyle_AC::kApplicationSmallStyle;

WindowPtr gWorkPort;
CGrafPtr gWorkCPort;
#if !qCarbon
static CWindowRecord* pWorkPortStorage;
#endif

RgnHandle gTemporaryRegion;

NMRecPtr gNotificationPtr;

ModalFilterYDProcPtr gModalFilterYDProcPtr = MacAppStandardFileFilter;

#if qDebug
bool gBusyTemporaryRegion;
CStr255_AC gUsedBy;
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

void RegisterCommonViews();	// leave as non-static so application can replace

//========================================================================================
// GLOBAL Functions
//========================================================================================

#if qOldConfigurationFlags
static void DefineConfiguration(Configuration& theConfiguration);
#endif

//----------------------------------------------------------------------------------------
// GetAlertButtonTitle: Retrieve the title of the button control. If itemNo isn't a
// button, then return ''.
//----------------------------------------------------------------------------------------

void GetAlertButtonTitle(DialogPtr theDialog,
						 short itemNo,
						 CStr255_AC& theTitle)
{
	short itemType;
	Handle item;
	CRect_AC box;
	GetDialogItem(theDialog, itemNo, &itemType, &item, &box);

	if (itemType == (ctrlItem + btnCtrl))
		GetControlTitle((ControlRef)item, theTitle);
	else
		theTitle.Empty();
}

//----------------------------------------------------------------------------------------
// DoAlertKeyDown: Handle a keypress that has been mapped to one of the button controls.
//----------------------------------------------------------------------------------------

void DoAlertKeyDown(DialogPtr theDialog,
					short itemNo)
{
#if qEmulateStandardControls
	CDialog_AC*	agaDialog = CDialog_AC::ObjectFromDialogPtr(theDialog);
	
	if (agaDialog != NULL)
		agaDialog->FlashButton(itemNo);
	else
#endif
		{
		short itemType;
		Handle item;
		CRect_AC box;

		GetDialogItem(theDialog, itemNo, &itemType, &item, &box);
		if (itemType == (ctrlItem + btnCtrl))
		{
			// this code gives visual feedback 
			HiliteControl((ControlRef)item, kControlUpButtonPart);// hilite the button 
			DelayFuture_AC(8);					// delay for 8 ticks 
			HiliteControl((ControlRef)item, kControlNoPart);// stop hiliting the button 
		}
	}
}

//----------------------------------------------------------------------------------------
// CompareAlertKeysToItem: Compares the buffered multi-byte chars to the first character
// of each button title 1st button in alert (by convention == "OK"). 2nd button in alert
// (by convention == "Cancel"). 3rd button in alert (by convention == "No")
//----------------------------------------------------------------------------------------

bool CompareAlertKeysToItem(DialogPtr theDialog,
							   const CStr2_AC& theChars,
							   short& itemHit)
{
	bool returnVal = false;

	static const short itemtests[3] = { ok, cancel, kNoButton };

	for (short i = 0; i < 4; ++i)
	{
		CStr255_AC title;
		GetAlertButtonTitle(theDialog, itemtests[i], title);
		if (CompareMultiByteChars(theChars, title, false))
		{
			itemHit = itemtests[i];
			returnVal = true;
			break;
		}
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// DrawDefaultProc:  Draw the thick rounded rectangle around the default button
// (Imported to MacApp from Ponnuki by GA)
//
// This routine uses Keith Rollin's algorithm, as presented in the USENET Guide to
// Programming the Macintosh. I have modified the basic algorithm only slightly--I add
// two to the calculated 'buttonOval' value. This gets better results, particularly for
// buttons of the default size (18 points).
//----------------------------------------------------------------------------------------

void DrawDefaultProc(DialogPtr dlog)
{
	// Don't call GetDialogItem if the default button # has a strange value
	short defaultButton = GetDialogDefaultItem(dlog);
	if (defaultButton > 0)
	{
		GrafPtr savePort;
		GetPort(&savePort);
#if !qCarbon
		SetPortWindowPort(dlog);
#else
		SetPortWindowPort(::GetDialogWindow(dlog));
#endif

		short type = 0;
		ControlRef buttonHandle = NULL;
		CRect_AC outlineBox;

		GetDialogItem(dlog, defaultButton, &type, (Handle *) & buttonHandle, outlineBox);
		outlineBox.Inset(-4, -4);

		// Don't draw the bold outline around the default button
		// unless it really is a button
		if (type == ctrlItem + btnCtrl)
		{
			PenState saveState;
			short buttonOval;

			GetPenState(&saveState);

			// We want to draw the thick line with a normal
			// pen pattern that is 3 pixels wide
			PenNormal();
			PenSize(3, 3);

			// If the button we are outlining is disabled,
			// draw the outline with a gray pattern.
			// ���  Actually, on color systems we should use disable gray mode
#if !qCarbon && !qMSWindows
// Carbon is always color
			if ((*buttonHandle)->contrlHilite == 255)
				PenPat(CPattern_AC::Gray());
#endif

			// Calculate the curvature to use and draw the thick line
			buttonOval = 2 + (outlineBox.bottom - outlineBox.top) / 2;
			FrameRoundRect(outlineBox, buttonOval, buttonOval);

			SetPenState(&saveState);
		}
		::SetPort_AC(savePort);
	}
}

//----------------------------------------------------------------------------------------
// MinimalAlertFilter: This is the minimally-functional alert filter that MacApp uses
// in cases where gDispatcher has not yet been initialized.  TApplication.AlertFilter
// calls this filter as well.
//----------------------------------------------------------------------------------------

#if !qMSWindows
pascal
#endif
	Boolean MinimalAlertFilter(DialogPtr theDialog,
								  EventRecord& theEvent,
								  short& itemHit)
{
	bool returnValue = false;

	switch (theEvent.what)
	{
		case updateEvt:
#if !qMSWindows
			if (((DialogPtr)theEvent.message) == theDialog)
				DrawDefaultProc(theDialog);
#endif
			break;

		case keyDown:
			{
				static CStr2_AC bufferedCharacter;	// hangs around in between keystrokes
				unsigned char theChar = static_cast<unsigned char>(theEvent.message & charCodeMask);

				bool processCharacter = true;
				switch (MACharacterByteType((Ptr) & theChar, 0, smCurrentScript))
				{
					case smFirstByte:
						processCharacter = false;
						// no break - just drop through

					case smSingleByte:
						bufferedCharacter = theChar;
						break;

					case smLastByte:
						bufferedCharacter += theChar;
						break;
				}

				if (processCharacter)
				{
					if ((bufferedCharacter == chEnter) || (bufferedCharacter == chReturn))
					{
						itemHit = GetDialogDefaultItem(theDialog);
						DoAlertKeyDown(theDialog, itemHit);
						returnValue = true;
					}
					else if ((bufferedCharacter == '`') || (bufferedCharacter == chEscape) || ((bufferedCharacter == '.') && (theEvent.modifiers & cmdKey)))
					{
						DoAlertKeyDown(theDialog, cancel);
						itemHit = cancel;
						returnValue = true;
					}
				}

				break;
			}
	}

	return returnValue;
}

//----------------------------------------------------------------------------------------
// MacAppAlertFilter: 
//----------------------------------------------------------------------------------------

#if !qMSWindows
pascal
#endif
	Boolean MacAppAlertFilter(DialogPtr theDialog,
								 EventRecord* theEvent,
								 short* itemHit)
{
	return gDispatcher ? gDispatcher->AlertFilter(theDialog, *theEvent, *itemHit) : MinimalAlertFilter(theDialog, *theEvent, *itemHit);
}

#if qAppleEventAware
//----------------------------------------------------------------------------------------
// MacAppAppleEventIdleProc: 
//----------------------------------------------------------------------------------------

pascal Boolean MacAppAppleEventIdleProc(EventRecord* theEventRecord,
										long* sleepTime,
										RgnHandle* mouseRgn)
{
	return gDispatcher ? gDispatcher->AppleEventIdleProc(*theEventRecord, *sleepTime, *mouseRgn) : false;
}
#endif

//----------------------------------------------------------------------------------------
// MacAppStandardFileFilter: 
//----------------------------------------------------------------------------------------


#if !qMSWindows
pascal
#endif
	Boolean MacAppStandardFileFilter(DialogPtr theDialog,
										EventRecord* theEvent,
										short* itemHit,
										void* yourDataPtr)
{
	return gDispatcher ? gDispatcher->StandardFileFilter(theDialog, *theEvent, *itemHit, yourDataPtr) : false;
}

#if qNavigation

//----------------------------------------------------------------------------------------
// MacAppNavigationEventFilter: 
//----------------------------------------------------------------------------------------

pascal void MacAppNavigationEventFilter(NavEventCallbackMessage callBackSelector, 
										NavCBRecPtr callBackParms, 
										NavCallBackUserData callBackUD)
// 	MacAppNavigationEventFilter is intended to handle events that occur while a Navigation Services dialog is displayed;
// it calls TApplication::NavEventFilter to do the event processing
// Override: Never. Override TApplication::NavEventFilter instead
// Call: Never. The system calls it for you
{
	if (gDispatcher)
		gDispatcher->NavEventFilter(callBackSelector, callBackParms, callBackUD);
} // MacAppNavigationEventFilter 

#endif

//----------------------------------------------------------------------------------------
// ApplicationBeep: 
//----------------------------------------------------------------------------------------

void ApplicationBeep()
{
#if qMSWindows
	if (gDispatcher)
		gDispatcher->Beep(2);
#else
	gDispatcher ? gDispatcher->Beep(2) : ::SysBeep(2);	// At least give some indication 
#endif
}

//----------------------------------------------------------------------------------------
// CleanupMacApp: 
//----------------------------------------------------------------------------------------

void CleanupMacApp()
{
	static bool inCleanupMacApp;					// flag ensures one and only one call
	
	if (!inCleanupMacApp)
	{
		inCleanupMacApp = true;						// dont' re-enter

		::SetResLoad(true);							// Make sure segments can load 


		//
		// Override Terminate if you need any special shutdown handling.
		//
		if (gDispatcher)
			gDispatcher->Terminate();

#if !qMSWindows && !qCarbon
		UnpatchAll();
#endif

		// Clear gDispatcher so nobody can refer to the object
		gDispatcher = NULL;
	}
}

//----------------------------------------------------------------------------------------
// DoneWithTemporaryRegion: Indicates that gTemporaryRegion is no longer in use. Call this
// only if qDebug is true.
//----------------------------------------------------------------------------------------

#if qDebug

void DoneWithTemporaryRegion()
{
	if (!gBusyTemporaryRegion)
		::ProgramBreak_AC("DoneWithTemporaryRegion called, but gTemporaryRegion is not locked");

	gBusyTemporaryRegion = false;
	gUsedBy.Empty();
	SetEmptyRgn(gTemporaryRegion);
}

#endif

//----------------------------------------------------------------------------------------
// ExitMacApp: 
//----------------------------------------------------------------------------------------

void ExitMacApp()
{
	CleanupMacApp();

	exit(EXIT_FAILURE);
}

//----------------------------------------------------------------------------------------
// GetNewCenteredDialog: 
//----------------------------------------------------------------------------------------

DialogPtr GetNewCenteredDialog(ResNumber dialogID,
							   Ptr dStorage,
							   WindowPtr behind)
{
	DialogPtr returnVal = NULL;

	DialogTHndl dlogTemplate;

	::SetCursorToArrow_AC();

	if (gDispatcher)
		gDispatcher->InvalidateMouseRegions();

	dlogTemplate = (DialogTHndl)CMultiLocale_AC::GetResource('DLOG', dialogID);
	if (dlogTemplate)
	{
		ResNumber	realDLOGID = CMultiLocale_AC::GetExistingResourceID('DLOG', dialogID);
		CenterRectOnScreen(((CRect_AC &)(*dlogTemplate)->boundsRect), true, true, true);
		returnVal = GetNewDialog(realDLOGID, dStorage, behind);
	}
	else
	{
		ApplicationBeep();
#if qDebug
		CStr255_AC theString;
		ConcatNumber("Unable to find 'DLOG' resource ", CMultiLocale_AC::GetExistingResourceID('DLOG', dialogID), theString);
		::ProgramBreak_AC(CChar255_AC(theString));
#endif

	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// GetTextStyleFontInfo: Really a utility, but the gWorkPort isn't reachable from
// UMacAppUtilities
//----------------------------------------------------------------------------------------

void GetTextStyleFontInfo(const CTextStyle_AC& theTextStyle,
						  FontInfo& theFontInfo,
						  short& theFontHeight)
{
	GrafPtr savedPort;

	GetPort(&savedPort);
	SetPortWindowPort(gWorkPort);
	theTextStyle.SetPortTextStyle();
	theFontHeight = MAGetFontInfo(theFontInfo);
	::SetPort_AC(savedPort);
}

//----------------------------------------------------------------------------------------
// InitUMacApp
//----------------------------------------------------------------------------------------

void InitUMacApp(short callsToMoreMasters)	
{
	InitUMacApp_Step1();									
	InitUMacApp_Step3(callsToMoreMasters);
}

//----------------------------------------------------------------------------------------
// InitUMacApp_Step1
//----------------------------------------------------------------------------------------

void InitUMacApp_Step1()
{
#if qTidyHeap
	CTidyHeap_AC::Instance()->StopTrackingUnknownBlocks();
#endif

//	CException_AC::SetTerminateHandler();
		// Install default termination handler.
	
	InitUReporter(); // ���  debug only?
		
	UniversalStartup();

	if (!ValidateConfiguration())
		AlertUnsupportedConfiguration();

	// Init the basics used by the ErrorMgr
	gMacAppAlertFilter = MacAppAlertFilter;	

	RegisterAppearance_AC();
}

//----------------------------------------------------------------------------------------
// InitUMacApp_Step3
//----------------------------------------------------------------------------------------

void InitUMacApp_Step3(short callsToMoreMasters)
{
	// Install MacApp's Memory management systems
	InitCoreMacApp(callsToMoreMasters);

	DoInitUMacApp();							// do rest of initialization 

	RegisterCommonViews();
}

//----------------------------------------------------------------------------------------
// DoInitUMacApp: Must be in the init segment
//----------------------------------------------------------------------------------------

void DoInitUMacApp()
{
	atexit(CleanupMacApp);

	// Initialize the view system
	bool initGX = false;
#if qGXViews || qGXPrinting
	initGX = true;
#endif

	TView::InitUView(initGX);

	// Other 1-time initialization 
	gTemporaryRegion = MakeNewRgn();

	// Create a work port for our convenience
	// Use MAOperatorNew instead of TH_new or new for allocating the work port storage,
	// because we're not going to delete it and we don't need any complaints. 
	// Also note that we never close the work port. That's because the destructors
	// of static global objects may call functions that rely on it. 
#if qCarbon || !qMAGlobalNew
	void* pWorkPortStorage = NULL;	// Can't allocate it ourselves in Carbon
#else
	pWorkPortStorage = static_cast<CWindowRecord*>(MAOperatorNew(sizeof(CWindowRecord)));
#endif

	gWorkPort = NewCWindow(pWorkPortStorage, gZeroRect, gEmptyString,
				  		   false, documentProc, NULL, false, 0);

	::ThrowIfNULL_AC(gWorkPort);
	gWorkCPort = GetWindowCGrafPtr_AC(gWorkPort);

#if qMSWindows
	// can't test for this here in Windows because the menu bar isn't loaded
	// yet!  For now just assume multi-level undo.
#else
	// check for special case of single-undo
	short menu;
	short item;
	CommandToMenuItem(cUndoRedo, menu, item);
	if (menu)
		TUndoHandler::SetMaxDesiredItems(1);
#endif

	InitUClipboardMgr();

#if qAppleEventAware
	// create gServerAddress
	ProcessSerialNumber psn;
	psn.highLongOfPSN = 0;
	psn.lowLongOfPSN = kCurrentProcess;
	::ThrowIfOSErr_AC(AECreateDesc(typeProcessSerialNumber, (Ptr) & psn, sizeof(ProcessSerialNumber), &gServerAddress));
#endif

	// initialize the pseudo-random sequence generation function
	unsigned long time;
	GetDateTime(&time);
	srand((unsigned int)time);
}

//----------------------------------------------------------------------------------------
// RegisterCommonViews: 
//----------------------------------------------------------------------------------------

void RegisterCommonViews()
{
#if qTemplateViews
	{
		// =============================================== 
		// Suppress Linker dead stripping of these classes 
#if qDrag
		REGISTER_CLASS_AC(TDragDropBehavior);
#endif
		// =============================================== 

		REGISTER_SIGNATURE_AC(TView, kStdView);
		REGISTER_SIGNATURE_AC(TView, kStdDefaultView);
		REGISTER_SIGNATURE_AC(TIncludeView, kStdIncludeAt);
		REGISTER_SIGNATURE_AC(TWindow, kStdWindow);
		REGISTER_SIGNATURE_AC(TScrollBar, kStdScrollBar);
		REGISTER_SIGNATURE_AC(TScrollerScrollBar, kStdScrollerScrollBar);
		REGISTER_SIGNATURE_AC(TScroller, kStdScroller);

		REGISTER_SIGNATURE_AC(TDrawingEnvironment, kStdDrawingEnvironment);
	}
#endif

	InitUAdorners();							// Temporarily needed for debug window 

#if qDebug
	//InitUDialog(); //Necessary for debug dialog.
#if qPerform
	InitUTEView();
#endif

#endif
}

//----------------------------------------------------------------------------------------
// InstallIfPrintHandler: 
//----------------------------------------------------------------------------------------

void InstallIfPrintHandler(TPrintHandler* aPrintHandler,
						   TView* aView)

{
	// Install a copy of aPrintHandler into the view.
	if (aPrintHandler && aView)
	{
		TPrintHandler* aNewPrintHandler = static_cast<TPrintHandler*>(aPrintHandler->Clone());// signals failure if can't clone

		aNewPrintHandler->fView = aView;
		TDocument* itsDocument = aView->GetDocument();
		if (itsDocument)
			aNewPrintHandler->fDocument = itsDocument;// so the printinfo can be shared if necessary

		aNewPrintHandler->SetDefaultPrintInfo();// do this after we have a document (if any)

		//
		// Now do the attachments
		//
		if (itsDocument)
			itsDocument->AttachPrintHandler(aNewPrintHandler);
		aView->AttachPrintHandler(aNewPrintHandler);
	}
}

//----------------------------------------------------------------------------------------
// UseTemporaryRegion: Call this when you are about to use gTemporaryRegion and qDebug is
// true. Used with DoneWithTemporaryRegion will prevent you from trying to use
// gTemporaryRegion from two places at the same time.
//----------------------------------------------------------------------------------------

#if qDebug

void UseTemporaryRegion(const CStr255_AC& byWhom)
{
	if (gBusyTemporaryRegion)
	{
		ProgramReport_AC("'%s' is trying to lock gTemporaryRegion,", CChar255_AC(byWhom));
		ProgramReport_AC("but it is already locked by '%s'\n", CChar255_AC(gUsedBy));
		::ProgramBreak_AC("Error in UseTemporaryRegion");
	}
	else
	{
		gBusyTemporaryRegion = true;
		gUsedBy = byWhom;
	}
}

#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// GetIndVolume: 
// Note: It doesn't make sense to try to call PBXGetVolInfoSync for both Carbon and non-Carbon,
// as PBXGetVolInfoSync won't work on file systems that don't support 2 Terabyte volumes.  So,
// on the non-Carbon side, we'd still have to check gestaltFSSupports2TBVols and call either
// PBXGetVolInfoSync or PBGetVolInfoSync.  Given that PBGetVolInfoSync gives us what we want
// (the volume's refNum) for large or small volumes in non-Carbon, its simpler to leave 
// this code in.
//----------------------------------------------------------------------------------------

OSErr GetIndVolume(short index,
				   short& vRefNum)
{
#if qCarbon
	XVolumeParam pb;
	BlockZero_AC(pb);

	pb.ioVolIndex = index;

	OSErr err = PBXGetVolInfoSync(&pb);
	if (err == noErr)
		vRefNum = pb.ioVRefNum;
#else
	ParamBlockRec pb;
	BlockZero_AC(pb);

	pb.volumeParam.ioVolIndex = index;

	OSErr err = PBGetVInfoSync(&pb);
	if (err == noErr)
		vRefNum = pb.volumeParam.ioVRefNum;
#endif

	return err;
}

#if !qMSWindows

//----------------------------------------------------------------------------------------
// GetSysVolume: 
//----------------------------------------------------------------------------------------

OSErr GetSysVolume(short& vRefNum)
{
	long dir;

	return FindFolder((short)kOnSystemDisk, kSystemFolderType, false, &vRefNum, &dir);
}

//----------------------------------------------------------------------------------------
// VolHasDesktopDB: 
//----------------------------------------------------------------------------------------

OSErr VolHasDesktopDB(short vRefNum,
					  bool& hasDesktop)
{
	GetVolParmsInfoBuffer info;

	HParamBlockRec pb;
	pb.ioParam.ioCompletion = NULL;
	pb.ioParam.ioVRefNum = vRefNum;
	pb.ioParam.ioNamePtr = NULL;
	pb.ioParam.ioBuffer = (Ptr) & info;
	pb.ioParam.ioReqCount = sizeof(GetVolParmsInfoBuffer);

	OSErr err = ::PBHGetVolParmsSync(&pb);

	hasDesktop = err == noErr && info.vMAttrib & (1L << bHasDesktopMgr);

	return err;
}

//----------------------------------------------------------------------------------------
// FindAppOnVolume: 
//----------------------------------------------------------------------------------------

OSErr FindAppOnVolume(OSType sig,
					  short vRefNum,
					  CFSSpec_AC& thefile)
{
	OSErr err;

	DTPBRec pb;
	pb.ioCompletion = NULL;
	pb.ioVRefNum = vRefNum;
	pb.ioNamePtr = NULL;
	if ((err = PBDTGetPath(&pb)) == noErr)
	{
		short refNum = pb.ioDTRefNum;

		pb.ioCompletion = NULL;
		pb.ioDTRefNum = refNum;
		pb.ioIndex = 0;
		pb.ioFileCreator = sig;
		pb.ioNamePtr = (StringPtr)thefile.name;
		err = PBDTGetAPPLSync(&pb);					// Find it!

		if (err == fnfErr)
			err = afpItemNotFound;					// Bug in PBDTGetAPPL
		if (err == noErr)
		{
			thefile.vRefNum = vRefNum;
			thefile.parID = pb.ioAPPLParID;
		}
	}

	return err;
}

//----------------------------------------------------------------------------------------
// LaunchAppByFSSpec: 
//----------------------------------------------------------------------------------------

OSErr LaunchAppByFSSpec(const CFSSpec_AC& fileSpec,
						LaunchFlags launchControlFlags,
						ProcessSerialNumber& psn)
{
	CFSSpec_AC localFSSpec = fileSpec;				// so we can take its address below

	LaunchParamBlockRec pb;
	pb.launchBlockID = extendedBlock;
	pb.launchEPBLength = extendedBlockLen;
	pb.launchFileFlags = launchNoFileFlags;
	pb.launchControlFlags = launchControlFlags | launchNoFileFlags;
	pb.launchAppSpec = &localFSSpec;
	pb.launchAppParameters = NULL;

	OSErr err = LaunchApplication(&pb);
	if (err == noErr)
		psn = pb.launchProcessSN;

	return err;
}

//----------------------------------------------------------------------------------------
// LaunchBySignature: 
//----------------------------------------------------------------------------------------

OSErr LaunchBySignature(OSType sig,
						ProcessSerialNumber& psn,
						CFSSpec_AC* fileSpec,
						bool* launched,
						bool allowLaunch,
						LaunchFlags launchControlFlags)
{
	// First see if it's already running:
	OSErr err = FindProcessBySignature(sig, psn, fileSpec);

	if (launched)
		*launched = false;

	if (err == noErr && !(launchControlFlags & launchDontSwitch))
		err = SetFrontProcess(&psn);			// They wanted to switch to it�
	else if (err == procNotFound && allowLaunch)
	{
		// Well, it's not running but it's okay to launch it. Let's have a look around:

		short sysVRefNum;
		err = GetSysVolume(sysVRefNum); // Find boot volume

		short vRefNum = sysVRefNum;			// Start search with boot volume
		short index = 0;
		while (err == noErr)				// Keep going until we run out of vols
		{
			if (!index || vRefNum != sysVRefNum)
			{
				bool hasDesktopDB;

				if ((err = VolHasDesktopDB(vRefNum, hasDesktopDB)) != noErr)
					break;
				else if (hasDesktopDB)
				{
					// If volume has a desktop DB,
					CFSSpec_AC file;
					err = FindAppOnVolume(sig, vRefNum, file);// ask it to find app
					if (err == noErr)
					{
						// If found,
						if (fileSpec)
							*fileSpec = file;
						if (launched)
							*launched = true;
						err = LaunchAppByFSSpec(file, launchControlFlags, psn);// Launch it!
						break;
					}
					else if (err != afpItemNotFound && err != paramErr/* in case of Volume with no files (audio CD) */ )
						break;
				}
			}
			err = GetIndVolume(++index, vRefNum);// Else go to next volume
		} 

		if (err == nsvErr || err == afpItemNotFound)
			err = fnfErr;					// File not found on any volume
	}

	return err;
}

#endif

//----------------------------------------------------------------------------------------
// End of UMacAppGlobals.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/21/96	[1117870] (2-BYTE) TTEView and Left&Right Arrow
							[1115111] (2-BYTE) TTEView::GetNumberOfChars returns 0 after 1 character has been typed
							[1353017] (Double-byte) Second Character Lost
		05/25/96	[1353199] Potential memory leak when disposing windows.
		05/21/96	Replace calls to the ToolBox function ExitToShell with the standard C/C++ function exit.
							While eliminating another ToolBox dependency it also ensures static destructors get called.
		05/08/96	Create and use CFSSpec_AC. You should search/replace in your code to switch to
		 					CFSSpec_AC.
		05/08/96	Cleanup CRGBColor_AC and add new class CTextStyle_AC
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/26/96	Made C/CCoordPoint_AC/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CCoordPoint_AC/Rects.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Moved all the CTempxxx classes to UCoreUtilities
		04/23/96	Eliminated custom embedded FailInfo handling, derive from MDestructo
		04/20/96	Remove implementation of CTempRegion_AC::operator new
		----- R10 -----
		03/30/96	FailInfo has a default constructor so failInfo.Reset was redundant in CTempRegion_AC constructors
		03/26/96	Cleanup references to gEmptyString and ""
		03/26/96	coerce CStrxxx_AC to const char* to get copies of the strings as c style strings
		03/23/96	Use CStr2_AC in CompareAlertKeysToItem parameter.
		03/23/96	Made MinimalAlertFilter two byte character friendly.
		03/22/96	Added MACharacterByteType to UMacAppUtilities
		03/19/96	Commented out InitUDialog again.
		03/19/96	Removed support for CFront
		03/18/96	Remove compatibility hacks.
		02/13/96	Add Basic QDGX Initialization and Termination. 
		03/14/96	Replaced curly quotes with straight single quote.
		03/07/96	[1313793] (Printing) fSharePrintInfo not respected
		03/04/96	Remove gratuitous inlining, Removed ::Success in favor of FailInfo::Success,
		 					restructured Try macro to reduce code bulk by about 2400 bytes. Removed ::HandlerExists
		 					in favor of FailInfo::HandlerExists. Made gTopHandler a static member of FailInfo
		03/01/96	Re-arranged data members, natural alignment results in 
		 					reduced storage size.
							Grouped some globals and global functions as static members.
		02/23/96	CAShutdown crashes, even without parts, shutting down the 
							session. Cleaned up for 3.5dx release (ETO 20)
		12/18/95	Multiple undo. 
		12/13/95	Uncomment code to init gMacAppAlertFilter. 
		12/08/95	Move a lot of code to UCoreGlobals. 
							Split up includes for modular MacApp. 
		05/07/95	Add code to initialize and shutdown CALib. 
		  					Implement HasOpenDoc. 
		----- 3.3 -----
		11/02/95	Change signature of TDrawingEnvironment from 'SRF2' to
							kStdDrawingEnvironment. 
		10/30/95	Fix bug in LaunchBySignature that caused failure if an audio CD was mounted.
		10/19/95	1293874 Removed HasASLM due to ASLM removal vs. deinstall problems.
		----- 3.3b1 -----
		09/01/95	CTempRegion_AC:: operator new comment size parameter.
		09/01/95	CTempRegion_AC::operator new returns nil.
		07/30/95	Added MAHasGestalt
		07/28/95	Add configuration functions to use instead of gConfiguration. 
		07/22/95	Take out the call to InitUScripting from DoInitUMacApp. 
		07/07/95	Call PBGetVInfoSync instead of PBGetVInfo.
		06/18/95	Remove gStandardWindowMoveBounds, gStandardWindowSizeRect and
		 					gStandardWindowScreenRect. Change usage of fMoveBounds and fResizeLimits
							to be used only if non-zero. Otherwise, values are dynamically calculated
							in the new functions: GetDynamicMoveBounds and GetDynamicResizeLimits.
							This is because monitor location, resolution and size is now dynamic since
							System 7.5.
		05/17/95	#Include for USegments
		06/12/95	Support TOSADispatcher::fgDispatcher
		05/16/95	DialogRef
		05/16/95	ControlRef, WindowRef
		05/05/95	Test for qNeedsSystem7_5 in ValidateConfiguration
		04/14/95	Load segment in LockSegment
		04/24/95	remove heap expansion and SetStackSpace to UniversalStartup
		03/20/95	Move all Universal code required to Vet the hardware together
		 					And reduce the "universal" code to a bare minimum
							Eliminate extern visibility of InitToolBox. 
		 					Changed CWLockSegment to LockSegmentLow and call it in all cases.
		04/06/95	Add inclusion of <Errors.h> back.
		03/30/95	Change old includes (GestaltEQU, OSEvents) to new equivalents. 
		 					Add hack to get around CFront problems with Traps.h. 
		03/22/95	Comment out unnecessary includes. 
							Compatibility hacks for 2.0f1 headers. 
		03/18/95	Include UDrawingEnvironment. 
		03/17/95	Register a signature for TDrawingEnvironment. 
		 					Don't call SetEventMask to get key up events; this is now
							under the control of the application. 
		03/15/95	Clear gDispatcher before freeing so nobody can 
							refer to the object while it is being destructed. 
		03/10/95	Include Traps.h. 
		03/09/95	Changed ClassDesc NewByXXX functions to return a void* 
							instead of a TObject*. 
		03/06/95	Include UDialog.h.
		02/28/95	Move gSignatures to be a member of ClassDesc. 
							Use MA_REGISTER_CLASS and MA_REGISTER_SIGNATURE instead of
							macroDontDeadStrip and RegisterStdType. 
		02/22/95	1222784 set various const usage globals to const attribute
		02/21/95	Fix UPP definitions to work with OLDROUTINENAMES=0. 
		 					Use kUnresolvedCFragSymbolAddress. 
							Add compatibility hack so we can compile with the 1.0 headers. 
		02/20/95	Update for USESOLDROUTINENAMES=0. 
		02/19/95	Undo change to ParseTitleTemplate -- windows came up without
		 					titles. 
		02/13/95	make "p" (private) globals static 
		02/13/95	Remove unnecessary initialization of static variables. See ARM �8.4 
		02/07/95	1143831 Allow empty window titles via ParseTitleTemplate. 
		02/07/95	Create missing prototypes for static functions used internally. 
		01/26/95	Add hasAppleScript to configuration. 
		12/14/94	Fix backwards #if qModelCFM for call to unload _DataInit. 
		12/13/94	Turn off code that doesn't work with -modelCFM. 
		12/08/94	Some of the support should also work with CW 4.5. 
		12/07/94	Always define qd except under Metrowerks. This is
							the direction things are going and it works ok
							with the old libraries too. 
							Conditionalized Metrowerks support code that is
							needed only for CodeWarrior 4.5. 
		11/18/94	Conditionalize includes of Drag and OCEStandardMail. 
		11/17/94	Include Drag and OCEStandardMail. 
		11/17/94	Cast instances of kUnresolvedSymbolAddress to Ptr
							for compatibility w/pre-release headers.
		11/17/94	Fix CWLockSegment to not release the CODE resource.
							It may be in use. 
		11/14/94	We have to define qd for -modelCFM. 
		11/13/94	Call dontDeadStrip(TDragDropBehavior).
		11/11/94	Test for qPowerPC || qModelCFM. 
		11/11/94	Change qNeedsDrag to qDrag. Change qNeedsPowerTalk to
							qPowerTalk.  In PowerPC environment, we were verifying
							that routines that may exist in shared system libraries
							was present. We now test for qModelCFM.
		11/09/94	Add MW fix to lock down Main. 
		11/08/94	DefineConfiguration determines whether or not shared 
							libraries for Thread, AEOM, DragAndDrop are present
							on a PowerPC.  Added support for qNeedsDrag,
							qNeedsPowerTalk, and qNeedsThreads.
							This makes it safe to weak link these libraries and
							determine if they are present at runtime.
		11/07/94	Added qSegments. 
		11/02/94	Add mods to support unloading segments with Metrowerks
							68K, as per Mark Anderson. 
		10/27/94	Compile with ETO 15 prerelease headers. 
		10/21/94	Call InitUTEView so the performance monitor dialog
							will work. 
		09/23/94	Add disposal of global TScriptEventDispatcher
							to CleanUpMacApp.  Support move of
							gMacAppAppleEventIdleProc to UScripting.
		06/22/94	Add back patch to ExitToShell. 
		05/26/94	Add cleanup proc. 
*/