//----------------------------------------------------------------------------------------
// UMenuCommandTable.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		03/11/00	Use TCmdTableIterator instead of TCmdTable::Iterator.  Confuses
							MrCPP.
		02/24/00	[W] Workaround in IsInMenuBar, GetMenu, CommandToMenuItem
		01/05/00	Update copyright notice.
		01/05/00	In TCmdTable::CommandToMenuItem change the routine to work the way
							it was before (pre 11/22/99), so that the routine returns
							the first installed item OR the first item in a non-installed
							menu.  Calc uses its 'buzzwords' menu, which isn't installed,
							to set command names and thus depends on the old behavior.
		12/08/99	In TCmdTable::CommandToMenuItem, the while loop check (++index > fSize)
							was backwards (should be ++index <= fSize).
		11/22/99	Fix CommandToMenuItem to work properly again. 
		11/09/99	Replace the old EnableItem, DisableItem type calls with the 
							EnableMenuItems_AC and DisableMenuItems_AC. 
		11/05/99	Split off the menu command table to its own unit. 
							Add CCommandIterator. 
*/

#ifndef __UMenuCommandTable__
#include "UMenuCommandTable.h"
#endif

// MacApp

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

// ACS

#ifndef __MenuUtils_AC__
#include "MenuUtils_AC.h"
#endif

// Toolbox


//========================================================================================
// MenuCmdRecord:
//========================================================================================

//----------------------------------------------------------------------------------------
// MenuCmdRecord::CompareCommandNumber
//----------------------------------------------------------------------------------------

CompareResult_AC MenuCmdRecord::CompareCommandNumber(const MenuCmdRecord& criteria) const
{
	CompareResult_AC returnVal = kItemEqualCriteria_AC;

	if (fCommand > criteria.fCommand)
		returnVal = kItemGreaterThanCriteria_AC;
	else if (fCommand < criteria.fCommand)
		returnVal = kItemLessThanCriteria_AC;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// MenuCmdRecord::IsInMenuBar
//----------------------------------------------------------------------------------------

bool MenuCmdRecord::IsInMenuBar() const
{
#if qMSWindows
	return true;
#else
	return TMenuBarManager::IsInMenuBar(fMenuID);
#endif
}

//----------------------------------------------------------------------------------------
// MenuCmdRecord::GetMenu
//----------------------------------------------------------------------------------------

MenuRef MenuCmdRecord::GetMenu() const
{
#if qMSWindows
	#pragma message ("MenuCmdRecord::GetMenu: Implementation needed.")
	return NULL;
#else
	return (fMenuID > 0) ? MAGetMenu(fMenuID) : NULL;
#endif
}

//----------------------------------------------------------------------------------------
// MenuCmdRecord::Enable
//----------------------------------------------------------------------------------------

void MenuCmdRecord::Enable(bool canDo)
{
	MenuRef aMenuRef = GetMenu();
	if (aMenuRef)
		::Enable(aMenuRef, fItem, canDo);
}

//----------------------------------------------------------------------------------------
// MenuCmdRecord::EnableCheck: 
//----------------------------------------------------------------------------------------

void MenuCmdRecord::EnableCheck(bool canDo, bool checkIt)
{
	MenuRef aMenuRef = GetMenu();
	if (aMenuRef)
		::EnableCheck(aMenuRef, fItem, canDo, checkIt);
}

//----------------------------------------------------------------------------------------
// MenuCmdRecord::SetIcon: 
//----------------------------------------------------------------------------------------

void MenuCmdRecord::SetIcon(Byte menuIcon)
{
	MenuRef aMenuRef = GetMenu();
	if (aMenuRef)
		::SetItemIcon(aMenuRef, fItem, menuIcon);
}

//----------------------------------------------------------------------------------------
// MenuCmdRecord::SetName: 
//----------------------------------------------------------------------------------------

void MenuCmdRecord::SetName(ConstStr255Param itemString)
{
	MenuRef aMenuRef = GetMenu();
	if (aMenuRef)
		::SetMenuItemText(aMenuRef, fItem, itemString);
}

//----------------------------------------------------------------------------------------
// MenuCmdRecord::SetStyle: 
//----------------------------------------------------------------------------------------

void MenuCmdRecord::SetStyle(StyleParameter aStyle)
{
	MenuRef aMenuRef = GetMenu();
	if (aMenuRef)
		SetItemStyle(aMenuRef, fItem, aStyle);
}


//========================================================================================
// CLASS TCmdTable
//========================================================================================

//----------------------------------------------------------------------------------------
// TCmdTable constructor
//----------------------------------------------------------------------------------------

TCmdTable::TCmdTable(ArrayIndex_AC initialSize)
	:	TemplateSortedArray_AC<MenuCmdRecord>(initialSize)
{
}

//----------------------------------------------------------------------------------------
// TCmdTable destructor
//----------------------------------------------------------------------------------------

TCmdTable::~TCmdTable()
{
}

//----------------------------------------------------------------------------------------
// TCmdTable::Compare: 
//----------------------------------------------------------------------------------------

CompareResult_AC TCmdTable::Compare(const MenuCmdRecord& record1,
									const MenuCmdRecord& record2) const// override 
{
	return record2.CompareCommandNumber(record1);
}

//----------------------------------------------------------------------------------------
// TCmdTable::TestItem: 
//----------------------------------------------------------------------------------------

CompareResult_AC TCmdTable::TestItem(const MenuCmdRecord& anRecord,
										  void* yourDataPtr)
{
	return anRecord.CompareCommandNumber(*(MenuCmdRecord *)yourDataPtr);
}

//----------------------------------------------------------------------------------------
// TCmdTable::FindFirstOf: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC TCmdTable::FindFirstOf(CommandNumber theCommand) const
{
	ArrayIndex_AC index = kEmptyIndex_AC;

	if (theCommand >= 0)
	{
		// Find a menu item with the same command number. 
		MenuCmdRecord aMenuCmdRecord(theCommand, kNoResource_AC, 0);
		if (DoSearch(&TestItem, &aMenuCmdRecord, index))
		{
			// Back up to the first menu item with the same command number. 
			while (index - 1 > kEmptyIndex_AC)
			{
				aMenuCmdRecord = At(index - 1);
				if (aMenuCmdRecord.fCommand != theCommand)
					break;

				--index;
			}
		}
		else
		{
			// DoSearch didn't find anything. Fix the index so it's empty
			// instead of the insertion point. 
			index = kEmptyIndex_AC;
		}
	}

	return index;
}

//----------------------------------------------------------------------------------------
// TCmdTable::CommandToMenuItem: 
//----------------------------------------------------------------------------------------

void TCmdTable::CommandToMenuItem(CommandNumber theCommand,
								  MenuID& menu,
								  short& item) const
{
#if !qMSWindows
	if (theCommand < 0)							/* negative commands are mapped not table based */
	{
		menu = static_cast<short>((-theCommand) >> 8);
		item = static_cast<short>((-theCommand) & 255);
	}
	else
	{
		menu = 0;
		item = 0;

		// Find the first menu item with the same command. 
		ArrayIndex_AC index = FindFirstOf(theCommand);
		
		if (index > kEmptyIndex_AC)
		{
			// Skip forward until we find the item in the first installed menu;
			// however, if this item isn't in an installed menu, then find the
			// item in the last non-installed menu that has a match.
			
			MenuCmdRecord aMenuCmdRecord;
			do
			{
				aMenuCmdRecord = At(index);
				if (aMenuCmdRecord.fCommand == theCommand)
				{
					menu = aMenuCmdRecord.fMenuID;
					item = aMenuCmdRecord.fItem;

					if (TMenuBarManager::IsInMenuBar(aMenuCmdRecord.fMenuID))
						break;
				}

			} while ((++index <= fSize) && (aMenuCmdRecord.fCommand == theCommand));
		}
	}
#else
	#pragma unused (theCommand, menu, item)
	#pragma message("TCmdTable::CommandToMenuItem: Implementation needed.")
#endif
}

//----------------------------------------------------------------------------------------
// TCmdTable::CommandFromMenuItem: 
//----------------------------------------------------------------------------------------

CommandNumber TCmdTable::CommandFromMenuItem(short menu,
											 short item) const
// Given a menuID/item # return the appropriate command number. if there
// is no such command number, return -BOR(((menu) << 8), item).  If the
// item number is <0 then assume that it is a negative command number.
{
	CommandNumber returnVal = cNoCommand;

	if (item < 0)
		returnVal = -item;
	else
	{
		if (item > 0)
		{
			// Search the table linearly. 
			for (Iterator iter(this); iter; ++iter)
			{
				if ((menu == (*iter).fMenuID) && (item == (*iter).fItem))
				{
					returnVal = (*iter).fCommand;
					break;
				}
			}
		}

		if (returnVal == cNoCommand)
		{
#if qDebugMsg
			if ((menu > 127) || (item > 255))
			{
				ProgramReport_AC("menu : %1d , item : %1d \n", menu, item);
				ProgramReport_AC("Menu/item number is too big for a negative command number!\n");
				::ProgramBreak_AC("Try using a negative item number instead.");
			}
#endif
			returnVal = -((menu << 8) | item);
		}
	}
	
	return returnVal;
}

//----------------------------------------------------------------------------------------
// TCmdTable::AddCommand: 
//----------------------------------------------------------------------------------------

void TCmdTable::AddCommand(CommandNumber commandNumber,
						   MenuID menuNumber,
						   short itemNumber)
{
	if (commandNumber > 0)						// Negative numbers are mapped not tabled 
		Insert(MenuCmdRecord(commandNumber, menuNumber, itemNumber));
}

//----------------------------------------------------------------------------------------
// TCmdTable::InsertCommand:
//----------------------------------------------------------------------------------------

void TCmdTable::InsertCommand(CommandNumber commandNumber,
							  MenuID menuNumber,
							  short itemNumber)
{
	for (Iterator iter(this); iter; ++iter)
	{
		if (((*iter).fMenuID == menuNumber) && ((*iter).fItem >= itemNumber))
		{
			// If we have found an item in the same menu as we are adding to and it is
			// the same index or greater then bump its itemNumber
			++(*iter).fItem;
		}
	}

	// Insert the new menu item
	Insert(MenuCmdRecord(commandNumber, menuNumber, itemNumber));
}

//----------------------------------------------------------------------------------------
// TCmdTable::DeleteMenuCommand:
//----------------------------------------------------------------------------------------

void TCmdTable::DeleteMenuCommand(CommandNumber theMenuItemCommandNumber)
{
	short menuNumber;
	short itemNumber;
	CommandToMenuItem(theMenuItemCommandNumber, menuNumber, itemNumber);

	for (Iterator iter(this); iter; ++iter)
	{
		if ((*iter).fMenuID == menuNumber)
		{
			if ((*iter).fItem == itemNumber)
			{
				// Delete the element
				AtDelete(iter.CurrentIndex());
			}
			else if ((*iter).fItem > itemNumber)
			{
				// If we have found an item in the same menu as we are deleting from and its
				// index is greater then decrement its itemNumber
				--((*iter).fItem);
			}
		}
	}
}


//========================================================================================
// CLASS CCommandIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CCommandIterator constructor
//----------------------------------------------------------------------------------------

CCommandIterator::CCommandIterator(const TCmdTable* inList, CommandNumber theCommand)
	:	TCmdTableIterator(inList),
		fCommand(theCommand),
		fMenuCmdRecord(theCommand, kNoResource_AC, 0)
{
	First();
}

//----------------------------------------------------------------------------------------
// CCommandIterator::First
//----------------------------------------------------------------------------------------

MenuCmdRecord* CCommandIterator::First()
{
	fMenuCmdRecord.fMenuID = kNoResource_AC;
	fMenuCmdRecord.fItem = 0;

	fCurrentIndex = 0;
	fCurrentElement = NULL;

	if (fCommand < 0)
	{
		// negative commands are mapped not table based
		fMenuCmdRecord.fMenuID = static_cast<short>((-fCommand) >> 8);
		fMenuCmdRecord.fItem = static_cast<short>((-fCommand) & 255);

		// The iterator user wants a pointer to a MenuCmdRecord so here it is
		fCurrentElement = &fMenuCmdRecord;
	}
	else
	{
		const TCmdTable* inList = reinterpret_cast<const TCmdTable*>(fDynamicArray);
		fCurrentIndex = inList->FindFirstOf(fCommand);
		if (fCurrentIndex > kEmptyIndex_AC)
			fCurrentElement = &inList->At(fCurrentIndex);
	}

	return Current();
}

//----------------------------------------------------------------------------------------
// CCommandIterator::First
//----------------------------------------------------------------------------------------

MenuCmdRecord* CCommandIterator::Next()
{
	if (fCommand < 0)
	{
		// negative commands are mapped not table based
		fCurrentElement = NULL;
	}
	else
	{
		if (TCmdTableIterator::Next())
		{
			if (Current()->fCommand != fCommand)
			{
				fCurrentIndex = kEmptyIndex_AC;
				fCurrentElement = NULL;
			}
		}
	}

	return Current();
}


//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// Enable: 
//----------------------------------------------------------------------------------------

void Enable(MenuRef aMenuRef, short item, bool canDo)
{
	if (canDo)
		EnableMenuItems_AC(aMenuRef, item);
	else
		DisableMenuItems_AC(aMenuRef, item);
}

//----------------------------------------------------------------------------------------
// EnableCheck: 
//----------------------------------------------------------------------------------------

void EnableCheck(MenuRef aMenuRef, short item, bool canDo, bool checkIt)
{
	Enable(aMenuRef, item, canDo);
#if qSMWindows
	#pragma message ("EnableCheck: Implementation needed.")
#endif
	::MacCheckMenuItem(aMenuRef, item, checkIt);
}


//----------------------------------------------------------------------------------------
// UMenuCommandTable.cpp
