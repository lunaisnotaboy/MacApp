//----------------------------------------------------------------------------------------
// UScripting.cpp
// Copyright � 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		08/15/01	Don't construct a CAEDesc_AC from NULL -- the compiler thinks
					it's an AEDesc*. 
		07/18/01	Include stdlib.h.
		05/06/01	DidCarbonEvent requires qCarbonEvents. 
		05/04/01	Call DidCarbonEvent after handling an Apple Event. 
		01/22/01	Info in PreDispatchHandlerGlue and DispatchHandlerGlue is now
					a AEHandlerRefcon to match header.
		01/05/01	Change to use CString_AC instead of std::string.
		01/10/00	Don't cast to a reference. 
		01/04/00	Define a type for the refcon so we can compile with different
					versions of the headers. 
		01/02/01	AEEventHandlerProcPtr refcon changed back to long. 
					Make the callbacks really match the toolbox procptr definitions. 
					No longer need to cast procptrs when creating UPPs. 
		01/02/01	Update copyright.
		12/26/00	Avoid iostream footprint hit. 
		12/20/00	Include string and sstream (or strstream).  Using std::string and
					std::ostringstream (or ostrstream).  Pass string to MAParamText.
		12/15/00	Use string in place of CStr255_AC in ReportDispatchError.
		12/12/00	Changed CTempDesc_AC initialization in ResolveObjectList.
		11/09/00	[PB] Change initialization order to match declaration. 
					Remove unused local variables in GetAppleEventCommandNumber. 
		11/03/00	itsAddress cast to const AEAddressDesc in TSetPropertyEvent.
		11/01/00	AEInteraction is only in Universal Interfaces 3.3.5 and greater. 
		10/20/00	[C] Include AEInteraction.h, AEDataModel.h, AEObjects.h.
					Use NewAEIdleUPP, NewAEEventHandlerUPP, NewOSLAccessorUPP,
					NewOSLCompareUPP, NewOSLCountUPP, NewOSLDisposeTokenUPP,
					NewOSLGetMarkTokenUPP, NewOSLMarkUPP and NewOSLAdjustMarksUPP
					instead of NewAEIdleProc, NewAEEventHandlerProc, NewOSLAccessorProc,
					NewOSLCompareProc, NewOSLCountProc, NewOSLDisposeTokenProc,
					NewOSLGetMarkTokenProc, NewOSLMarkProc and NewOSLAdjustMarksProc.
		10/11/00	When optimizing a self-send event, perform the command directly. 
					The trick of returning a "not handled" error is bad because
					the Apple Event manager could give our event to a system handler. 
		09/20/00	No need to coerce const string to StringPtr in InitUScripting.
		03/31/00	Get pointee to test fgIdleProc and fDispatchUPP in
					InstallDispatchHandlers and fPreDispatchUPP in
					InstallPreDispatchHandler.  Removed some unnecessary conditionalized
					code.
		03/20/00	The objectDesc passed to ResolveObjectSpecifier can be const. 
					[2446249] Add ResolveObjectList. 
		02/23/00	Optimization in FreeTemporaryTokens.
		02/03/00	Look for subject attribute on create element events. 
		12/07/99	Removed developer identifying comment.  Include UDispatcher.h
					to get TCommandList.  Removed MrC specialization of fgDispatcher,
					and for throw in DispatchHandler.  Special handling of exception
					for MrC in PreDispatchHandlerGlue, ObjectAccessorGlue, CountObjectsGlue
					CompareObjectsGlue, DisposeTokenGlue, GetMarkTokenGlue, MarkObjectGlue
					and AdjustMarksGlue
		10/21/99	Use IsMenuItemEnabled_AC() instead of #if qCarbon stuff.
		09/28/99	Carbon: Get RemovePreDispatchHandler_AC and InstallPreDispatchHandler_AC
					compiling.
		08/09/99	Changed MA_REGISTER_CLASS to REGISTER_CLASS_AC.
					Changed ClassDesc to CClassRegistration_AC in InitUScripting.
		07/23/99	Use CountMenuItems instead of CountMItems in CountContainedObjects.
		03/24/99	Update copyright notice.
		03/19/99	Rename GetMessage to GetExceptionMessage
					since it conflicts with a Windows define.
		02/04/99	Changed GetDataHandle with dataHandle.
		01/15/99	CAEDesc_AC is now in ACS. 
		11/11/98	Carbon - in TOSADispatcher::InstallObjectCallbacks added casts for glue functions 
					to get around compile errors;
					In InstallDispatchHandlers added cast to AEIdleProcPtr for same reason.
		11/06/98	Carbon - change APIs of these procs to match latest headers:
					TOSADispatcher::PreDispatchHandlerGlue, TOSADispatcher::DispatchHandlerGlue
					Also made 1st param of ReportDispatchError 'const'
		11/05/98	Carbon - use SetQDGlobalsRandomSeed to set qd.randSeed
		10/29/98	GetCommandContext can't be const since it might return 'this'.
		10/26/98	Carbonize
		10/08/98	Add a GetSetPropertyInfo method to TPropertyAccessor. 
					MPurgeable. 
					PreDispatchHandler and DispatchHandler now perform any pending
					commands before returning. This makes it possible for commands
					to be posted the regular way and still be able to access the
					message and reply Apple Events. 
					Merge TCommandHandler into TEventHandler. 
					Made PostPendingReplyCommand be honest about expecting a TClientCommand. 
					TEventList is really a TCommandList. 
*/

#ifndef __USCRIPTING__
#include "UScripting.h"
#endif

#if qAppleEventAware

// MacApp

#ifndef __UCOMMANDHANDLER__
#include "UCommandHandler.h"
#endif

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USUBSTITUTION__
#include "USubstitution.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

// ACS

#ifndef __AEObjects_AC__
#include "AEObjects_AC.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __CListIterator_AC__
#include "CListIterator_AC.h"
#endif

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

#ifndef __MenuUtils_AC__
#include "MenuUtils_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// Toolbox

#if qCarbon
	#if UNIVERSAL_INTERFACES_VERSION >= 0x0335
		#ifndef __AEINTERACTION__
		#include <AEInteraction.h>
		#endif
	#endif
	
	#ifndef __AEDATAMODEL__
	#include <AEDataModel.h>
	#endif

	#ifndef __AEOBJECTS__
	#include <AEObjects.h>
	#endif
#endif

#ifndef __AEPACKOBJECT__
#include <AEPackObject.h>
#endif

#ifndef __AEREGISTRY__
#include <AERegistry.h>
#endif

#ifndef __ASREGISTRY__
#include <ASRegistry.h>
#endif

#ifndef __MENUS__
#include <Menus.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

// ANSI

#ifndef __STDLIB__
#include <stdlib.h>
#endif

//========================================================================================
// Static data allocations
//========================================================================================

CAutoPtr_AC<TOSADispatcher> TOSADispatcher::fgDispatcher;

//==================================================================================================
// class TOSADispatcher
//==================================================================================================
#undef Inherited


MA_DEFINE_CLASS(TOSADispatcher);

//----------------------------------------------------------------------------------------
// TOSADispatcher::InitUScripting
//----------------------------------------------------------------------------------------

void TOSADispatcher::InitUScripting(const char* className)
{
	if (!IsHighLevelEventAware())
	{
#if qDebug
		DebugStr("\p###Not HighLevelEventAware! Check SIZE resource.");
#endif
		abort();
	}

	if (TOSADispatcher::fgDispatcher.get())
	{
#if qDebugMsg
		ProgramReport_AC("Scripting already initialized\n");
#endif
	}
	else
	{
		ObjectInit_AC();
#if !qCarbon
		qd.randSeed = TickCount();
#else
		::SetQDGlobalsRandomSeed(TickCount());
#endif

		fgDispatcher = dynamic_cast_or_throw_AC(TOSADispatcher*, CClassRegistration_AC::NewByClassName(className));
	}
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::TOSADispatcher : 
//----------------------------------------------------------------------------------------

TOSADispatcher::TOSADispatcher()
	:	fDefaultTarget(NULL),
		fTemporaryTokens(NewList_AC()),
		fPendingReplyList(TH_new TCommandList),
		fDispatchLevel(0),
		fAEResolveFlags(kAEIDoMinimum | kAEIDoWhose | kAEIDoMarking),
#if qAttachable
		fAttachedScripts(0)
#endif
{
	InstallDispatchHandlers();
	InstallObjectCallbacks();
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::~TOSADispatcher : 
//----------------------------------------------------------------------------------------

TOSADispatcher::~TOSADispatcher()
{
	// dispose the routine descriptors allocated by this object	
	// ��� Should remove handlers first!!!
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::InstallDispatchHandlers : 
//----------------------------------------------------------------------------------------

// Just in case, this should be in a different segment than the glue it installs

void TOSADispatcher::InstallDispatchHandlers()
{
	if (!TAppleEvent::fgIdleProc)
	{
		// (Carbon) Cast MacAppAppleEventIdleProc since its API doesn't match exactly
		TAppleEvent::fgIdleProc = NewAEIdleUPP(MacAppAppleEventIdleProc);
		::ThrowIfNULL_AC(TAppleEvent::fgIdleProc.get());
	}

	if (!fDispatchUPP)
	{
		fDispatchUPP = NewAEEventHandlerUPP(DispatchHandlerGlue);
		::ThrowIfNULL_AC(fDispatchUPP.get());
	}

	short numberOfTables = MACount1Resources('aedt'); // count the number of table resources
	::ThrowIfResError_AC();
	
	for (short tableIndex = 1; tableIndex <= numberOfTables; ++tableIndex)
	{
		Handle tableHandle = MAGet1IndResource('aedt', tableIndex);
		::ThrowIfNULLResource_AC(tableHandle);
		CTempHandleLock_AC tempHandleLock(tableHandle, eDontMoveHi, eReleaseIt, eLockIt);

		Size tableSize = GetHandleSize(tableHandle);
		::ThrowIfMemError_AC();
		short tableElements = static_cast<short>(tableSize / sizeof(MAEventTableRec));
			
		MAEventTableRec *tablePtr = (MAEventTableRec*)*tableHandle;
			
		for (short eventIndex = 1; eventIndex <= tableElements; ++eventIndex)
		{
			// install the same event handler for all events
			::ThrowIfOSErr_AC(InstallEventHandler_AC(tablePtr->theClass, tablePtr->theID,
						 fDispatchUPP, tablePtr->theValue, false));
			++tablePtr;
		}
	}
}

#if qOptimizeSelfSendAevt
//----------------------------------------------------------------------------------------
// TOSADispatcher::OptimizeCommand: 
//----------------------------------------------------------------------------------------

void TOSADispatcher::OptimizeCommand(const TCommand* command)
{
	if (!fOptimizeCommands.GetEqualItemNo(command))
		fOptimizeCommands.Insert(command);
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::RemoveOptimizeCommand: 
//----------------------------------------------------------------------------------------

void TOSADispatcher::RemoveOptimizeCommand(const TCommand* command)
{
	fOptimizeCommands.Delete(const_cast<TCommand*>(command));
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::IsOptimizedCommand: 
//----------------------------------------------------------------------------------------

bool TOSADispatcher::IsOptimizedCommand(const TCommand* command) const
{
	bool found = false;

	for (TemplateIterator_AC<TCommand*> iter(&fOptimizeCommands); iter; ++iter)
	{
		if (iter == command)
		{
			found = true;
			break;
		}
	}

	return found;
}

#endif // qOptimizeSelfSendAevt

#if qAttachable

//----------------------------------------------------------------------------------------
// TOSADispatcher::ScriptAttached : 
//----------------------------------------------------------------------------------------

void TOSADispatcher::ScriptAttached()
{
	if (++fAttachedScripts == 1)
		InstallPreDispatchHandler();
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::ScriptDetached : 
//----------------------------------------------------------------------------------------

void TOSADispatcher::ScriptDetached()
{
#if qDebug
	::Assertion_AC(fAttachedScripts >= 0, "Too many calls to ScriptDetached");
#endif
	if (!(--fAttachedScripts))
		RemovePreDispatchHandler();
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::InstallPreDispatchHandler : 
//----------------------------------------------------------------------------------------

// Just in case, this should be in a different segment than the glue it installs

void TOSADispatcher::InstallPreDispatchHandler()
{
	if (HasAppleScript_AC())
	{	
		if  (!fPreDispatchUPP)
		{
			fPreDispatchUPP = NewAEEventHandlerUPP(PreDispatchHandlerGlue);
			::ThrowIfNULL_AC(fPreDispatchUPP.get());
		}
		::ThrowIfOSErr_AC(InstallPreDispatchHandler_AC(fPreDispatchUPP.get(), false));
	}
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::RemovePreDispatchHandler : 
//----------------------------------------------------------------------------------------

void TOSADispatcher::RemovePreDispatchHandler()
{
	if (HasAppleScript_AC() && fPreDispatchUPP)
		::ThrowIfOSErr_AC(RemovePreDispatchHandler_AC(fPreDispatchUPP.get(), false));
}

#endif // qAttachable

//----------------------------------------------------------------------------------------
// TOSADispatcher::InstallObjectCallbacks : 
//----------------------------------------------------------------------------------------

// Just in case, this should be in a different segment than the glue it installs

void TOSADispatcher::InstallObjectCallbacks()
{
// ���  Added casts for Carbon, since definitions in AEObjects.h changed from define to typedef

	// install the universal object accessor
	fAccessorUPP = NewOSLAccessorUPP(ObjectAccessorGlue);
	::ThrowIfOSErr_AC(InstallObjectAccessor_AC(typeWildCard, typeWildCard, fAccessorUPP, 0, false));
	
	fCompareUPP = NewOSLCompareUPP(CompareObjectsGlue);
	fCountUPP = NewOSLCountUPP(CountObjectsGlue);
	fDisposeTokenUPP = NewOSLDisposeTokenUPP(DisposeTokenGlue);
	fGetMarkTokenUPP = NewOSLGetMarkTokenUPP(GetMarkTokenGlue);
	fMarkUPP = NewOSLMarkUPP(MarkObjectGlue);
	fAdjustMarksUPP = NewOSLAdjustMarksUPP(AdjustMarksGlue);
	
	::ThrowIfOSErr_AC(SetObjectCallbacks_AC(fCompareUPP, fCountUPP, fDisposeTokenUPP,
											fGetMarkTokenUPP, fMarkUPP, fAdjustMarksUPP, NULL));
//#endif
}

#if qAttachable

//----------------------------------------------------------------------------------------
// TOSADispatcher::PreDispatchHandler : 
//----------------------------------------------------------------------------------------

OSErr TOSADispatcher::PreDispatchHandler(CommandNumber	aCommandNumber,
										TAppleEvent* 	message,
									 	TAppleEvent*	reply)
{
	OSErr err = noErr;
		
	try
	{
		MScriptableObject* targetObject = GetTargetObject(aCommandNumber, message);
		if (!targetObject->HandleOSAEvent(aCommandNumber, message, reply)) 
			err = errAEEventNotHandled;

		// Do any pending commands
#if qCarbonEvents
		if (gDispatcher->UseCarbonEvents())
			gDispatcher->DidCarbonEvent();
		else
#endif
			gDispatcher->DoPendingCommands();
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		// if the event is an "exists" event and the target was not found
		// return false instead of an error

		if (aCommandNumber == cAEDoObjectsExist && theException.GetError() == errAENoSuchObject)
			dynamic_cast_or_throw_AC(TAppleEvent*,reply)->WriteBoolean(keyAEResult, false);
		else
			throw;
	}
	
		
	return err;
}

#endif // qAttachable

//----------------------------------------------------------------------------------------
// TOSADispatcher::DispatchHandler : 
//----------------------------------------------------------------------------------------

OSErr TOSADispatcher::DispatchHandler(	CommandNumber	aCommandNumber,
										TAppleEvent* 	message,
									 	TAppleEvent*	reply)
{
	OSErr err = noErr;
	
	try
	{
		TScriptableObjectList 	*theObjectList;
		bool					targetIsContainer = false;

		MScriptableObject* targetObject = GetTargetObject(aCommandNumber, message);
	
		if (targetObject->GetOMClass() == cScriptableObjectList)
		{
			theObjectList = dynamic_cast_or_throw_AC(TScriptableObjectList*, targetObject);
			targetObject = theObjectList->GetObjectsContainer();
			targetIsContainer = true;
		}
		
#if qOptimizeSelfSendAevt
		TCommand* command = reinterpret_cast<TCommand*>(message->GetTransactionID());
		if (IsOptimizedCommand(command))
		{
			if (targetObject->GetCommandContext(aCommandNumber) != command->GetContext())
			{
#if qDebug
				ProgramBreak_AC("Command made an incorrect object specifier!");
#endif
				err = minErr;	// this is a program error
			}
			else
			{
				// Since the Apple Event came from a command in this application,
				// as an optimization we can just do it. 
				TCommand::PerformSelfSendCommand(command);
			}
		}
		else
#endif
		{
			// print events directed at objects other than the application
			// need to be handled as cPrint commands. 
			if (aCommandNumber == cFinderPrint && targetObject != gDispatcher)
				aCommandNumber = cPrint;
				
			if (targetIsContainer)
				targetObject->DoAEOnContainedObjects(theObjectList, aCommandNumber, message, reply);
			else
				targetObject->HandleScriptCommand(aCommandNumber, message, reply);
		}

		// Do any pending commands
#if qCarbonEvents
		if (gDispatcher->UseCarbonEvents())
			gDispatcher->DidCarbonEvent();
		else
#endif
			gDispatcher->DoPendingCommands();
	}
	catch(CException_AC& theException)
	{	
		DoCatchMessage_AC(theException);
		// if the event is an "exists" event and the target was not found
		// return false instead of an error

		if (aCommandNumber == cAEDoObjectsExist && theException.GetError() == errAENoSuchObject)
			dynamic_cast_or_throw_AC(TAppleEvent*,reply)->WriteBoolean(keyAEResult, false);
		else
			throw;
	}

	return err;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::ReportDispatchError :
// Note: This function is invoked when an error occurs during processing of an incoming
// AppleEvent. All calls to subroutines must call resident code. Apple event manager
// calls are made directly, rather than through TAppleEvent, to eliminate dependencies
// on non-resident code.
//----------------------------------------------------------------------------------------

void TOSADispatcher::ReportDispatchError(const AppleEvent* 	messageEvent,
										 AppleEvent* 		replyEvent,
										 OSErr				dispatchErr,
										 long				dispatchErrMessage)
{
	Boolean sentToSelf = false;
	bool interactWithUser = false;
	bool senderWantsReply = false;
	OSErr	err;
	
	if (messageEvent)
	{
		ProcessSerialNumber eventPSN;
		DescType			actualType;
		Size				actualSize;
		AESendMode			sendMode;
		
		err = AEGetAttributePtr(messageEvent, keyAddressAttr, typeProcessSerialNumber,
								&actualType, &eventPSN, sizeof(ProcessSerialNumber), &actualSize);
		if (err == noErr)
			::SameProcess(&eventPSN, gDispatcher, &sentToSelf);
		
		err = ::AEGetAttributePtr(messageEvent, keyInteractLevelAttr, typeShortInteger,
								  &actualType, &sendMode, sizeof(short), &actualSize);
		if (err == noErr)
			senderWantsReply = (sendMode & kAEReplyModeMask) != kAENoReply;
	}
	
	if (!sentToSelf && !senderWantsReply)
	{
		// pass NULL for the idling proc. incoming events right now might
		// cause memory problems
		interactWithUser = MAInteractWithUserNoIdleProc() == noErr;
	}
			
	// Put up a dialog if:
	//   1) we are not responding to an event sent by ourself AND
	//   2) the client doesn't expect a reply AND
	//   3) user interaction is acceptable.
	
	if (!sentToSelf && !senderWantsReply && interactWithUser)
		gDispatcher->ShowError(dispatchErr, dispatchErrMessage);
	
	if (replyEvent && replyEvent->descriptorType != typeNull && replyEvent->dataHandle)
	{
		long 	failureError = dispatchErr;	// needs to be a signed long
		CString_AC	errorString;

		AEPutParamPtr(replyEvent, keyErrorNumber, typeLongInteger, &failureError, sizeof(long));
		if (!LookupErrString(dispatchErr, errReasonID, errorString))
		{
			// No error string was found, substitute the generic one.
			CString_AC errNumString;
			stringprintf(errNumString, "%ld", dispatchErr);
			MAParamText(CString_AC("^ENUM"), errNumString);
			LookupErrString(errGenericErrorWithNum, errReasonID, errorString);
			MAReplaceText(errorString);
		}

		AEPutParamPtr(replyEvent, keyErrorString, typeChar,
					  errorString.c_str(), errorString.size());
	}
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::GetTargetObject : 
//----------------------------------------------------------------------------------------

MScriptableObject* TOSADispatcher::GetTargetObject(	CommandNumber aCommandNumber,
													TAppleEvent* appleEvent)
{
	MScriptableObject* targetObject = NULL;
	
	// If the event is a create element event,
	// use the insertion object.
	CTempDesc_AC objectDesc;
	if (aCommandNumber == cAECreateElement)
	{
		OSErr err = AEGetAttributeDesc(appleEvent, keySubjectAttr, typeObjectSpecifier, objectDesc);
		if (err != noErr)
			err = appleEvent->ReadParameter(keyAEInsertHere, typeWildCard, objectDesc);

		if (err != errAEDescNotFound)
			::ThrowIfOSErr_AC(err);
	}

	// Get the direct object of the event. 
	if (objectDesc.GetDescriptorType() == typeNull)
	{
		OSErr err = appleEvent->ReadParameter(keyDirectObject, typeWildCard, objectDesc);
		if (err != errAEDescNotFound)
			::ThrowIfOSErr_AC(err);
	}
	
	// Resolve the object desc. 
	if (objectDesc.GetDescriptorType() == typeInsertionLoc)
	{
		CTempDesc_AC insertionDesc;

		::ThrowIfOSErr_AC(AECoerceDesc(objectDesc, typeAERecord, insertionDesc));
		::ThrowIfOSErr_AC(objectDesc.DisposeDesc());
		insertionDesc.GetKeyDesc(keyAEObject, typeWildCard, objectDesc);
		appleEvent->WriteParameter(keyDirectObject, objectDesc);
	}

	if (objectDesc.GetDescriptorType() == cAEList)
		targetObject = ResolveObjectList(objectDesc);
	else if (objectDesc.GetDescriptorType() != typeNull)
		targetObject = ResolveObjectSpecifier(objectDesc);

	if (!targetObject)
		targetObject = GetDefaultTarget();

	return targetObject;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::ResolveObjectList
//----------------------------------------------------------------------------------------

MScriptableObject* TOSADispatcher::ResolveObjectList(const CAEDesc_AC& listDesc)
{
	MScriptableObject* targetObject = NULL;

	CAutoPtr_AC<TScriptableObjectList> theList(TH_new TScriptableObjectList);
	
	long numObjects = listDesc.CountListItems();
	for (long myIndex = 1; myIndex <= numObjects; ++myIndex)
	{
		CTempDesc_AC objectDesc(listDesc.GetNthItem(myIndex, typeWildCard));
		if (objectDesc.GetDescriptorType() == typeObjectSpecifier)
		{
			MScriptableObject* indexedObject = ResolveObjectSpecifier(objectDesc);
			if (indexedObject)
				theList->InsertLast(indexedObject);
		}
	}
	
	// Now check for at least one good object
	if (theList->GetSize() > 0)
	{
		// Set container (not known initially, assume all objects have same as first)
		theList->fContainer = static_cast<MScriptableObject*>(theList->First())->GetObjectsContainer();
		
		targetObject = theList.release();
		TOSADispatcher::fgDispatcher->AddTemporaryToken(targetObject);
	}
	else
		targetObject = GetDefaultTarget();

	return targetObject;
}


//----------------------------------------------------------------------------------------
// TOSADispatcher::ResolveObjectSpecifier
//----------------------------------------------------------------------------------------

MScriptableObject* TOSADispatcher::ResolveObjectSpecifier(const CAEDesc_AC& objectDesc)
// Ask the OSL to resolve an object specifier. 
// This will initiate a dialog between the OSL
// and our object resolution callbacks. 
{
	MScriptableObject* result = NULL;
			
	if (objectDesc.GetDescriptorType() == typeObjectSpecifier)
	{
		CTempDesc_AC tokenDesc;
		
		::ThrowIfOSErr_AC(Resolve_AC(objectDesc, fAEResolveFlags, tokenDesc));
		result = GetObject(tokenDesc);
	}
	else
		result = GetDefaultTarget();
	
	return result;
}

//----------------------------------------------------------------------------------------
// GetAppleEventCommandNumber: return the commandNumber associated with a specific
// event class and ID.
//----------------------------------------------------------------------------------------

CommandNumber TOSADispatcher::GetAppleEventCommandNumber(AEEventClass 	eventClass,
														 AEEventID 		eventID)
{
	long theCommandNumber = 0;

	AEEventHandlerUPP eventHandler = NULL;
	OSErr err = GetEventHandler_AC(eventClass, eventID, &eventHandler, &theCommandNumber, false);
	if (err != noErr)
		theCommandNumber = 0;
		
	return theCommandNumber;
}


//----------------------------------------------------------------------------------------
// TOSADispatcher::ObjectAccessor : Handles the AccessContainedObjects OSL callback by
// asking the container object to return a reference to a specific contained object. If
// the object was created for object resolution, and requires disposal later, it is added
// to the temp tokens list.
//----------------------------------------------------------------------------------------

void TOSADispatcher::ObjectAccessor(DescType 	desiredClass,
									const CAEDesc_AC& 	container,
									DescType	/* containerClass */,
									DescType 	form,
									const CAEDesc_AC& 	selectionData,
									CAEDesc_AC& 	value,
									long		/* accessorRefcon */)
{
	MScriptableObject *containerObject = GetObject(container);
	if (!containerObject)
		containerObject = fDefaultTarget;
		
	MScriptableObject *resultObject = containerObject->GetContainedObject(desiredClass, form, selectionData);
	if (!resultObject)
		::ThrowIfOSErr_AC(errAENoSuchObject);
	
	PutObject(value, resultObject);
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::CountObjects: Handle the OSL CountObjects callback by asking
// a container object to count the contained objects of a certain type.
//----------------------------------------------------------------------------------------

long TOSADispatcher::CountObjects(	DescType 	desiredType,
									DescType 	/*containerClass*/,
								   	const CAEDesc_AC& 	container)
{
	return GetObject(container)->CountContainedObjects(desiredType);
} 

//----------------------------------------------------------------------------------------
// TOSADispatcher::CompareObjects: Handle the OSL CompareObjects callback by asking
// the target object to compare itself to another object.
//----------------------------------------------------------------------------------------

bool TOSADispatcher::CompareObjects(	DescType 	whichOperation,
										const CAEDesc_AC& 	targetDesc,
										const CAEDesc_AC& 	thingToCompare)
{
	return GetObject(targetDesc)->CompareScriptableObjects(whichOperation, thingToCompare);
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::DisposeToken: The OSL calls this method after object resolution but
// before the event is processed. After an event is processed, all temporary tokens
// are disposed.
//----------------------------------------------------------------------------------------

void TOSADispatcher::DisposeToken(CAEDesc_AC& unneededToken)
{
	::ThrowIfOSErr_AC(unneededToken.DisposeDesc());
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::GetMarkToken: Before marking a set of objects, the OSL asks for a
// token to contain them.  MacApp provides a TScriptableObjectList.
//----------------------------------------------------------------------------------------

void TOSADispatcher::GetMarkToken(const CAEDesc_AC& theContainerToken,
								   DescType	/*containerClass*/,
								   CAEDesc_AC& result)
{
	MScriptableObject *containerObject = GetObject(theContainerToken);
	TScriptableObjectList *theMarkingList = containerObject->MakeNewMarkingList();
	::ThrowIfNonObject_AC(theMarkingList);
	PutObject(result, theMarkingList);
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::MarkObject: OSL is requesting the specified object be marked.
//----------------------------------------------------------------------------------------

void TOSADispatcher::MarkObject(const CAEDesc_AC&	theToken,
								const CAEDesc_AC&	markingListToken,
								long				index)
{
	#pragma unused (index)

	TScriptableObjectList *theMarkingList = dynamic_cast_or_throw_AC(TScriptableObjectList*, GetObject(markingListToken));
	MScriptableObject *objectToMark = GetObject(theToken);
	theMarkingList->InsertMarkedObject(objectToMark);
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::AdjustMarks: 
//----------------------------------------------------------------------------------------

void TOSADispatcher::AdjustMarks(long 		newStart,
								 long 		newStop,
								 const CAEDesc_AC& 	markToken)
{
	// Ask the TAppleObjectList marking list to adjust the items it contains.
	TScriptableObjectList *theMarkingList = dynamic_cast_or_throw_AC(TScriptableObjectList*, GetObject(markToken));
	theMarkingList->AdjustMarks(newStart, newStop);
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::PostPendingReplyCommand: 
//----------------------------------------------------------------------------------------

void TOSADispatcher::PostPendingReplyCommand(TClientCommand* command)
{
	fPendingReplyList->Insert(command);
}


//----------------------------------------------------------------------------------------
// TOSADispatcher::MatchReplyToPending: 
//----------------------------------------------------------------------------------------

void TOSADispatcher::MatchReplyToPending(TAppleEvent* reply)
{
	TClientCommand * theMatchedCommand = NULL;

	// Higher priority events are at the end of the list.
	for (TemplateIterator_AC<TClientCommand*> iter(fPendingReplyList, kIterateBackward_AC); iter; ++iter)
		if ((*iter).GetReturnID() == reply->GetReturnID())
		{
			theMatchedCommand = iter;
			break;
		}

	if (theMatchedCommand)
	{
		fPendingReplyList->Delete(theMatchedCommand);
		theMatchedCommand->ProcessReply(reply);
		theMatchedCommand->GetContext()->PostCommand(theMatchedCommand);
	}
	else
		::ThrowIfOSErr_AC(errAEEventNotHandled);
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::GetTemporaryTokens
//----------------------------------------------------------------------------------------

CList_AC* TOSADispatcher::GetTemporaryTokens()
{
	return fTemporaryTokens;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::AddTemporaryToken: Insert an object into the temp tokens list.
// Temp tokens will be discarded after the target is resolved and the event is executed.
//----------------------------------------------------------------------------------------

void TOSADispatcher::AddTemporaryToken(MScriptableObject* tempToken)
{
	if (fTemporaryTokens->GetEqualItemNo(tempToken) == kEmptyIndex_AC)
		fTemporaryTokens->InsertLast(tempToken);
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::FreeTemporaryTokens: 
//----------------------------------------------------------------------------------------

void TOSADispatcher::FreeTemporaryTokens()
{
	// Frees all the objects in the temp token list.
	if (fDispatchLevel < 1 && fTemporaryTokens->GetSize() > 0)
	{
		try
		{
			for (TemplateIterator_AC<MScriptableObject*> iter(fTemporaryTokens); iter; ++iter)
				delete iter.Current();
			fTemporaryTokens->DeleteAll();
		}
		catch(CException_AC& theException)
		{
			DoCatchMessage_AC(theException);
		}
	}
}

#if qAttachable

//----------------------------------------------------------------------------------------
// TOSADispatcher::PreDispatchHandlerGlue : AppleScript does not send the refCon
// associated with the standard dispatch handler for the event.
//----------------------------------------------------------------------------------------

pascal OSErr TOSADispatcher::PreDispatchHandlerGlue(const AppleEvent* message,
													AppleEvent* reply,
													AEHandlerRefcon	info)
{
	#pragma unused (info)

	OSErr dispatchErr = noErr;
	long dispatchErrMessage = 0;

	++TOSADispatcher::fgDispatcher->fDispatchLevel;

	try
	{
		TAppleEvent messageEvent(*message, false);
		TAppleEvent replyEvent(*reply, false);
		
		AEEventClass eventClass = messageEvent.ReadEventClass();
		AEEventID eventID = messageEvent.ReadEventID();
		CommandNumber eventCommand = TOSADispatcher::fgDispatcher->GetAppleEventCommandNumber(eventClass, eventID);
	
		dispatchErr = TOSADispatcher::fgDispatcher->PreDispatchHandler(eventCommand, &messageEvent, &replyEvent);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		dispatchErr = theException.GetError();				// Don't propogate the error.
		dispatchErrMessage = theException.GetExceptionMessage();	
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::PreDispatchHandlerGlue: Foreign exception caught.");
	#endif
		dispatchErr = minErr;
	}
#endif
	
	if (dispatchErr != noErr && dispatchErr != errAEEventNotHandled)
		TOSADispatcher::fgDispatcher->ReportDispatchError(message, reply, dispatchErr, dispatchErrMessage);
		
	--TOSADispatcher::fgDispatcher->fDispatchLevel;
	TOSADispatcher::fgDispatcher->FreeTemporaryTokens();

	return dispatchErr;
}

#endif // qAttachable

//----------------------------------------------------------------------------------------
// TOSADispatcher::DispatchHandlerGlue
//----------------------------------------------------------------------------------------

pascal OSErr TOSADispatcher::DispatchHandlerGlue(const AppleEvent* 	message,
												 AppleEvent* 		reply,
												 AEHandlerRefcon	info)
{
	OSErr dispatchErr = noErr;
	long dispatchErrMessage =  0;
	bool matchedToPending = false;

	TAppleEvent* messageEvent = NULL;
	TAppleEvent* replyEvent = NULL;

	CommandNumber itsCommand = (CommandNumber)info;
	
	++TOSADispatcher::fgDispatcher->fDispatchLevel;

	try
	{
		messageEvent = TH_new TAppleEvent(*message, false);
		replyEvent = TH_new TAppleEvent(*reply, false);
		
		if (itsCommand == cAppleEventReply)		// handle incoming replies to client commands
		{
			TOSADispatcher::fgDispatcher->MatchReplyToPending(messageEvent);
			matchedToPending = true;
		}
		else
			dispatchErr = TOSADispatcher::fgDispatcher->DispatchHandler(itsCommand, messageEvent, replyEvent);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		dispatchErr = theException.GetError();				// Do not propogate the error.
		dispatchErrMessage = theException.GetExceptionMessage();	
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::DispatchHandlerGlue: Foreign exception caught.");
	#endif
		dispatchErr = minErr;
	}
#endif
	
	
	if (dispatchErr != noErr && dispatchErr != errAEEventNotHandled)
		TOSADispatcher::fgDispatcher->ReportDispatchError(message, reply, dispatchErr, dispatchErrMessage);

	--TOSADispatcher::fgDispatcher->fDispatchLevel;
	TOSADispatcher::fgDispatcher->FreeTemporaryTokens();
		
	// delete the message only if it wasn't matched to a pending command
	if (!matchedToPending)
		delete messageEvent;
	delete replyEvent;
	
	return dispatchErr;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::ObjectAccessorGlue
//----------------------------------------------------------------------------------------

pascal OSErr TOSADispatcher::ObjectAccessorGlue(DescType desiredClass,
												const AEDesc* container,
												DescType containerClass,
												DescType form,
												const AEDesc* selectionData,
												AEDesc* value,
												long accessorRefcon)
{
	OSErr result = noErr;
	
	try
	{
		TOSADispatcher::fgDispatcher->ObjectAccessor(desiredClass, 
													 *reinterpret_cast<const CAEDesc_AC*>(container), 
													 containerClass, form, 
													 *reinterpret_cast<const CAEDesc_AC*>(selectionData), 
													 *reinterpret_cast<CAEDesc_AC*>(value), 
													 accessorRefcon);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		result = theException.GetError();
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::ObjectAccessorGlue: Foreign exception caught.");
	#endif
		result = minErr;
	}
#endif

	return result;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::CountObjectsGlue
//----------------------------------------------------------------------------------------

pascal OSErr TOSADispatcher::CountObjectsGlue(DescType desiredType,
											  DescType containerClass,
											  const AEDesc* container,
											  long* result)
{
	OSErr err = noErr;
	
	try
	{
		*result =  TOSADispatcher::fgDispatcher->CountObjects(desiredType, containerClass, container);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		err = theException.GetError();
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::CountObjectsGlue: Foreign exception caught.");
	#endif
		err = minErr;
	}
#endif

	return err;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::CompareObjectsGlue
//----------------------------------------------------------------------------------------

pascal OSErr TOSADispatcher::CompareObjectsGlue(DescType whichOperation,
												const AEDesc* obj1,
												const AEDesc* obj2,
												Boolean* result)
{
	OSErr err = noErr;

	try
	{
		*result = TOSADispatcher::fgDispatcher->CompareObjects(whichOperation, obj1, obj2);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		err = theException.GetError();
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::CompareObjectsGlue: Foreign exception caught.");
	#endif
		err = minErr;
	}
#endif
	

	return err;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::DisposeTokenGlue
//----------------------------------------------------------------------------------------

pascal OSErr TOSADispatcher::DisposeTokenGlue(AEDesc* unneededToken)
{
	OSErr result = noErr;

	try
	{
		TOSADispatcher::fgDispatcher->DisposeToken(*reinterpret_cast<CAEDesc_AC*>(unneededToken));
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		result = theException.GetError();
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::DisposeTokenGlue: Foreign exception caught.");
	#endif
		result = minErr;
	}
#endif	

	return result;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::GetMarkTokenGlue
//----------------------------------------------------------------------------------------

 pascal OSErr TOSADispatcher::GetMarkTokenGlue(const AEDesc* containerToken,
											   DescType containerClass,
											   AEDesc* result)
{
	OSErr err = noErr;

	try
	{
		TOSADispatcher::fgDispatcher->GetMarkToken(*reinterpret_cast<const CAEDesc_AC*>(containerToken),
												   containerClass,
												   *reinterpret_cast<CAEDesc_AC*>(result));
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		err = theException.GetError();
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::GetMarkTokenGlue: Foreign exception caught.");
	#endif
		err = minErr;
	}
#endif

	return err;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::MarkObjectGlue
//----------------------------------------------------------------------------------------

pascal OSErr TOSADispatcher::MarkObjectGlue(const AEDesc *dToken,
											const AEDesc *markToken,
											long index)
{
	OSErr result = noErr;

	try
	{
		TOSADispatcher::fgDispatcher->MarkObject(*reinterpret_cast<const CAEDesc_AC*>(dToken),
												 *reinterpret_cast<const CAEDesc_AC*>(markToken),
												 index);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		result = theException.GetError();
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::MarkObjectGlue: Foreign exception caught.");
	#endif
		result = minErr;
	}
#endif

	return result;
}

//----------------------------------------------------------------------------------------
// TOSADispatcher::AdjustMarksGlue
//----------------------------------------------------------------------------------------

pascal OSErr TOSADispatcher::AdjustMarksGlue(long newStart,
											 long newStop,
		 									 const AEDesc* markToken)
{
	OSErr result = noErr;

	try
	{
		TOSADispatcher::fgDispatcher->AdjustMarks(newStart, newStop,
												  *reinterpret_cast<const CAEDesc_AC*>(markToken));
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		result = theException.GetError();
	}
#if defined(__SC__) || defined(__MRC__)
	// MrCpp exceptions cannot cross the boundary of os callbacks.
	catch(...)
	{
	#if qDebug
		ProgramBreak_AC("TOSADispatcher::AdjustMarksGlue: Foreign exception caught.");
	#endif
		result = minErr;
	}
#endif

	return result;
}

//==================================================================================================
// Class COptimizeCommand
//==================================================================================================
#undef Inherited

#if qOptimizeSelfSendAevt
//----------------------------------------------------------------------------------------
// COptimizeCommand constructor
//----------------------------------------------------------------------------------------

COptimizeCommand::COptimizeCommand(TCommand* command) :
	fCommand(command)
{
	TOSADispatcher::fgDispatcher->OptimizeCommand(fCommand);
}

//----------------------------------------------------------------------------------------
// COptimizeCommand destructor
//----------------------------------------------------------------------------------------

COptimizeCommand::~COptimizeCommand()
{
	if (fCommand)
	{
		TOSADispatcher::fgDispatcher->RemoveOptimizeCommand(fCommand);
		fCommand = NULL;
	}
}

#endif // qOptimizeSelfSendAevt

//==================================================================================================
// Class TSetPropertyCommand
//==================================================================================================
#undef Inherited
#define Inherited TCommand

//----------------------------------------------------------------------------------------
// TSetPropertyCommand::TSetPropertyCommand
//----------------------------------------------------------------------------------------

TSetPropertyCommand::TSetPropertyCommand(DescType theProperty,
										 CList_AC* theObjectsToSet,
										 TAppleEvent* message,
										 TAppleEvent* /*reply*/) :
	fProperty(theProperty),
	fOldPropData(),
	fNewPropData()
{
	// We take charge of the temporary objects in the disposal list so we can use them
	// during execution of this command.
	// We'll free these when we commit.
	CList_AC* theDisposalList = TOSADispatcher::fgDispatcher->GetTemporaryTokens();
	fObjectsToFree = static_cast<CList_AC*>(theDisposalList->Clone());
	theDisposalList->DeleteAll();

	// We'll clone the list so the caller can free it immediately.
	fObjectsToSet = static_cast<CList_AC*>(theObjectsToSet->Clone());

	// Get the info for this command from the object.
	CommandNumber cmdNum = cNoCommand;
	bool canUndo = false;
	bool causesChange = true;
	TEventHandler* itsContext = NULL;

	MScriptableObject* theFirstObject = (MScriptableObject*)theObjectsToSet->At(1);
	::ThrowIfNULL_AC(theFirstObject);
	theFirstObject->GetSetPropertyInfo(theProperty, cmdNum, canUndo, causesChange, itsContext);

	fContext = itsContext;
	fObjectToNotify = itsContext;
	fCanUndo = canUndo;
	fCausesChange = causesChange;
	fIdentifier = cmdNum;

	message->ReadParameter(keyAEData, typeWildCard, fNewPropData);
}

//----------------------------------------------------------------------------------------
// TSetPropertyCommand::~TSetPropertyCommand
//----------------------------------------------------------------------------------------


TSetPropertyCommand::~TSetPropertyCommand()
{
	if (fObjectsToFree)
	{
		while (fObjectsToFree->GetSize() > 0)
			delete static_cast<MScriptableObject*>(fObjectsToFree->Pop());
	}
}

//----------------------------------------------------------------------------------------
// TSetPropertyCommand::DoIt
//----------------------------------------------------------------------------------------


void TSetPropertyCommand::DoIt()
{
	CAEDesc_AC theOldPropList;
	if (fCanUndo)
	{
		theOldPropList.CreateList();

		for (TemplateIterator_AC<MScriptableObject*> iter(fObjectsToSet); iter; ++iter)
		{
			CTempDesc_AC thePropData;
			(*iter).GetObjectProperty(thePropData, fProperty, CAEDesc_AC::fgNullDesc);
			::ThrowIfOSErr_AC(AEPutDesc(theOldPropList, 0, thePropData));
		}
	}
	fOldPropData = theOldPropList;
		
	RedoIt();
}

//----------------------------------------------------------------------------------------
// TSetPropertyCommand::UndoIt
//----------------------------------------------------------------------------------------


void TSetPropertyCommand::UndoIt()
{
	CAEDesc_AC theOldPropData(fOldPropData);
	::Assertion_AC(theOldPropData.dataHandle != NULL, "Trying to undo with no data!");

	short listIndex = 1;

	for (TemplateIterator_AC<MScriptableObject*> iter(fObjectsToSet); iter; ++iter)
	{
		CTempDesc_AC theOldPropDesc;
		DescType theActualKey;
		::ThrowIfOSErr_AC(AEGetNthDesc(theOldPropData, listIndex++, typeWildCard, &theActualKey, theOldPropDesc));

		(*iter).SetObjectProperty(theOldPropDesc, fProperty);
	}
}

//----------------------------------------------------------------------------------------
// TSetPropertyCommand::RedoIt
//----------------------------------------------------------------------------------------

void TSetPropertyCommand::RedoIt()
{
	CAEDesc_AC thePropData(fNewPropData);
	for (TemplateIterator_AC<MScriptableObject*> iter(fObjectsToSet); iter; ++iter)
		(*iter).SetObjectProperty(thePropData, fProperty);
}

//----------------------------------------------------------------------------------------
// TSetPropertyCommand::TotalSize
//----------------------------------------------------------------------------------------

Size TSetPropertyCommand::TotalSize(bool justLocked) const
{
	// ��� fObjectsToSet
	// ��� fObjectsToFree
	return fOldPropData.TotalSize(justLocked) +
		   fNewPropData.TotalSize(justLocked);
}


//========================================================================================
// TPropertyAccessor
//========================================================================================
#undef Inherited


MA_DEFINE_CLONE(TPropertyAccessor);

//----------------------------------------------------------------------------------------
// TPropertyAccessor::TPropertyAccessor
//----------------------------------------------------------------------------------------

TPropertyAccessor::TPropertyAccessor(MScriptableObject* whichObject,
										  DescType whichProperty) :
	MScriptableObject(cProperty),

	fWhichObject(whichObject),
	fWhichProperty(whichProperty)
{
}

//----------------------------------------------------------------------------------------
// TPropertyAccessor destructor
//----------------------------------------------------------------------------------------


TPropertyAccessor::~TPropertyAccessor()
{
}

//----------------------------------------------------------------------------------------
// TPropertyAccessor::GetCommandContext
//----------------------------------------------------------------------------------------


TEventHandler* TPropertyAccessor::GetCommandContext(const CommandNumber aCommandNumber)
{
	TEventHandler *commandHandler = NULL;
	
	if (fWhichObject)
	{	
		commandHandler = dynamic_cast_AC(TEventHandler*, fWhichObject);
		if (commandHandler)
			commandHandler = commandHandler->GetContext(aCommandNumber);

		if (!commandHandler)
			commandHandler = fWhichObject->GetCommandContext(aCommandNumber);
	}
	
	if (!commandHandler)
		commandHandler = MScriptableObject::GetCommandContext(aCommandNumber);
	
	return commandHandler;
}

//----------------------------------------------------------------------------------------
// TPropertyAccessor::DoScriptCommand
//----------------------------------------------------------------------------------------


void TPropertyAccessor::DoScriptCommand(CommandNumber 	aCommandNumber,
										TAppleEvent*	message,
								   		TAppleEvent* 	reply)
{
	// Handles GetData and SetData for this property.
	try
	{
		switch (aCommandNumber)
		{
			case cAEGetData:
				{
					CTempDesc_AC requestedType;
					if (message->HasParameter(keyAERequestedType))
						message->ReadParameter(keyAERequestedType, typeWildCard, requestedType);
					
					CTempDesc_AC thePropertyValue;
					fWhichObject->GetObjectProperty(thePropertyValue, fWhichProperty, requestedType);
					reply->WriteParameter(keyAEResult, thePropertyValue);
					break;
				}
			case cAESetData:
				{
					CList_AC aOneObjectList;

					aOneObjectList.InsertLast(fWhichObject);
					TSetPropertyCommand * theCmd = TH_new TSetPropertyCommand(fWhichProperty, &aOneObjectList, message, reply);

					theCmd->Process();
					break;
				}
			default:
				MScriptableObject::DoScriptCommand(aCommandNumber, message, reply);
				break;
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		reply->WriteOSError(theException.GetError());
	}
	
}

//----------------------------------------------------------------------------------------
// TPropertyAccessor::CompareScriptableObjects
//----------------------------------------------------------------------------------------


bool TPropertyAccessor::CompareScriptableObjects(DescType operation,
												 const CAEDesc_AC& thingToCompare)
{
	// Compares the properties.
	return fWhichObject->CompareProperties(fWhichProperty, operation, thingToCompare);
}

//----------------------------------------------------------------------------------------
// TPropertyAccessor::GetSetPropertyInfo
//----------------------------------------------------------------------------------------


void TPropertyAccessor::GetSetPropertyInfo(DescType whichProperty,
										   CommandNumber& cmdNum,
										   bool& canUndo,
										   bool& causesChange,
										   TEventHandler* &theContext)
// Needed for expressions that produce a list of object properties. 
// TSetPropertyCommand will call GetSetPropertyInfo on the first
// property accessor in the list. The property accessor needs
// to pass the call to the real object. 
{
	fWhichObject->GetSetPropertyInfo(whichProperty, cmdNum, canUndo, causesChange, theContext);
}

//----------------------------------------------------------------------------------------
// TPropertyAccessor::SetObjectProperty
//----------------------------------------------------------------------------------------


void TPropertyAccessor::SetObjectProperty(const CAEDesc_AC& thePropertyValue,
										  DescType whichProperty)
{
	fWhichObject->SetObjectProperty(thePropertyValue, whichProperty);
}

//----------------------------------------------------------------------------------------
// TPropertyAccessor::GetObjectProperty
//----------------------------------------------------------------------------------------


bool TPropertyAccessor::GetObjectProperty(CAEDesc_AC& thePropertyValue,
											 DescType whichProperty,
											 const CAEDesc_AC& desiredType)
{
	return fWhichObject->GetObjectProperty(thePropertyValue, whichProperty, desiredType);
}

//----------------------------------------------------------------------------------------
// TPropertyAccessor::DoAEGetDataSize
//----------------------------------------------------------------------------------------


void TPropertyAccessor::DoAEGetDataSize(TAppleEvent* message,
										TAppleEvent* reply)
{
	CTempDesc_AC requestedType;
	if (message->HasParameter(keyAERequestedType))
		message->ReadParameter(keyAERequestedType, typeWildCard, requestedType);
	
	CTempDesc_AC thePropertyValue;
	fWhichObject->GetObjectProperty(thePropertyValue, fWhichProperty, CAEDesc_AC::fgNullDesc);
	long theSize = thePropertyValue.GetDataSize();
	reply->WriteLong(keyAEResult, theSize);
}

#if qAttachable

//----------------------------------------------------------------------------------------
// TPropertyAccessor::HandleOSAEvent:
//----------------------------------------------------------------------------------------


bool TPropertyAccessor::HandleOSAEvent(	CommandNumber 	aCommandNumber,
											TAppleEvent* 	message,
											TAppleEvent* 	reply)
{
	message->WriteType(keyAEProperty, fWhichProperty);
	return fWhichObject->HandleOSAEvent(aCommandNumber, message, reply);
}

#endif // qAttachable

//----------------------------------------------------------------------------------------
// TScriptableObjectList
//----------------------------------------------------------------------------------------
#undef Inherited
#define Inherited CList_AC


MA_DEFINE_CLASS(TScriptableObjectList);

//----------------------------------------------------------------------------------------
// TScriptableObjectList::TScriptableObjectList
//----------------------------------------------------------------------------------------

TScriptableObjectList::TScriptableObjectList(MScriptableObject* itsContainer)
	:	CList_AC(),
		MScriptableObject(cScriptableObjectList),
		fContainer(itsContainer)
{
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList destructor
//----------------------------------------------------------------------------------------


TScriptableObjectList::~TScriptableObjectList()
{
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList::DoAECountElements
//----------------------------------------------------------------------------------------


void TScriptableObjectList::DoAECountElements(TAppleEvent* /*message*/,
										 TAppleEvent* reply)
{
	// If we say "get number of (windows whose name contains "untitled")" OSL builds a
	// TAppleObjects list of TWindows that satisfies the whose test then calls this method.
	reply->WriteLong(keyAEResult, GetSize());
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList::DoScriptCommand
//----------------------------------------------------------------------------------------


void TScriptableObjectList::DoScriptCommand(CommandNumber	aCommandNumber,
											TAppleEvent* 	message,
								   			TAppleEvent* 	reply)
{
	if (aCommandNumber == cAECountElements)
		MScriptableObject::DoScriptCommand(aCommandNumber, message, reply);
	else
	{
		CTempDesc_AC theReplyList;
		theReplyList.CreateList();
		// Calls DoScriptCommand for all the objects in the list.
		for (TemplateIterator_AC<MScriptableObject*> iter(this); iter; ++iter)
		{
			iter.Current()->DoScriptCommand(aCommandNumber, message, reply);
			CTempDesc_AC theEventReply;
			if (reply->HasParameter(keyAEResult))
			{
				reply->ReadParameter(keyAEResult, typeWildCard, theEventReply);
				::ThrowIfOSErr_AC(AEPutDesc(theReplyList, 0, theEventReply));
			}
		}
		if (reply->dataHandle)
			reply->WriteParameter(keyAEResult, theReplyList);
	}
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList::InsertMarkedObject
//----------------------------------------------------------------------------------------


void TScriptableObjectList::InsertMarkedObject(MScriptableObject* theObjectMarked)
{
	// Adds the marked object to the list
	InsertLast(theObjectMarked);
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList::AdjustMarks
//----------------------------------------------------------------------------------------


void TScriptableObjectList::AdjustMarks(long newStart,
								   long newStop)
{
	// The OSL may occasionally change its mind about which objects should be marked.
	// This routine makes the adjustments.
	long numToDelete = GetSize() - newStop;
	if (numToDelete > 0)
		DeleteElementsAt(newStop + 1, numToDelete);
	numToDelete = newStart - 1;
	if (numToDelete > 0)
		DeleteElementsAt(1, numToDelete);
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList::GetObjectsContainer
//----------------------------------------------------------------------------------------


MScriptableObject* TScriptableObjectList::GetObjectsContainer()
{
	return fContainer;
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList::IsPropertyList
//----------------------------------------------------------------------------------------


bool TScriptableObjectList::IsPropertyList()
{
	// How do we know if this is a list of properties and not of objects?
	// We could walk down the list and make sure each element was a TPropertyAccessor,
	// but that adds overhead for large lists.
	// I haven't been able to think of a situation where objects and properties are operated
	// on at the same time and would be in the same list, so lets just check the first one.
	// I believe that even complex object specifiers can only refer to objects of the same class
	// and in the same container.

	MScriptableObject * theFirstObject = NULL;
	if (fSize > 0)
		theFirstObject = (MScriptableObject *)At(1);
	return theFirstObject && theFirstObject->GetOMClass() == cProperty;
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList::GetContainedObject
//----------------------------------------------------------------------------------------


MScriptableObject* TScriptableObjectList::GetContainedObject(DescType desiredType,
											  DescType selectionForm,
											  const CAEDesc_AC& selectionData)
{
	// This method is needed when a complex object specifier has resolved into a list of objects,
	// but then actually wants a property from each one.
	// We handle this by building up a list of contained objects from each object in this list.

	CAutoPtr_AC<TScriptableObjectList> theNewList(TH_new TScriptableObjectList(GetObjectsContainer()));

	for (TemplateIterator_AC<MScriptableObject*> iter(this); iter; ++iter)
	{
		MScriptableObject *theResult = (*iter).GetContainedObject(desiredType, selectionForm, selectionData);
		if (!theResult)
			::ThrowIfOSErr_AC(errAENoSuchObject);
		theNewList->InsertLast(theResult);
	}
	TOSADispatcher::fgDispatcher->AddTemporaryToken(theNewList);

	return theNewList.release();
}

//----------------------------------------------------------------------------------------
// TScriptableObjectList::CountContainedObjects
//----------------------------------------------------------------------------------------


long TScriptableObjectList::CountContainedObjects(DescType desiredType)
// Adds up CountContainedObjects for all objects in the list.
{
	long result = 0;

	for (TemplateIterator_AC<MScriptableObject*> iter(this); iter; ++iter)
		result += (*iter).CountContainedObjects(desiredType);

	return result;
}

//----------------------------------------------------------------------------------------
// TSetPropertyEvent
//----------------------------------------------------------------------------------------
#undef Inherited
#define Inherited TAppleEvent

//----------------------------------------------------------------------------------------
// TSetPropertyEvent::TSetPropertyEvent
//----------------------------------------------------------------------------------------

TSetPropertyEvent::TSetPropertyEvent(const CAEDesc_AC&		itsAddress,
									 long					itsSendingMode,
									 MScriptableObject*		objectToSet,
									 DescType				propType)
	:	TAppleEvent(kAECoreSuite, kAESetData,
					(const AEAddressDesc&)CAEDesc_AC(itsAddress),
					itsSendingMode)
{
	// Initializes the event with the recipient, sending mode, the object you want to set and the 
	// property you want to modify. Creates an object specifier for the object's property and 
	// sticks it in the direct object.

	CAEDesc_AC objectSpecifier;
	CAEDesc_AC theProperty;
	objectToSet->MakeObjectSpecifier(objectSpecifier, objectToSet->GetSpecifierForm());

	theProperty.PutType(propType);
	CTempDesc_AC propertyToSet;
	::ThrowIfOSErr_AC(CreateObjSpecifier(cProperty, objectSpecifier, formPropertyID, theProperty, true, propertyToSet));
	WriteParameter(keyDirectObject, propertyToSet);
}

//----------------------------------------------------------------------------------------
// TSetPropertyEvent destructor
//----------------------------------------------------------------------------------------


TSetPropertyEvent::~TSetPropertyEvent()
{
}

//----------------------------------------------------------------------------------------
// TMenuAccessor
//----------------------------------------------------------------------------------------
#undef Inherited

//----------------------------------------------------------------------------------------
// TMenuAccessor::TMenuAccessor
//----------------------------------------------------------------------------------------

TMenuAccessor::TMenuAccessor(MenuRef theMenu, short theIndex) :
	MScriptableObject(cMenu),

	fMenu(theMenu),
	fIndex(theIndex)
{
}

//----------------------------------------------------------------------------------------
// TMenuAccessor destructor
//----------------------------------------------------------------------------------------


TMenuAccessor::~TMenuAccessor()
{
}

//----------------------------------------------------------------------------------------
// TMenuAccessor::GetObjectProperty
//----------------------------------------------------------------------------------------


bool TMenuAccessor::GetObjectProperty(CAEDesc_AC& thePropertyValue,
										 DescType whichProperty,
										 const CAEDesc_AC& desiredType)
{
	bool hasProperty = true;

	try
	{
		switch (whichProperty)
		{
	
			case pName:
				{
#if !qCarbon
					thePropertyValue.PutString(CString_AC(static_cast<Str255&>((**fMenu).menuData)));
#else
					Str255 theMenuName;
					::GetMenuTitle(fMenu, theMenuName);
					thePropertyValue.PutString(CString_AC(theMenuName));
#endif
				}
				break;
				
			case pIndex:
				{
					thePropertyValue.PutLong(fIndex);
				}
				break;
	
			case pMenuID:
				{
					thePropertyValue.PutLong(static_cast<long>(GetMenuID_AC(fMenu)));
				}
				break;
	
			default:
				hasProperty = MScriptableObject::GetObjectProperty(thePropertyValue, whichProperty, desiredType);
				break;
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		hasProperty = false;
	}
	

	return hasProperty;
}

//----------------------------------------------------------------------------------------
// TMenuAccessor::SetObjectProperty: 
//----------------------------------------------------------------------------------------


void TMenuAccessor::SetObjectProperty(const CAEDesc_AC& thePropertyValue,
									  DescType whichProperty)
{
	switch (whichProperty)
	{
		case pName:
		case pMenuID:
			::ThrowIfOSErr_AC(errAECantSetReadOnly);
			break;

		default:
			MScriptableObject::SetObjectProperty(thePropertyValue, whichProperty);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TMenuAccessor::GetContainedObject
//----------------------------------------------------------------------------------------


MScriptableObject* TMenuAccessor::GetIndContainedObject(DescType desiredType,
													   long index)
{
	MScriptableObject* returnVal = NULL;

	if (desiredType == cMenuItem)
	{
		// Create a menu item accessor to handle events for this menu item
		TMenuItemAccessor* theAccessor = TH_new TMenuItemAccessor(fMenu, static_cast<short>(index));
		TOSADispatcher::fgDispatcher->AddTemporaryToken(theAccessor);
		returnVal = theAccessor;
	}
	else
		returnVal = MScriptableObject::GetIndContainedObject(desiredType, index);
	
	return returnVal;
}

//----------------------------------------------------------------------------------------
// TMenuAccessor::CountContainedObjects
//----------------------------------------------------------------------------------------


long TMenuAccessor::CountContainedObjects(DescType desiredType)
	// Returns the number of menu item in a menu.
{
	return desiredType == cMenuItem ? CountMenuItems(fMenu) : MScriptableObject::CountContainedObjects(desiredType);
}

//----------------------------------------------------------------------------------------
// TMenuItemAccessor
//----------------------------------------------------------------------------------------
#undef Inherited

//----------------------------------------------------------------------------------------
// TMenuItemAccessor::TMenuItemAccessor
//----------------------------------------------------------------------------------------

TMenuItemAccessor::TMenuItemAccessor(MenuRef theMenu, short theItem) :
	MScriptableObject(cMenuItem),

	fMenu(theMenu),
	fMenuItem(theItem)
{
}

//----------------------------------------------------------------------------------------
// TMenuItemAccessor destructor
//----------------------------------------------------------------------------------------


TMenuItemAccessor::~TMenuItemAccessor()
{
}

//----------------------------------------------------------------------------------------
// TMenuItemAccessor::GetObjectProperty
//----------------------------------------------------------------------------------------


bool TMenuItemAccessor::GetObjectProperty(CAEDesc_AC& thePropertyValue,
											 DescType whichProperty,
											 const CAEDesc_AC& desiredType)
{
	bool hasProperty = true;

	try
	{
		switch (whichProperty)
		{
	
			case pName:
				{
					Str255 theItemName;
					GetMenuItemText(fMenu, fMenuItem, theItemName);
					thePropertyValue.PutString(CString_AC(theItemName));
				}
				break;
				
			case pItemNumber:
			case pIndex:
				thePropertyValue.PutLong(fMenuItem);
				break;
	
			case pEnabled:
				thePropertyValue.PutBoolean(IsMenuItemEnabled_AC(fMenu, fMenuItem));
				break;
	
			default:
				hasProperty = MScriptableObject::GetObjectProperty(thePropertyValue, whichProperty, desiredType);
				break;
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		hasProperty = false;
	}
	

	return hasProperty;
}

//----------------------------------------------------------------------------------------
// TMenuItemAccessor::SetObjectProperty: 
//----------------------------------------------------------------------------------------

void TMenuItemAccessor::SetObjectProperty(const CAEDesc_AC& thePropertyValue,
									  DescType whichProperty)
{
	switch (whichProperty)
	{
		case pName:
		case pItemNumber:
		case pEnabled:
			::ThrowIfOSErr_AC(errAECantSetReadOnly);
			break;

		default:
			MScriptableObject::SetObjectProperty(thePropertyValue, whichProperty);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TMenuItemAccessor::DoAEOpen
//----------------------------------------------------------------------------------------

void TMenuItemAccessor::DoAEOpen(TAppleEvent* message, TAppleEvent* reply)
{
#pragma unused (message, reply)

	gDispatcher->MenuEvent(GetMenuID_AC(fMenu), fMenuItem);
}

//----------------------------------------------------------------------------------------
// InitUScripting
//----------------------------------------------------------------------------------------
void InitUScripting()
{
	REGISTER_CLASS_AC(TOSADispatcher);

	TOSADispatcher::InitUScripting("TOSADispatcher");
}

#endif	// #if qAppleEventAware

//----------------------------------------------------------------------------------------
// End of UScripting.cpp



/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		06/09/96	Removed UStreamable to a separate file from UObject
		05/21/96	Replace calls to the ToolBox function ExitToShell with the standard C/C++ function exit.
							While eliminating another ToolBox dependency it also ensures static destructors get called.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/07/96	Made TAppleEvent derive from CAEDesc_AC as well as TObject.
		05/07/96	Added MAVolatile for variables accessed in recovery or dropthru of exception handling..
		05/07/96	Made CAEDesc_AC a derivative of AEDesc.
		05/07/96	Use enums for parameters of CTempHandleLock_AC constructor.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/29/96	Create and use functions that return their data as results for:
							TStream::ReadCharacter/CCoordPoint_AC/Rect/CCoordRect_AC/RGBColor/String. Create compatible inlines
							so users don't have to change their code.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		02/21/96	1302769 Changed ReportDispatchError to return dispatchErr.
		12/08/95	Bring back MAInteractWithUser. 
							Split up includes for modular MacApp. 
		----- 3.3 -----
		11/02/95	Fix qOptimizeSendSelfAevt conditionals.
		11/02/95	Use long instead of OSErr in ReportDispatchError.
		11/02/95	Add TPropertyAccessor::GetCommandContext.
							Add qOptimizeSendSelfAevt.
		11/01/95	Glue should be resident. 
		11/01/95	Call success in FreeTemporaryTokens FailInfo.
		11/01/95	Dispatch level is incremented/decremented in the glue functions.
							Glue calls FreeTemporaryTokens. FreeTemporaryTokens swallows
							errors.
							Use kMacAppTimeout in calls to InteractWithUser.
		11/01/95	Make drag cursor and script idle code resident. 
		10/31/95	ReportDispatchError takes AppleEvents rather than TAppleEvents.
							ReportDispatchError doesn't do anything that might cause a
							segment load.
		10/31/95	cFinderPrint commands are converted to cPrint if the target
							is not the application.
		10/31/95	Added MAVolatile to Pre/DispatchHandlerGlue routines.  1297768
		10/30/95	Added check for AEEventNotHandled in PreDispatchHandlerGlue and
							DisptachHandlerGlue's error reporting.
		10/27/95	Remove fMessageWasMatchedToPending. Move call to
							MatchReplyToPending into DispatchHandlerGlue to eliminate
							reliance on static fMessageWasMatchedToPending.
							Add ReportDispatchError. DispatchHandlerGlue and
							PreDispatchHandlerGlue call ReportDispatchError and
							NEVER propogate failures out of the callback.
							Correct test that determines if interaction is allowed.
		10/25/95	Add fMessageWasMatchedToPending.
		10/25/95	TOSADispatcher::PreDispatchHandler and DispatchHandler now
							resignal the error rather than just returning it.
							PreDispatchHandlerGlue and DispatchHandlerGlue now catch errors
							and decide if user interface should take place or if a reply is sent
							to the client.  1290392
		10/24/95	Replace calls to GetBestType with GetSpecifierForm.
		10/21/95	Use GetBestType() in calls to MakeObjectSpecifier. 
		10/19/95	PreDispatchHandler and DispatchHandler handle "exists" errors
							when the target object is not found.
		09/26/95	[1276050] Added TMenuAccessor::SetObjectProperty and check for
		 					read-only properties [pName, pMenuID]. Added TMenuItemAccessor::
		 					SetObjectProperty and check for read-only properties [pName,
							pItemNumber, pEnabled].  TPropertyAccessor::DoScriptCommand now
							processes the set property command rather than posts.
		09/20/95	TScriptableObjectList::GetContainedObject fails with
		 					errAENoSuchObject if an object can't be accessed.
		----- 3.3b1 -----
		09/06/95	Initialize and Dispose TAppleEvent::fgIdleProc.
		08/31/95	Changed TSetPropertyCommand back to a TCommand.
		09/01/95	TSetProperty constructor wasn't intializing fObjectsToFree.
		  					Clean up of TSetProperty constructor/destuctor.
		08/30/95	Made TSetPropertyCommand suspend.  Added some failure handling
		 					and put a TObjectIterator inside a block inside a failure block.
		08/29/95	Report an error in TOSADispatcher::DispatchHandlerGlue
							if the user interaction level is set appropriately.
							TSetPropertyCommand now derives from TServerCommand.
		08/10/95	Add fAttachedScripts, ScriptAttached, ScriptDetached and
							RemovePreDispatchHandler. 
							Merge segment OSLDispatchRes into MAOSLDispatch. 
		07/28/95	Add configuration functions to use instead of gConfiguration. 
		07/27/95	Conditionalize attachability support. 
		07/26/95	Use OSAID instead of COSAScript. 
		07/25/95	Move fgGenericScriptingComponent to COSAScript. 
							Remove GetGenericComponent. 
		07/21/95	Add the ability to install a custom scripting dispatcher. 
		07/03/95	Add fAEResolveFlags. (requested by Bob Krause)
		 					"InsertHere" param in a create element event is written back
							into the event as the direct object.
		06/28/95	Reorder scripting method params.
		06/19/95	GetMarkToken wasn't casting the right object. Actually don't
		 					need to cast at all. 
							Dynamic casting expressions is inefficient. 
		06/16/95	Support MI in TRecipient, TScriptableObjectList, TMenuAccessor,
		 					TMenuItemAccessor, & TPropertyAccessor classdescs. 
							Sidecasts always use dynamic cast
							Fix misuse of CAEDesc_AC in DisposeToken
		06/14/95	Fix a couple of unitialized return values and CAEDescs
		 					in OSL callbacks
		06/13/95	Remove casts from calls to DisposeIfRoutineDescriptor.
		 					Don't instantiate global COSAScript*'s
		06/13/95	Remove MakeCreateElementEvent (moved to UAppleEvents)
		06/12/95	Reorganization. See UScripting.h change history.
		 					Change TScriptEventDispatcher to TOSADispatcher.
							Support pending command action.
							General reorganization.
		05/30/95	AddReplyErr uses LookupErrString instead of GetIndString.
		05/16/95	MenuRef
		05/15/95	Remove support for pre-system 7. 
		04/13/95	Use #if instead of if qDebug. 
		03/17/95	MAVolatile. 
		03/13/95	Change Free methods to destructors. 
		03/07/95	Add back cast in call to AEInstallSpecialHandler so it will
							compile for 68K (works around a bug in the toolbox headers). 
							Turn default pre-dispatching back on. 
		03/06/95	Add InstallPreDispatch. Default pre-dispatching off. 
		02/20/95	Use FailNULLResource instead of FailResError in IScriptingDispatcher. 
		02/19/95	Suppress warning messages. 
		02/13/95	Remove unnecessary initialization of static variables. See ARM �8.4 
		02/17/95	Integration fixes. 
		02/14/95	Fix write to 0 caused by PreDispatchAppleEventGlue passing null
							to AEGetEventHandler. 
		02/14/95	Second batch of attachability changes. 
							In MakeCreateElementEvent, if there is no initial data for the
							new object, give it an empty placeholder instead of nothing. 
		01/26/95	Many changes for attachability support. 
		02/14/95	TPropertyAccessor::GetObjectProperty returns a bool.
							TMenuAccessor::GetObjectProperty returns a bool.
							TMenuItemAccessor::GetObjectProperty returns a bool.
		----- 3.5d3 Release -----
		10/17/94	Include UMemory to get MAGet1IndResource and MACount1Resources. 
							Change NULL to nil. 
		10/17/94	InstallEventDispatch tables was calling Get1IndResource and
							Count1Resources.  Changed to MAGet1IndResource and
							MACount1Resources. Radar #1197657
		10/17/94	TScriptEventDispatcher::IScriptEventDispatcher wasn't calling
							TObject::IObject.
		09/30/94	Add TScriptEventDispatcher::SendEventToTarget.  Events whose
							object specifiers have been resolved are passed to their
							targets through this bottleneck.  SendEventToTarget also
							calls the new MScriptableObject::HandleBehaviorScriptCommand,
							which allows behaviors attached to scriptable objects to handle
							apple events.
		09/23/94	Add TScriptEventDispatcher::Free to release allocated memory.
							CleanupMacApp disposes gScriptEventDispatcher.
		09/23/94	Add TScriptEventDispatcher.  Add global instance
							of TScriptEventDispatcher.  Move scripting
							related globals from UAppleEvents into this
							unit.
		09/14/94	Removed TScriptingBehavior. Added TMenuAccessor.
							Fixed SetPropertyEvent context setting problem
							that prevented these events from being undoable.
		08/22/94	 	Fixed possible dereference of NULL handle in 
							TScriptableObjectList::DoScriptCommand when writing
							the reply result out to the replyList.
		07/26/94	Include UApplication and UErrorMgr. 
		07/18/94	Change NULL to nil. 
		07/14/94	Merged with Ken Ryall's MAScript changes. 
*/