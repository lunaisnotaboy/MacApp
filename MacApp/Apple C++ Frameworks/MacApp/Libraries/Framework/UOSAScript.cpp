//----------------------------------------------------------------------------------------
// UOSAScript.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/15/00	Use CString_AC instead of CStr255_AC.
		01/02/01	Update copyright.
		11/09/00	[PB] Change initialization order to match declaration. 
		06/14/00	Cosmetic cleanup.  Use CMultiLocale_AC::Get1Resource instead of
					MAGet1Resource.  Include CMultiLocal_AC.h.
		02/03/00	Don't dispose of handles in CAEDesc_AC on Carbon. 
		10/07/99	Carbon: OSAGetSource now available, so compile it back in.
		03/24/99	Update copyright notice.
		02/04/99	[C] Added some #pragma unuseds.  Added back in some code for OSA
					functions not previously available in Carbon.
		01/15/99	CAEDesc_AC is now in ACS. 
		10/26/98	Carbonize - many OSA functions not available yet
		10/08/98	Merge TCommandHandler into TEventHandler. 
*/

#ifndef __UOSASCRIPT__
#include "UOSAScript.h"
#endif

#if qAppleEventAware

// MacApp

#ifndef __UCOMMANDHANDLER__
#include "UCommandHandler.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

//	#ifndef __UMACAPPUTILITIES__
//	#include "UMacAppUtilities.h"
//	#endif

#ifndef __USCRIPTING__
#include "UScripting.h"
#endif

// ACS

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

// Toolbox

#ifndef __AEPACKOBJECT__
#include <AEPackObject.h>
#endif

#ifndef __ASDEBUGGING__
#include <ASDebugging.h>
#endif

#ifndef __ASREGISTRY__
#include <ASRegistry.h>
#endif

#ifndef __OSAGeneric__
#include <OSAGeneric.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

//----------------------------------------------------------------------------------------
// Static Allocations
//----------------------------------------------------------------------------------------

ComponentInstance COSAScript::fgGenericScriptingComponent;

COSAScript COSAScript::fgGlobalScript;
COSAScript COSAScript::fgSharedScript;
COSAScript COSAScript::fgEmptyScript;

//========================================================================================
// CLASS COSAScript
//========================================================================================

//----------------------------------------------------------------------------------------
// COSAScript::GetDefaultComponent: 
//----------------------------------------------------------------------------------------

ComponentInstance COSAScript::GetDefaultComponent()
{
	if (HasAppleScript_AC() && !fgGenericScriptingComponent)
		fgGenericScriptingComponent = OpenDefaultComponent(kOSAComponentType,
														   kOSAGenericScriptingComponentSubtype);

	return fgGenericScriptingComponent;
}

//----------------------------------------------------------------------------------------
// COSAScript::GetEmptyScript: 
//----------------------------------------------------------------------------------------

COSAScript COSAScript::GetEmptyScript()
{
	if (HasAppleScript_AC() && (fgEmptyScript == kOSANullScript))
	{
		ComponentInstance defaultComponent = GetDefaultComponent();
		Handle scriptRes = CMultiLocale_AC::Get1Resource('scpt', 128);
		::ThrowIfNULLResource_AC(scriptRes);
		DetachResource(scriptRes);
		CTempDesc_AC emptyScriptDesc('scpt', scriptRes);
		fgEmptyScript.SetScript(defaultComponent, emptyScriptDesc,
								kOSAModeCompileIntoContext, kOSAModeNull);
	}
	return fgEmptyScript;
}

//----------------------------------------------------------------------------------------
// COSAScript::COSAScript
//----------------------------------------------------------------------------------------

COSAScript::COSAScript()
{
	fScriptID = kOSANullScript;
}

//----------------------------------------------------------------------------------------
// COSAScript::COSAScript
//----------------------------------------------------------------------------------------

COSAScript::COSAScript(OSAID theScript)
{
	fScriptID = theScript;
}

//----------------------------------------------------------------------------------------
// COSAScript::IsEmpty
//----------------------------------------------------------------------------------------

bool COSAScript::IsEmpty()
{
	return (fScriptID == kOSANullScript);
}

//----------------------------------------------------------------------------------------
// COSAScript::DisposeScript
//----------------------------------------------------------------------------------------

OSAError COSAScript::DisposeScript(ComponentInstance theComponent)
{
	OSAError err = noErr;
	if (!IsEmpty())
	{
		CTempUseResFile_AC tempUseResFile(CurResFile_AC());  // preserve the current resource file
		err = OSADispose(theComponent, fScriptID);
		fScriptID = kOSANullScript;
	}
	return err;
}

//----------------------------------------------------------------------------------------
// COSAScript::Execute
//----------------------------------------------------------------------------------------

OSAError COSAScript::Execute(ComponentInstance theComponent,
						  OSAID theContext,
						  long executeFlags,
						  OSAID& theResult)
{
	OSAError err = noErr;

	CTempUseResFile_AC tempUseResFile(CurResFile_AC());  // preserve the current resource file
	err = OSAExecute(theComponent, fScriptID, theContext, executeFlags, &theResult);

	return err;
}

//----------------------------------------------------------------------------------------
// COSAScript::GetScript
//----------------------------------------------------------------------------------------

OSAError COSAScript::GetScript(ComponentInstance theComponent,
							DescType whichType,
							CAEDesc_AC& scriptDesc,
							long storeFlags)
{
	OSAError err = noErr;
	
	CTempUseResFile_AC tempUseResFile(CurResFile_AC());  // preserve the current resource file
	// Check to see if they want a text version of the script
	if ((whichType == typeIntlText) || (whichType == typeChar))
		err = OSAGetSource(theComponent, fScriptID, whichType, scriptDesc);
	else
		err = OSAStore(theComponent, fScriptID, whichType, storeFlags, scriptDesc);

	return err;
}

//----------------------------------------------------------------------------------------
// COSAScript::SetScript
//----------------------------------------------------------------------------------------

OSAError COSAScript::SetScript(ComponentInstance theComponent,
							   const CAEDesc_AC& scriptDesc,
							   long compileFlags,
							   long loadFlags)
{
	OSAError err = noErr;
	CTempUseResFile_AC tempUseResFile(CurResFile_AC()); // setting the script may toss the resource chain

	try
	{
		OSAID newScriptID = kOSANullScript;
		DescType scriptType = scriptDesc.GetDescriptorType();
		if (scriptType != typeNull)
		{
			if ((scriptType == typeIntlText) || (scriptType == typeChar))
			{
				if (scriptDesc.GetDataSize()) // lets you empty out an objects script with ""
					::ThrowIfError_AC(OSACompile(theComponent, scriptDesc, compileFlags, &newScriptID));
			}
			else if ((scriptType == typeFSS) || (scriptType == typeAlias))
			{
				TFile scriptFile(kAllQuestionsType_AC, kAllQuestionsType_AC, kUsesDataFork, preferResourceFork, !kDataOpen, !kRsrcOpen);

#if qCarbon
				if (scriptType == typeAlias)
				{
					TemplateTempHandle<AliasHandle> aHandle(reinterpret_cast<AliasHandle>(scriptDesc.GetDataAsHandle()));
					scriptFile.SpecifyWithAlias(aHandle);
				}

				if (scriptType == typeFSS)
				{
					TemplateTempHandle<CFSSpec_AC**> aHandle(reinterpret_cast<CFSSpec_AC**>(scriptDesc.GetDataAsHandle()));
					CFSSpec_AC theSpec = **aHandle;
					scriptFile.Specify(theSpec);
				}
#else
				//DescType whichPosition = **(DescType * *)theDataDesc.GetDataHandle();
				if (scriptType == typeAlias)
					scriptFile.SpecifyWithAlias((AliasHandle)scriptDesc.GetDataHandle());

				if (scriptType == typeFSS)
				{
					CFSSpec_AC theSpec = **(CFSSpec_AC**)scriptDesc.GetDataHandle();
					scriptFile.Specify(theSpec);
				}
#endif
				
				OSType fileType = kAllQuestionsType_AC;
				::ThrowIfOSErr_AC(scriptFile.GetFileType(fileType));
				if (fileType == kTextType_AC)
				{
					scriptFile.SetUsesRsrcFork(noResourceFork);
					::ThrowIfOSErr_AC(scriptFile.OpenFile());
					long textSize = 0;
					::ThrowIfOSErr_AC(scriptFile.GetDataLength(textSize));
					Handle textHdl = NewHandle(textSize);
					::ThrowIfNULL_AC(textHdl);
					{
						CTempHandleLock_AC tempHandleLock(textHdl);
						::ThrowIfOSErr_AC(scriptFile.ReadData(*textHdl, textSize));
					}
					::ThrowIfOSErr_AC(scriptFile.CloseFile());
					CTempDesc_AC textDesc(typeChar, textHdl);
					::ThrowIfError_AC(OSACompile(theComponent, textDesc, compileFlags, &newScriptID));
				}
				else if (fileType == kOSAFileType)
				{
					scriptFile.SetUsesDataFork(false);
					scriptFile.SetUsesRsrcFork(needResourceFork);
					::ThrowIfOSErr_AC(scriptFile.OpenFile());
					CAEDesc_AC scriptRsrcDesc;
					scriptRsrcDesc.ReadFrom(&scriptFile, kOSAScriptResourceType, 128);
					::ThrowIfError_AC(OSALoad(theComponent, scriptRsrcDesc, loadFlags, &newScriptID));
					::ThrowIfOSErr_AC(scriptFile.CloseFile());
				}
			}
			else
				::ThrowIfError_AC(OSALoad(theComponent, scriptDesc, loadFlags, &newScriptID));
		}
		if (!IsEmpty())
			::ThrowIfOSErr_AC(DisposeScript(theComponent));
		fScriptID = newScriptID;
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		err = theException.GetError();
	}

	return err;
}

//----------------------------------------------------------------------------------------
// COSAScript::SetParentScript
//----------------------------------------------------------------------------------------

OSAError COSAScript::SetParentScript(ComponentInstance genericComponent,
									 OSAID itsParent)
{
	OSAError err = noErr;

	CTempUseResFile_AC tempUseResFile(CurResFile_AC()); // preserve the current resource file

	try
	{
		if (!IsEmpty()) 
		{
			ComponentInstance exactComponent = NULL;
			CTempDesc_AC parentProp;
			DescType parentCode = pASParent;
			::ThrowIfOSErr_AC(AECreateDesc(typeProperty, (Ptr)&parentCode, sizeof(parentCode), parentProp));
			OSAID myScriptID = fScriptID;
			OSAID parentScriptID = itsParent;
			if (itsParent == kOSANullScript)
				parentScriptID = GetEmptyScript();
			::ThrowIfError_AC(OSAGenericToRealID(genericComponent, &myScriptID, &exactComponent));
			::ThrowIfError_AC(OSAGenericToRealID(genericComponent, &parentScriptID, &exactComponent));
			::ThrowIfError_AC(OSASetProperty(exactComponent, kOSAModeNull, myScriptID, parentProp, parentScriptID));
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		err = theException.GetError();
	}

	return err;
}

//----------------------------------------------------------------------------------------
// COSAScript::GetParentScript
//----------------------------------------------------------------------------------------

OSAError COSAScript::GetParentScript(ComponentInstance genericComponent,
									 OSAID& itsParent)
{
	OSAError err = noErr;
	CTempUseResFile_AC tempUseResFile(CurResFile_AC()); // preserve the current resource file

	try
	{
		if (!IsEmpty())
		{
			CTempDesc_AC parentProp;
			ComponentInstance exactComponent = NULL;
			DescType parentCode = pASParent;
			::ThrowIfOSErr_AC(AECreateDesc(typeProperty, (Ptr)&parentCode, sizeof(parentCode), parentProp));
			OSAID myScriptID = fScriptID;
			OSAID parentScriptID = fScriptID;
			
			if (genericComponent != exactComponent)
				::ThrowIfError_AC(OSAGenericToRealID(genericComponent, &myScriptID, &exactComponent));

			::ThrowIfError_AC(OSAGetProperty(exactComponent, kOSAModeNull, myScriptID, parentProp, &parentScriptID));
			if ((err == noErr) && (genericComponent != exactComponent))
				::ThrowIfError_AC(OSARealToGenericID(genericComponent, &parentScriptID, exactComponent));

			itsParent = parentScriptID;
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		err = theException.GetError();
	}
	

	return err;
}

//----------------------------------------------------------------------------------------
// COSAScript::DoOSAEvent
//----------------------------------------------------------------------------------------

OSAError COSAScript::DoOSAEvent(ComponentInstance theComponent,
								TAppleEvent* message,
								TAppleEvent* reply,
								long modeFlags)
{
	OSAError err = noErr;

	CTempUseResFile_AC tempUseResFile(CurResFile_AC());  // preserve the current resource file
	err = OSADoEvent(theComponent, message, fScriptID, modeFlags, reply);

	return err;
}

//========================================================================================
// CLASS COSAScriptCntPtr
//========================================================================================

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::COSAScriptCntPtr
//----------------------------------------------------------------------------------------

COSAScriptCntPtr::COSAScriptCntPtr() :
	fRep(NULL)
{
}

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::~COSAScriptCntPtr
//----------------------------------------------------------------------------------------

COSAScriptCntPtr::~COSAScriptCntPtr()
{
	DownCount();
}

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::COSAScriptCntPtr
//----------------------------------------------------------------------------------------

COSAScriptCntPtr::COSAScriptCntPtr(const COSAScriptCntPtr& other) :
	fRep(other.fRep)
{
	UpCount();
}

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::COSAScriptCntPtr
//----------------------------------------------------------------------------------------

COSAScriptCntPtr::COSAScriptCntPtr(TOSAScriptRep* rep) :
	fRep(rep)
{
	UpCount();
}

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::operator=
//----------------------------------------------------------------------------------------

COSAScriptCntPtr& COSAScriptCntPtr::operator=(const COSAScriptCntPtr& other)
{
	SetRep(other.fRep);
	return *this;
}

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::operator=
//----------------------------------------------------------------------------------------

COSAScriptCntPtr& COSAScriptCntPtr::operator=(TOSAScriptRep* rep)
{
	SetRep(rep);
	return *this;
}

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::SetRep
//----------------------------------------------------------------------------------------

void COSAScriptCntPtr::SetRep(TOSAScriptRep* rep)
{
	if (fRep != rep)
	{
		DownCount();
		fRep = rep;
		UpCount();
	}
}
		
//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::UpCount
//----------------------------------------------------------------------------------------

void COSAScriptCntPtr::UpCount()
{
	if (fRep)
		fRep->IncrementReferenceCount();
}

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::DownCount
//----------------------------------------------------------------------------------------

void COSAScriptCntPtr::DownCount()
{
	if (fRep && !fRep->DecrementReferenceCount())
		delete fRep;
	// It is not necessary to set fRep to 0. To see why, see how DownCount is used above.
	// In all cases, fRep is either immediately reset, or the instance is being destroyed.
	// Note too that DownCount is private, so the usages above all all possible usages.
}

//----------------------------------------------------------------------------------------
// COSAScriptCntPtr::NewOSAScript:
//----------------------------------------------------------------------------------------

TOSAScriptRep* COSAScriptCntPtr::NewOSAScript()
{
	return TH_new TOSAScriptRep;
}

//========================================================================================
// CLASS TOSAScriptRep
//========================================================================================

//----------------------------------------------------------------------------------------
// TOSAScriptRep constructor
//----------------------------------------------------------------------------------------

TOSAScriptRep::TOSAScriptRep()
	:	fRefCount(0),
		fScript(kOSANullScript),
		fNextScriptIdle(0),
		fLoadFlags(kOSAModeNull),
		fCompileFlags(kOSAModeCompileIntoContext),
		fStoreFlags(kOSAModeDontStoreParent),
		fExecuteFlags(kOSAModeNull),
		fDoEventFlags(kOSAModeNull),
		fScriptingComponent(NULL)
{
	fScriptingComponent = COSAScript::GetDefaultComponent();
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep destructor
//----------------------------------------------------------------------------------------

TOSAScriptRep::~TOSAScriptRep()
{
	FreeOSAScript();
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::HasOSAScript:
//----------------------------------------------------------------------------------------

bool TOSAScriptRep::HasOSAScript()
{
	return HasAppleScript_AC() && (!fScript.IsEmpty());
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::FreeOSAScript:
//----------------------------------------------------------------------------------------

void TOSAScriptRep::FreeOSAScript()
{
	if (HasOSAScript())
		::ThrowIfError_AC(fScript.DisposeScript(fScriptingComponent));
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::SetOSAScript:
//----------------------------------------------------------------------------------------

void TOSAScriptRep::SetOSAScript(const CAEDesc_AC& scriptDesc)
{
	if (HasAppleScript_AC())
	{
		FreeOSAScript();	// dispose the current script
		::ThrowIfError_AC(fScript.SetScript(fScriptingComponent, scriptDesc, fCompileFlags, fLoadFlags));
		OSAID parentScript = GetOSAParent();
		fScript.SetParentScript(fScriptingComponent, parentScript);
	}
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::GetOSAScript:
//----------------------------------------------------------------------------------------

void TOSAScriptRep::GetOSAScript(CAEDesc_AC& scriptDesc,
								const CAEDesc_AC& desiredType)
{
	if (HasAppleScript_AC())
	{
		if (HasOSAScript())
		{
			DescType whichType = typeOSAGenericStorage;
			if (desiredType.GetDescriptorType() == typeType)
				whichType = desiredType.GetType();
			::ThrowIfError_AC(fScript.GetScript(fScriptingComponent, whichType, scriptDesc, fStoreFlags));
		}
	}
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::ExecuteOSAScript:
//----------------------------------------------------------------------------------------

OSAID TOSAScriptRep::ExecuteOSAScript()
{
	OSAID resultScript = kOSANullScript;
	if (HasOSAScript())
		::ThrowIfError_AC(fScript.Execute(fScriptingComponent, kOSANullScript, fExecuteFlags, resultScript));
	
	return resultScript;
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::HandleOSAEvent:
//----------------------------------------------------------------------------------------

bool TOSAScriptRep::HandleOSAEvent(CommandNumber aCommandNumber,
								   TAppleEvent* message,
								   TAppleEvent* reply)
{
	#pragma unused (aCommandNumber)

	bool handled = false;

	if (HasAppleScript_AC())
	{
		OSErr err = errAEEventNotHandled;
		COSAScript globalScript = COSAScript::GetGlobalScript();
		COSAScript parentScript = GetOSAParent();
		bool hasParentScript = !(parentScript == kOSANullScript);
		bool hasLocalScript = HasOSAScript();
		bool useGlobalScript = !(globalScript == kOSANullScript) &&
								  (hasLocalScript || hasParentScript);
		
		if (useGlobalScript || hasLocalScript || hasParentScript)
		{
			long refCon = 0;						// passed by address
			AEEventHandlerUPP currProc = NULL;		// passed by address

			try
			{
				::ThrowIfError_AC(OSAGetResumeDispatchProc(fScriptingComponent, &currProc, &refCon));
				::ThrowIfError_AC(OSASetResumeDispatchProc(fScriptingComponent, (AEEventHandlerUPP)kOSAUseStandardDispatch, kOSADontUsePhac));
				
				if (useGlobalScript)
				{
					if (hasLocalScript)
						globalScript.SetParentScript(fScriptingComponent, fScript);
					else if (hasParentScript)
						globalScript.SetParentScript(fScriptingComponent, parentScript);
					err = globalScript.DoOSAEvent(fScriptingComponent, message, reply, fDoEventFlags);
				}
				else if (hasLocalScript)
				{
					err = fScript.DoOSAEvent(fScriptingComponent, message, reply, fDoEventFlags);
				}
				else if (hasParentScript)
				{
					err = parentScript.DoOSAEvent(fScriptingComponent, message, reply, fDoEventFlags);
				}
				handled = (err == noErr);
				::ThrowIfError_AC(OSASetResumeDispatchProc(fScriptingComponent, currProc, refCon));
			}
			catch(CException_AC& theException)
			{
				DoCatchMessage_AC(theException);
				::ThrowIfError_AC(OSASetResumeDispatchProc(fScriptingComponent, currProc, refCon));
				throw;
			}
			
			
		}
	}

	return handled;
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::ReadOSAScript:
//----------------------------------------------------------------------------------------

void TOSAScriptRep::ReadOSAScript(CStream_AC* aStream)
{
	CTempDesc_AC theScriptDesc;
	theScriptDesc.ReadFrom(aStream);
	SetOSAScript(theScriptDesc);
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::ReadOSAScript:
//----------------------------------------------------------------------------------------

void TOSAScriptRep::ReadOSAScript(	TFile* 	aFile,
									ResType	resourceType,
									short	resourceID)
{
	CTempDesc_AC theScriptDesc;
	
	theScriptDesc.ReadFrom(aFile, resourceType, resourceID);
	SetOSAScript(theScriptDesc);
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::WriteOSAScript:
//----------------------------------------------------------------------------------------

void TOSAScriptRep::WriteOSAScript(	CStream_AC* aStream,
									DescType asType)
{
	CTempDesc_AC theScriptDesc;
	CTempDesc_AC theTypeDesc;
	theTypeDesc.PutType(asType);
	GetOSAScript(theScriptDesc, theTypeDesc);
	theScriptDesc.WriteTo(aStream);
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::WriteOSAScript:
//----------------------------------------------------------------------------------------

void TOSAScriptRep::WriteOSAScript(	TFile* 		aFile,
									DescType 	asType,
									short		resourceID,
									CString_AC&	resourceName)
{
	CTempDesc_AC scriptDesc;
	CTempDesc_AC typeDesc;
	
	typeDesc.PutType(asType);
	GetOSAScript(scriptDesc, typeDesc);
	scriptDesc.WriteTo(aFile, resourceID, resourceName);
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::GetOSAParent:
//----------------------------------------------------------------------------------------

OSAID TOSAScriptRep::GetOSAParent()
{
	return COSAScript::GetSharedScript();
}

//----------------------------------------------------------------------------------------
// TOSAScriptRep::IdleOSAScript:
//----------------------------------------------------------------------------------------

void TOSAScriptRep::IdleOSAScript()
{
	// Gives an attached script idle time so its idle event handler can do some work.
	if (HasAppleScript_AC() && (fNextScriptIdle != kMaxIdleTime) && (TickCount() > fNextScriptIdle))
	{
		CAEDesc_AC myAddress;
		TAppleEvent* message = NULL;
		TAppleEvent* reply = NULL;
		TClientCommand* theCmd = NULL;

		try
		{
			message = TH_new TAppleEvent('misc', 'idle', myAddress, kAEWaitReply);
			reply = TH_new TAppleEvent('misc', 'idle', myAddress, kAENoReply);
			
			fNextScriptIdle = TickCount() + 3600; // Default to one minute in case the idle proc doesn't return anything
			try
			{
				if (HandleOSAEvent(0, message, reply) && reply->HasParameter(keyAEResult))
				{
					unsigned long idleSeconds = reply->ReadLong(keyAEResult);
					fNextScriptIdle = TickCount() + (idleSeconds * 60);
				}
			}
			catch(CException_AC& theException)
			{
				DoCatchMessage_AC(theException);
				// fall through without resignalling
			}
			
			
			theCmd = TH_new TClientCommand(0, NULL, false, false, NULL, message);
			theCmd->ProcessReply(reply);
		}
		catch(CException_AC& theException)
		{
			DoCatchMessage_AC(theException);
			// fall through without resignalling
		}
		
		
		if (theCmd)
			delete theCmd;
		else
		{	// Freeing the command will free the message and reply
			delete message;
			delete reply;
		}
	}
}

//========================================================================================
// CLASS TExecuteScriptCommand
//========================================================================================
//----------------------------------------------------------------------------------------
// TExecuteScriptCommand constructor
//----------------------------------------------------------------------------------------

TExecuteScriptCommand::TExecuteScriptCommand(CommandNumber itsCommandNumber,
												  TEventHandler* itsContext,
											      bool canUndo,
											      bool causesChange,
											      MDependable_AC* objectToNotify,
											      OSAID scriptToExecute,
											      OSAID theScriptContext,
											      long executeFlags,
											      bool disposeOfScript,
											      ComponentInstance whichComponent) :
	TCommand(itsCommandNumber, itsContext, canUndo, causesChange, objectToNotify),

	fScript (scriptToExecute),
	fScriptContext(theScriptContext),
	fDisposeScript(disposeOfScript),
	fComponent(whichComponent),
	fExecuteFlags(executeFlags)
{
}

//----------------------------------------------------------------------------------------
// TExecuteScriptCommand::~TExecuteScriptCommand:
//----------------------------------------------------------------------------------------

TExecuteScriptCommand::~TExecuteScriptCommand()
{
	if (fDisposeScript)
		fScript.DisposeScript(fComponent);
}

//----------------------------------------------------------------------------------------
// TExecuteScriptCommand::DoIt:
//----------------------------------------------------------------------------------------

void TExecuteScriptCommand::DoIt()	// override
{
	COSAScript theScript(fScript);
	OSAID aResult;
	if (theScript != kOSANullScript)
	{
		// Run it through the globals script if there is one
		COSAScript globalsScript = COSAScript::GetGlobalScript();
		if (globalsScript != kOSANullScript)
		{
			globalsScript.SetParentScript(fComponent, theScript);		
			globalsScript.Execute(fComponent, fScriptContext, fExecuteFlags, aResult);
		}
		else
			theScript.Execute(fComponent, fScriptContext, fExecuteFlags, aResult);
	}
}

#endif	// #if qAppleEventAware

//----------------------------------------------------------------------------------------
// End of UOSAScript.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		 5/08/96	Create and use CFSSpec_AC. You should search/replace in your code to switch to
		 					CFSSpec_AC.
		05/07/96	Made TAppleEvent derive from CAEDesc_AC as well as TObject.
		05/07/96	Use CTempUseResFile_AC whenever feasible
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		----- R10 -----
		 12/8/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		 11/1/95	Make drag cursor and script idle code resident. 
		10/31/95	Add CurResFile_AC, Fix UseResFile_AC to avoid unnecessary UseResFile calls.
		10/25/95	Add resource versions of ReadScript/WriteScript.
							SetScript frees the old script.
		----- 3.3b1 -----
		  9/5/95	Removed short cast of OSA error.  Changed TOSAScriptCntPtr to
		  					COSAScriptCntPtr since it's not based on TObject.
		 8/14/95	Added reference counting to the TOSAScript class
		 					due to some undesired destruction of said scripts
							while executing them during document closing.  The
							reference counting code was plagerized from FWCouPtr.cpp.
		 7/28/95	Add configuration functions to use instead of gConfiguration. 
		 7/28/95	Default to give idle time to scripts. 
		 7/27/95	Make GetEmptyScript non-inline. 
							No longer need MakeGlobalScripts. 
							SetParentScript no longer takes a reference. 
		 7/24/95	Initial version. 
*/