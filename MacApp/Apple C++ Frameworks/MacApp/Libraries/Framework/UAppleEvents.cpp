//----------------------------------------------------------------------------------------
// UAppleEvents.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/01/01	Need to include CReporter_AC. 
		01/05/01	Change to use CString_AC instead of std::string.
		01/02/01	Update copyright.
		12/26/00	Avoid iostream footprint hit. 
		12/15/00	Use string in WriteOSError and in call to MAParamText.  [PB] Include
					strstream instead of sstream and use ostrstream instead of ostringstream.
		11/10/00	Cosmetic.
		11/03/00	[C] DonÕt include SegLoad.h.
		09/08/00	Added embedded documentation - TAppleEvent::DeleteParameter.
		08/15/00	Add a convenience macro for generating temp UPP classes. 
		02/03/00	Don't dispose of handles in CAEDesc_AC on Carbon. 
		10/07/99	Use TemplateTempUPP_AC instead of TmplTmpRtnDescrptr.
		07/14/99	Renamed the CreateDesc method to reset. 
		03/24/99	Update copyright notice.
		02/03/99	[C] Cannot use dataHandle since it is now opaque.
		01/16/99	Don't dereference a null descriptor dataHandle. 
		01/15/99	CAEDesc_AC is now in ACS. 
		11/06/98	Carbon: no ReadSectionHandle or WriteSectionHandle
		10/08/98	GetHandleSizeIfLocked. 
					Add TotalSize method. 
*/

#ifndef __UAPPLEEVENTS__
#include "UAppleEvents.h"
#endif

// qAppleEventAware indicates if the build includes AppleEvent support.
#if qAppleEventAware

// MacApp

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USCRIPTING__
#include "UScripting.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __USUBSTITUTION__
#include "USubstitution.h"
#endif

// ACS

#ifndef __CListIterator_AC__
#include "CListIterator_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

#ifndef __TemplateUPP_AC__
#include "TemplateUPP_AC.h"
#endif

// Toolbox

#ifndef __AEREGISTRY__
#include <AERegistry.h>
#endif

#ifndef __PROCESSES__
#include <Processes.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#if !qCarbon
	#ifndef __SEGLOAD__
	#include <SegLoad.h>
	#endif
#endif

//========================================================================================
// static allocations
//========================================================================================

CTempAEIdleUPP		TAppleEvent::fgIdleProc;
CTempAEFilterUPP	TAppleEvent::fgFilterProc;

//========================================================================================
// CLASS CAEDesc_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// GetObject:
//----------------------------------------------------------------------------------------

MScriptableObject* GetObject(const CAEDesc_AC& fromDesc)
{
	CAEObject object(fromDesc);
	return object.GetValue() ? object.GetValue() : gDispatcher;
}

//----------------------------------------------------------------------------------------
// PutObject:
//----------------------------------------------------------------------------------------

void PutObject(CAEDesc_AC& toDesc, MScriptableObject* theObject)
{
#if qDebug
	if (theObject == NULL)
		::ProgramBreak_AC("PutObject: theObject is NULL!");
	else
#else
	::ThrowIfNULL_AC(theObject);
#endif
	toDesc.reset(CAEObject(theObject));
}


//========================================================================================
// CAEObject
//========================================================================================

//----------------------------------------------------------------------------------------
// CAEObject Default constructor
//----------------------------------------------------------------------------------------

CAEObject::CAEObject()
	:	TemplateAEValue_AC<MScriptableObject*, cObject>()
{
}

//----------------------------------------------------------------------------------------
// CAEObject Construct from an AEDesc
//----------------------------------------------------------------------------------------

CAEObject::CAEObject(const CAEDesc_AC& fromDesc)
	:	TemplateAEValue_AC<MScriptableObject*, cObject>()
{
	fDescriptorType = fromDesc.GetDescriptorType();
	if (!fromDesc.IsNULL())
		fValue = **reinterpret_cast<MScriptableObject* **>(fromDesc.dataHandle);
	if (fValue)
		fDescriptorType = fValue->GetOMClass();
}

//----------------------------------------------------------------------------------------
// CAEObject Construct from a keyed item in an AEDesc
//----------------------------------------------------------------------------------------

CAEObject::CAEObject(const CAEDesc_AC& fromDesc, AEKeyword key, bool* found)
	:	TemplateAEValue_AC<MScriptableObject*, cObject>(fromDesc, key, found)
{
	if (fValue)
		fDescriptorType = fValue->GetOMClass();
}

//----------------------------------------------------------------------------------------
// CAEObject Construct from a value
//----------------------------------------------------------------------------------------

CAEObject::CAEObject(MScriptableObject* value)
	:	TemplateAEValue_AC<MScriptableObject*, cObject>(value)
{
	if (fValue)
		fDescriptorType = fValue->GetOMClass();
}

//----------------------------------------------------------------------------------------
// CAEObject Copy constructor
//----------------------------------------------------------------------------------------

CAEObject::CAEObject(const CAEObject& other)
	:	TemplateAEValue_AC<MScriptableObject*, cObject>(other)
{
	if (fValue)
		fDescriptorType = fValue->GetOMClass();
}

//----------------------------------------------------------------------------------------
// CAEObject::operator=
//----------------------------------------------------------------------------------------

CAEObject& CAEObject::operator=(MScriptableObject* value)
{
	fValue = value;
	if (fValue)
		fDescriptorType = fValue->GetOMClass();
	return *this;
}

//----------------------------------------------------------------------------------------
// CAEObject::Set
//----------------------------------------------------------------------------------------

void CAEObject::Set(const CAEDesc_AC& fromDesc)
{
	TemplateAEValue_AC<MScriptableObject*, cObject>::Set(fromDesc);
	if (fValue)
		fDescriptorType = fValue->GetOMClass();
}

//----------------------------------------------------------------------------------------
// CAEObject::Set
//----------------------------------------------------------------------------------------

void CAEObject::Set(const CAEDesc_AC& fromDesc, AEKeyword key, bool* found)
{
	TemplateAEValue_AC<MScriptableObject*, cObject>::Set(fromDesc, key, found);
	if (fValue)
		fDescriptorType = fValue->GetOMClass();
}


//========================================================================================
// CLASS TAppleEvent
//========================================================================================

//----------------------------------------------------------------------------------------
// TAppleEvent::TAppleEvent:
//----------------------------------------------------------------------------------------

TAppleEvent::TAppleEvent(const AEEventClass		itsEventClass,
						 const AEEventID		itsEventID,
						 const AEAddressDesc&	itsAddress,
						 long					itsSendingMode)
	:	fSendingMode(itsSendingMode),
		fTimeoutVal(kAEDefaultTimeout),
		fPriority(kAENormalPriority),
		fFreeMessage(false)
{
	if (itsEventClass != typeNull)
	{
		::ThrowIfOSErr_AC(AECreateAppleEvent(itsEventClass, itsEventID, &itsAddress, kAutoGenerateReturnID, kAnyTransactionID, this));

		fFreeMessage = true;						// We created it, we need to free it
	}
}

//----------------------------------------------------------------------------------------
// TAppleEvent::TAppleEvent:
//----------------------------------------------------------------------------------------

TAppleEvent::TAppleEvent(const AppleEvent& theMessage, bool freeMessage)
	:	CAEDesc_AC(theMessage),
		fSendingMode(kAENoReply),
		fTimeoutVal(kAEDefaultTimeout),
		fPriority(kAENormalPriority),
		fFreeMessage(freeMessage)
{
	// Initialize the reply mode.
	DescType actualType;
	Size actualSize;
	short interactLevel = 0;
	if (AEGetAttributePtr(this, keyInteractLevelAttr, typeShortInteger, &actualType, &interactLevel, sizeof(short), &actualSize) == noErr)
		fSendingMode = interactLevel & kAEReplyModeMask;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::~TAppleEvent
//----------------------------------------------------------------------------------------

TAppleEvent::~TAppleEvent()
{
	if (fFreeMessage)
		AEDisposeDesc(this);
}

//----------------------------------------------------------------------------------------
//		¥ MakeCreateElementEvent: 
//----------------------------------------------------------------------------------------

TAppleEvent* TAppleEvent::MakeCreateElementEvent(AEAddressDesc&		targetAddress,
												 AESendMode			sendMode,
												 const CAEDesc_AC&	targetSpecifier,
												 DescType			newElementType,
												 DescType			newElementPosition,
												 const CAEDesc_AC&	initialData,
												 const CAEDesc_AC&	initialProperties)
{
	CAutoPtr_AC<TAppleEvent> theEvent(TH_new TAppleEvent(kAECoreSuite, kAECreateElement, targetAddress, sendMode));

	// create the insertion record
	CTempDesc_AC insertionRecord;
	insertionRecord.CreateRecord();
	insertionRecord.PutKeyDesc(keyAEObject, targetSpecifier);
	insertionRecord.PutKeyEnum(keyAEPosition, newElementPosition);
	CTempDesc_AC insertionLocation(insertionRecord.CoerceDesc(typeInsertionLoc));

	// add the insertion record to the apple event
	theEvent->WriteParameter(keyAEInsertHere, insertionLocation);

	// add the class of the item to be created to the event
	theEvent->WriteType(keyAEObjectClass, newElementType);

	// add the initial data to the event
	if (initialData.dataHandle)
		theEvent->WriteParameter(keyAEData, initialData);

	// add the initial properties to the event
	if (initialProperties.dataHandle)
		theEvent->WriteParameter(keyAEPropData, initialProperties);

	return theEvent.release();
}

//----------------------------------------------------------------------------------------
// TAppleEvent::Send:
//----------------------------------------------------------------------------------------

TAppleEvent* TAppleEvent::Send() const
{
	TAppleEvent * resultEvent = NULL;
	::ThrowIfOSErr_AC(SendEvent(resultEvent));

	return resultEvent;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::SendEvent:
//----------------------------------------------------------------------------------------

OSErr TAppleEvent::SendEvent() const
{
	TAppleEvent* resultEvent = NULL;
	OSErr err = SendEvent(resultEvent);
	delete resultEvent;

	return err;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::SendEvent:
//----------------------------------------------------------------------------------------

OSErr TAppleEvent::SendEvent(TAppleEvent*& replyEvent) const
{
	AppleEvent reply;

	OSErr err = AECreateDesc(typeNull, NULL, 0, &reply);
	if (err == noErr)
	{
		// Debugging note: 
		//	If the application is sending this Apple Event to itself, you can follow it
		//	through the AESend by setting breakpoints in the functions
		//	TOSADispatcher::PreDispatchHandlerGlue and TOSADispatcher::DispatchHandlerGlue
		//	in UScripting.cp. 

		bool keepBusy;
		if (gDispatcher)
			keepBusy = gDispatcher->KeepCursorBusy(true);

		err = AESend(this, &reply, fSendingMode, fPriority, fTimeoutVal, TAppleEvent::fgIdleProc, TAppleEvent::fgFilterProc);

		if (gDispatcher)
			gDispatcher->KeepCursorBusy(keepBusy);

		if (err == noErr && (GetSendingMode() & kAEReplyModeMask) == kAEWaitReply)
			replyEvent = TH_new TAppleEvent(reply, true);
		else
			AEDisposeDesc(&reply);
	}

	return err;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::GetAddress:
//----------------------------------------------------------------------------------------

void TAppleEvent::GetAddress(AEAddressDesc& theAddress) const

{
	::ThrowIfOSErr_AC(AEGetAttributeDesc(this, keyAddressAttr, typeWildCard, &theAddress));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::GetProcessSerialNumber:
//----------------------------------------------------------------------------------------

void TAppleEvent::GetProcessSerialNumber(ProcessSerialNumber& thePSN) const

{
	DescType actualType;
	Size actualSize;
	::ThrowIfOSErr_AC(AEGetAttributePtr(this, keyAddressAttr, typeProcessSerialNumber, &actualType, &thePSN, sizeof(ProcessSerialNumber), &actualSize));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::GetReturnID:
//----------------------------------------------------------------------------------------

long TAppleEvent::GetReturnID() const
{
	DescType actualType;
	long returnID;
	long actualSize;

	::ThrowIfOSErr_AC(AEGetAttributePtr(this, keyReturnIDAttr, typeLongInteger, &actualType, &returnID, sizeof(returnID), &actualSize));

	return returnID;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::GetTransactionID:
//----------------------------------------------------------------------------------------

long TAppleEvent::GetTransactionID() const
{
	long transactionID;
	DescType actualType;
	long actualSize;

	return (AEGetAttributePtr(this, keyTransactionIDAttr, typeLongInteger, &actualType, &transactionID, sizeof(transactionID), &actualSize) == noErr) ? transactionID : 0;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::SetAddress:
//----------------------------------------------------------------------------------------

void TAppleEvent::SetAddress(const AEAddressDesc& theAddress)
{
	::ThrowIfOSErr_AC(AEPutAttributeDesc(this, keyAddressAttr, &theAddress));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::SetPriority:
//----------------------------------------------------------------------------------------

void TAppleEvent::SetPriority(short thePriority)
{
	fPriority = thePriority;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::SetReturnID:
//----------------------------------------------------------------------------------------

void TAppleEvent::SetReturnID(long returnID)
{
	::ThrowIfOSErr_AC(AEPutAttributePtr(this, keyReturnIDAttr, typeLongInteger, &returnID, sizeof(returnID)));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::SetSendingMode:
//----------------------------------------------------------------------------------------

void TAppleEvent::SetSendingMode(long sendingMode)
{
	fSendingMode = sendingMode;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::SetTimeoutVal:
//----------------------------------------------------------------------------------------

void TAppleEvent::SetTimeoutVal(long theTimeoutVal)
{
	fTimeoutVal = theTimeoutVal;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::SetTransactionID:
//----------------------------------------------------------------------------------------

void TAppleEvent::SetTransactionID(long transactionID)
{
	::ThrowIfOSErr_AC(AEPutAttributePtr(this, keyTransactionIDAttr, typeLongInteger, &transactionID, sizeof(transactionID)));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadEventClass:
//----------------------------------------------------------------------------------------

AEEventClass TAppleEvent::ReadEventClass() const
{
	DescType typeCode;
	AEEventClass eventClass;
	Size actualSize;

	::ThrowIfOSErr_AC(AEGetAttributePtr(this, keyEventClassAttr, typeType, &typeCode, &eventClass, sizeof(eventClass), &actualSize));

	return eventClass;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadEventClass:
//----------------------------------------------------------------------------------------

AEEventID TAppleEvent::ReadEventID() const
{
	DescType typeCode;
	AEEventID eventID;
	Size actualSize;

	::ThrowIfOSErr_AC(AEGetAttributePtr(this, keyEventIDAttr, typeType, &typeCode, &eventID, sizeof(eventID), &actualSize));

	return eventID;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadShort:
//----------------------------------------------------------------------------------------

short TAppleEvent::ReadShort(const AEKeyword theKey) const
{
	DescType actualType;
	Size actualSize;
	short theData = 0;

	::ThrowIfOSErr_AC(AEGetParamPtr(this, theKey, typeShortInteger, &actualType, &theData, sizeof(theData), &actualSize));

	return theData;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadLong:
//----------------------------------------------------------------------------------------

long TAppleEvent::ReadLong(const AEKeyword theKey) const
{
	DescType actualType;
	Size actualSize;
	long theData = 0;

	::ThrowIfOSErr_AC(AEGetParamPtr(this, theKey, typeLongInteger, &actualType, &theData, sizeof(theData), &actualSize));

	return theData;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadString:
//----------------------------------------------------------------------------------------

void TAppleEvent::ReadString(const AEKeyword theKey, CStr255_AC& theData) const
{
	DescType actualType;
	Size actualSize;

	theData.Empty();
	::ThrowIfOSErr_AC(AEGetParamPtr(this, theKey, typeChar, &actualType, &theData[1], sizeof(CStr255_AC) - 1, &actualSize));

	if (actualSize > 255)
	{
#if qDebug
		ProgramReport_AC("TAppleEvent::ReadString: String was longer than 255 bytes.  Will be truncated\n");
#endif

		actualSize = 255;
	}
	theData.Length() = static_cast<unsigned char>(actualSize);
}

#if !qCarbon
//----------------------------------------------------------------------------------------
// TAppleEvent::ReadSectionHandle:
//----------------------------------------------------------------------------------------

SectionHandle TAppleEvent::ReadSectionHandle(const AEKeyword theKey) const
{
	DescType actualType;
	Size actualSize;
	SectionHandle theData = NULL;

	::ThrowIfOSErr_AC(AEGetParamPtr(this, theKey, typeSectionH, &actualType, &theData, sizeof(SectionHandle), &actualSize));

	return theData;
}
#endif	// !qCarbon

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadPtrList:
//----------------------------------------------------------------------------------------

void TAppleEvent::ReadPtrList(const AEKeyword	theKey,
							  const DescType	theType,
							  CDynamicArray_AC*	theData) const
{
	AEDescList theDescList;
	::ThrowIfOSErr_AC(AEGetParamDesc(this, theKey, typeAEList, &theDescList));

	long items;

	::ThrowIfOSErr_AC(AECountItems(&theDescList, &items));// Get the number of elements in the list 
	CTempPtr_AC thePtr(NewPermPtr(theData->GetElementSize()));

	for (short index = 1; index <= items; ++index)
	{
		AEKeyword theActualKey;
		DescType theActualType;
		Size theActualSize;

		::ThrowIfOSErr_AC(AEGetNthPtr(&theDescList, index, theType, &theActualKey, &theActualType, thePtr, theData->GetElementSize(), &theActualSize));

		theData->InsertElementsBefore(theData->GetSize() + 1, thePtr, 1);
	}
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadHandleList:
//----------------------------------------------------------------------------------------


void TAppleEvent::ReadHandleList(const AEKeyword	theKey,
								 const DescType		theType,
								 CDynamicArray_AC*	theData) const
{
	AEDescList theDescList;
	::ThrowIfOSErr_AC(AEGetParamDesc(this, theKey, typeAEList, &theDescList));

	long items;
	::ThrowIfOSErr_AC(AECountItems(&theDescList, &items));// Get the number of elements in the list 
	for (short index = 1; index <= items; ++index)
	{
		CTempDesc_AC theHandle;
		AEKeyword theActualKey;
		::ThrowIfOSErr_AC(AEGetNthDesc(&theDescList, index, theType, &theActualKey, theHandle));

		theData->InsertElementsBefore(theData->GetSize() + 1, &theHandle.dataHandle, 1);
		theHandle.release();
	}
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadParameter:
//----------------------------------------------------------------------------------------


OSErr TAppleEvent::ReadParameter(const AEKeyword	theKey,
								 const DescType		desiredType,
								 CAEDesc_AC&		theData) const
{
	return AEGetParamDesc(this, theKey, desiredType, theData);
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadParameterPtr:
//----------------------------------------------------------------------------------------


void TAppleEvent::ReadParameterPtr(const AEKeyword	theKey,
								   const DescType	desiredType,
								   DescType&		actualType,
								   Ptr				theData,
								   long				maximumSize,
								   long&			actualSize) const
{
	::ThrowIfOSErr_AC(AEGetParamPtr(this, theKey, desiredType, &actualType, theData, maximumSize, &actualSize));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteShort:
//----------------------------------------------------------------------------------------


void TAppleEvent::WriteShort(const AEKeyword theKey, short theData)
{
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeShortInteger, &theData, sizeof(theData)));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteLong:
//----------------------------------------------------------------------------------------


void TAppleEvent::WriteLong(const AEKeyword theKey, long theData)
{
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeLongInteger, &theData, sizeof(theData)));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteString:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteString(const AEKeyword theKey, const CStr255_AC& theData)
{
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeChar, &theData[1], theData.Length()));
}

#if !qCarbon
//----------------------------------------------------------------------------------------
// TAppleEvent::WriteSectionHandle:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteSectionHandle(const AEKeyword theKey, SectionHandle theData)
{
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeSectionH, &theData, sizeof(SectionHandle)));
}
#endif	// !qCarbon

//----------------------------------------------------------------------------------------
// TAppleEvent::WritePtrList:
//----------------------------------------------------------------------------------------

void TAppleEvent::WritePtrList(const AEKeyword		theKey,
							   const DescType		theType,
							   CDynamicArray_AC*	theData)
{
	CTempDesc_AC theDescList;					// used to be VOLATILE, but since it's a structure it won't be cached into registers on OUR compilers

	theDescList.CreateList();

	{
		// Create a block for the iterator to disambiguate it from the failure handler it's nested in
		for (CArrayIterator_AC iter(theData); iter.Current(); ++iter)
			::ThrowIfOSErr_AC(AEPutPtr(theDescList, iter.Current(), theType, theData->ComputeAddress(iter.Current()), theData->GetElementSize()));
	}
	::ThrowIfOSErr_AC(AEPutParamDesc(this, theKey, theDescList));

	::ThrowIfOSErr_AC(theDescList.DisposeDesc());
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteHandleList:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteHandleList(const AEKeyword		theKey,
								  const DescType		theType,
								  CDynamicArray_AC*		theData)
{
	CTempDesc_AC theDescList;
	theDescList.CreateList();

	// Create a block for the iterator to disambiguate it from the failure handler it's nested in
	for (CArrayIterator_AC iter(theData); iter.Current(); ++iter)
	{
		Handle h = *((Handle*)(theData->ComputeAddress(iter.Current())));
#if qCarbon
		CTempHLock_AC lockHandle(h);
		theDescList.PutListPtr(iter.Current(), theType, *h, GetHandleSize(h));
#else
		CAEDesc_AC theElement(theType, h);
		theDescList.PutListItem(iter.Current(), theElement);
#endif
	}

	::ThrowIfOSErr_AC(AEPutParamDesc(this, theKey, theDescList));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteParameter:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteParameter(const AEKeyword theKey, const CAEDesc_AC& theData)
{
	::ThrowIfOSErr_AC(AEPutParamDesc(this, theKey, theData));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteParameterPtr:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteParameterPtr(const AEKeyword	theKey,
									const DescType	typeCode,
									Ptr				theData,
									long			dataSize)
{
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeCode, theData, dataSize));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::DeleteParameter:
//----------------------------------------------------------------------------------------

void TAppleEvent::DeleteParameter(const AEKeyword theKey)
// DeleteParameter deletes the specified descriptor record from the Apple 
// event message by its key.
//
// theKey:	Specifies the descriptor record.
//
// Call?		As needed.
// Override?	NEVER. It is not virtual.
{
	::ThrowIfOSErr_AC(AEDeleteKeyDesc(this, theKey));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::CheckRequiredParameters:
//----------------------------------------------------------------------------------------

void TAppleEvent::CheckRequiredParameters() const
{
	// look for the keyMissedKeywordAttr
	DescType returnedType;
	Size actualSize;
	OSErr theErr = AEGetAttributePtr(this, keyMissedKeywordAttr, typeWildCard, &returnedType, NULL, 0, &actualSize);
	if (theErr == noErr)
	{
		// We missed a parameter!
		::ThrowIfOSErr_AC(errAEParamMissed);
	}
	else if (theErr != errAEDescNotFound)
	{
		// Its OK if we got errAEDescNotFound because that means we got all the params.
		::ThrowIfOSErr_AC(theErr);
	}
}

//----------------------------------------------------------------------------------------
// TAppleEvent::HasParameter:
//----------------------------------------------------------------------------------------

bool TAppleEvent::HasParameter(const AEKeyword theKey) const
{
	DescType typeCode;
	long actualSize;

	return AEGetParamPtr(this, theKey, typeWildCard, &typeCode, NULL, 0, &actualSize) == noErr;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ParameterType:
//----------------------------------------------------------------------------------------

DescType TAppleEvent::ParameterType(const AEKeyword theKey) const
{
	// Returns the descriptor type of an event parameter.
	// TAppleEvent::ParameterType is here courtesy of Matt Clark. Thanks Matt.
	CTempDesc_AC paramDesc;

	OSErr theErr = AEGetParamDesc(this, theKey, typeWildCard, paramDesc);
	if ((theErr != noErr) && (theErr != errAEDescNotFound))
		::ThrowIfOSErr_AC(theErr);
	DescType result = paramDesc.GetDescriptorType();

	return result;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadType:
//----------------------------------------------------------------------------------------

DescType TAppleEvent::ReadType(const AEKeyword theKey) const
{
	DescType actualType;
	long actualSize;
	DescType theData = 0;

	OSErr theErr = AEGetParamPtr(this, theKey, typeType, &actualType, &theData, sizeof(theData), &actualSize);

	if ((theErr != noErr) && (theErr != errAEDescNotFound))
		::ThrowIfOSErr_AC(theErr);

	return theData;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadEnum:
//----------------------------------------------------------------------------------------

DescType TAppleEvent::ReadEnum(const AEKeyword theKey) const
{
	DescType actualType;
	long actualSize;
	DescType theData = 0;

	OSErr theErr = AEGetParamPtr(this, theKey, typeEnumeration, &actualType, &theData, sizeof(theData), &actualSize);

	if ((theErr != noErr) && (theErr != errAEDescNotFound))
		::ThrowIfOSErr_AC(theErr);

	return theData;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadBoolean:
//----------------------------------------------------------------------------------------

bool TAppleEvent::ReadBoolean(const AEKeyword theKey) const
{
	DescType actualType;
	long actualSize;
	Boolean theData = false;

	OSErr theErr = AEGetParamPtr(this, theKey, typeBoolean, &actualType, &theData, sizeof(theData), &actualSize);

	if ((theErr != noErr) && (theErr != errAEDescNotFound))
		::ThrowIfOSErr_AC(theErr);

	return theData;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadRect:
//----------------------------------------------------------------------------------------

void TAppleEvent::ReadRect(const AEKeyword theKey, CRect_AC& theRect) const
{
	DescType actualType;
	long actualSize;
	CRect_AC localRect;

	OSErr theErr = AEGetParamPtr(this, theKey, typeQDRectangle, &actualType, &localRect, sizeof(localRect), &actualSize);

	if ((theErr != noErr) && (theErr != errAEDescNotFound))
		::ThrowIfOSErr_AC(theErr);

	theRect = localRect;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteType:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteType(const AEKeyword theKey, DescType theType)
{
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeType, &theType, sizeof(theType)));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteEnum:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteEnum(const AEKeyword theKey, DescType theEnum)
{
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeEnumeration, &theEnum, sizeof(theEnum)));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteBoolean:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteBoolean(const AEKeyword theKey, bool theBoolean)
{
	Boolean localBoolean = theBoolean;
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeBoolean, &localBoolean, sizeof(localBoolean)));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteRect:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteRect(const AEKeyword theKey, const CRect_AC& theRect)
{
	::ThrowIfOSErr_AC(AEPutParamPtr(this, theKey, typeQDRectangle, &theRect, sizeof(theRect)));
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteReplySpecifier:
//----------------------------------------------------------------------------------------

bool TAppleEvent::WriteReplySpecifier(MScriptableObject* theReplyObject)
{
	// Use this whenever you need to return the object's specifier as the result of an event.
	// Makes an object specifier for an object and puts it in the keyAEResult parameter of this reply event.
	// MScriptableObject::ReturnReplySpecifier is here courtesy of Matt Clark. Thanks Matt.
	bool result = false;

	if (dataHandle)
	{
		CTempDesc_AC objSpecifier;
		if (theReplyObject->MakeObjectSpecifier(objSpecifier, theReplyObject->GetSpecifierForm()))
			WriteParameter(keyAEResult, objSpecifier);

		result = true;
	}

	return result;
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteError:
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteError(long errNum, short errorStringResource, short errorStringIndex)
{
	if (dataHandle)
	{
		WriteLong(keyErrorNumber, errNum);
		CStr255_AC errStr(errorStringResource, errorStringIndex);
		WriteString(keyErrorString, errStr);
	}
}

//----------------------------------------------------------------------------------------
// TAppleEvent::WriteOSError
//----------------------------------------------------------------------------------------

void TAppleEvent::WriteOSError(OSErr theError)
{
	if (descriptorType != typeNull && dataHandle)
	{
		CString_AC errorString;
		WriteLong(keyErrorNumber, errAEEventFailed);
		if (!LookupErrString(theError, errReasonID, errorString))
		{
			// No error string was found, substitute the generic one.
			CString_AC errNumString;
			stringprintf(errNumString, "%ld", theError);
			MAParamText(CString_AC("^ENUM"), errNumString);
			LookupErrString(errGenericErrorWithNum, errReasonID, errorString);
			MAReplaceText(errorString);
		}

		WriteString(keyErrorString, CStr255_AC(errorString));
	}
}

//----------------------------------------------------------------------------------------
// TAppleEvent::ReadError:
//----------------------------------------------------------------------------------------

void TAppleEvent::ReadError(long& errorNumber, CStr255_AC& errorString) const
{
	errorNumber = noErr;

	if (HasParameter(keyErrorNumber))
		errorNumber = (OSErr)ReadLong(keyErrorNumber);

	if (HasParameter(keyErrorString))
		ReadString(keyErrorString, errorString);
}

#endif	// #if qAppleEventAware

//----------------------------------------------------------------------------------------
// End of UAppleEvents.cp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		06/19/96	Fix SCpp whining in CAEDesc_AC::WriteTo by adding a (Handle) cast.
		 5/09/96	Added CopyHandle_AC: a better HandToHand replacement. And created
		 					PermCopyHandle a better PermHandToHand.
		 5/08/96	Create and use CFSSpec_AC. You should search/replace in your code to switch to
		 					CFSSpec_AC.
		05/07/96	Made TAppleEvent derive from CAEDesc_AC as well as TObject.
		05/07/96	Made CAEDesc_AC a derivative of AEDesc.
		05/07/96	Use CTempUseResFile_AC whenever feasible
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Eliminated custom embedded FailInfo handling, derive from MDestructo
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use more "while" style iteration
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/27/96	FailInfo has a default constructor so failInfo.Reset was redundant in CTempDesc_AC constructors
		03/27/96	Switch last remaining Str255s to CStr255s_AC
		03/27/96	Fix MrC compile error
		03/26/96	Use fMessage directly, don't copy it to a local first since we're pointer based now.
		03/26/96	Cleanup references to gEmptyString
		 3/04/96	Remove gratuitous inlining, Removed ::Success in favor of FailInfo::Success,
		 					restructured Try macro to reduce code bulk by about 2400 bytes. Removed ::HandlerExists
		 					in favor of FailInfo::HandlerExists. Made gTopHandler a static member of FailInfo
		01/17/95	Added & in TAppleEvent::ReadError.
		 12/8/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		 11/1/95	Make drag cursor and script idle code resident. 
		10/25/95	Changed TAppleEvent::InitializeFromMessage to retrieve the
							reply mode from the source message.  Added
							TAppleEvent::GetProcessSerialNumber.  1290392
		10/25/95	Add CAEDesc_AC::ReadFrom and WriteTo resource versions.
							CAEDesc_AC::DisposeDesc sets fields to safe values.
		10/24/95	Replace calls to GetBestType with GetSpecifierForm.
		10/21/95	Use GetBestType() in calls to MakeObjectSpecifier. 
		 10/2/95	Test gBusyCursor before using it.
		----- 3.3b1 -----
		 8/22/95	Make sure we're not writing to a null reply in TAppleEvent::WriteOSError.
		 8/10/95	Include UDialog to get MAParamText and MAReplaceText. 
		  8/8/95	Added TAppleEvent::WriteOSError for reporting errors which
		  					are documented in the errReasonID 'errs' resource.
		  7/6/95	Add a comment about debugging through AESend. 
		 6/29/95	CTempDesc_AC::~CTempDesc_AC nulls data members.
		 6/28/95	Add TAppleEvent::ReadError.
		 6/20/95	Unitialized variable in Send caused crashes.
		 6/19/95	Add TAppleEvent::SendEvent() and Send(TAppleEvent*&)
		 6/14/95	MakeCreateElementEvent had improperly scoped CTempDescs.
		 6/13/95	Add TAppleEvent::MakeCreateElementEvent.
		 6/5/95		GSF		ReadParameter returns an error instead of throwing.
		 					CAEDesc_AC copy constructor uses member initializer list
		 					Add CAEDesc_AC::CAEDesc_AC(const AEDesc* theDesc)
		 					Add and use TAppleEvent::fgIdleProc and fgFilterProc
		 					Add TAppleEvent::WriteError.
							Add CAEDesc_AC::fgNullDesc
							Add TAppleEvent::ReadEventClass and ReadEventID
		 5/26/95	GetTransactionID never throws an exception. If a transactionID
		 					is not available, return 0.
		 5/17/95	Add CanCoerceDesc which doesn't call Failure.
		 4/14/95	save/lock and restore handle state instead of lock and unlock
		 4/12/95	Use #if instead of if qDebug. 
		 3/24/95	ARM 8.4.3 x& cannot be initialized with volatile x. 
		 3/17/95	MAVolatile. 
		 3/13/95	Change Free methods to destructors. 
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		 1/26/95	Add KeepCursorBusy around call to AESend in TAppleEvent::Send. 
							Change WritePtrList and WriteHandleList to use CAEDesc_AC instead 
							of AEDescList. Change EqualDesc to use CompareDesc. 
							Add CompareDesc. Add CreateList, CountListItems, GetNthItem, 
							PutListItem, DeleteListItem, CreateRecord and DeleteKeyDesc. 
		 2/14/95	Add failure handler to TAppleEvent::WriteReplySpecifier
							to catch throws from subroutines. 
		----- 3.5d3 Release -----
		 9/28/94	Add CAEDesc_AC::GetFSSpec and CAEDesc_AC::PutFSSpec.
		 9/26/94	Add local AEDesc variables to several routines to
							prevent CFront compiler warnings.
		 9/22/94	Moved several global routines and variables to
							UScripting.h.
		 8/22/94	Added CAEDesc_AC::GetKeyDesc  and CAEDesc_AC::PutKeyDesc (per Ken Ryall).
		 7/18/94	CAEDesc_AC::GetObject now returns gDispatcher if it has a
							null descriptor (as per Ken Ryall). 
							Add this, CreateDesc, GetKeyPtr and PutKeyPtr.
							DisposeDesc now returns a status. Fixed CTempDesc_AC to 
							use its embedded failure handler safely. 
		 7/14/94	Merged with Ken Ryall's MAScript changes. 
*/