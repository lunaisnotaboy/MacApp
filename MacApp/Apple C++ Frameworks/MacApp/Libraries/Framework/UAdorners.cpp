//----------------------------------------------------------------------------------------
// UAdorners.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/01/01	Need to include CReporter_AC. 
		01/02/01	Update copyright.
		11/10/00	Cosmetic.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		09/01/00	Added embedded documentation. 
		08/31/00	Use MStreamable_AC instead of MStreamable.
		07/31/00	Cosmetic. [W] Don't implement TRRectAdorner::Draw.
					Don't FrameRoundRect in TCompatibilityAdorner::Draw.
					GetStandardSignature should be const.
		03/24/99	Update copyright notice.
		03/23/99	Go back to native Toolbox region, rect and line calls.
		03/22/99	[W] Can't call DrawResizeIcon.
		03/18/99	Removed '&' on parms to a variety of Toolbox calls.
		11/05/98	Moved InitUAdorners to bottom of file to get around Mach-0 link errors
		10/29/98	No longer need to include QTMLMapNames.h.  Use FrameRect_AC,
					CopyRgn_AC, PaintRgn_AC, LineTo_AC instead of FrameRect, CoprRgn,
					PaintRgn_AC, LineTo_AC.  Include ImagingUtils_AC.h.
*/

#ifndef __UADORNERS__
#include "UAdorners.h"
#endif

// MacApp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

//----------------------------------------------------------------------------------------
// Definition for global variables declared in interface:

// Static, pre-allocated, shared adorners
TDimAdorner			TAdorner::fgDimAdorner;
TDrawAdorner		TAdorner::fgDrawAdorner;
TEraseAdorner		TAdorner::fgEraseAdorner;
THiliteAdorner		TAdorner::fgHiliteAdorner;
TPrintAdorner		TAdorner::fgPrintAdorner;
TResizeIconAdorner	TAdorner::fgResizeIconAdorner;
TSelectionAdorner	TAdorner::fgSelectionAdorner;

//========================================================================================
// CLASS CAdornerIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CAdornerIterator constructor
//----------------------------------------------------------------------------------------

CAdornerIterator::CAdornerIterator(const TView* theView,
								   ArrayIndex_AC itsLowBound,
								   ArrayIndex_AC itsHighBound,
								   bool itsForward) :
	fIterator(theView ? theView->GetAdorners() : NULL, itsLowBound, itsHighBound, itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CAdornerIterator constructor
//----------------------------------------------------------------------------------------

CAdornerIterator::CAdornerIterator(const TView* theView, bool itsForward)
	:	fIterator(theView ? theView->GetAdorners() : NULL, itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CAdornerIterator constructor
//----------------------------------------------------------------------------------------

CAdornerIterator::CAdornerIterator(const TAdornerList*	theAdornerList,
								   ArrayIndex_AC		itsLowBound,
								   ArrayIndex_AC		itsHighBound,
								   bool					itsForward)
	:	fIterator(theAdornerList, itsLowBound, itsHighBound, itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CAdornerIterator constructor
//----------------------------------------------------------------------------------------

CAdornerIterator::CAdornerIterator(const TAdornerList*	theAdornerList,
								   bool					itsForward)
	:	fIterator(theAdornerList, itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CAdornerIterator::First:
//----------------------------------------------------------------------------------------

TAdorner* CAdornerIterator::First()
{
	return fCurrent = fIterator.First() ? fIterator.Current()->adorner : NULL;
}

//----------------------------------------------------------------------------------------
// CAdornerIterator::Next:
//----------------------------------------------------------------------------------------

TAdorner* CAdornerIterator::Next()
{
	return fCurrent = fIterator.Next() ? fIterator.Current()->adorner : NULL;
}


//========================================================================================
// CLASS TAdorner
//========================================================================================

MA_DEFINE_CLASS(TAdorner);

//----------------------------------------------------------------------------------------
// NewStdAdorner:
//----------------------------------------------------------------------------------------

TAdorner* TAdorner::NewStdAdorner(	IDType		signature,
									const char*	className,
									IDType		itsID,
									bool		freeOnDeletion)
{
	MStreamable_AC* object = ::NewObjectBySignature_AC(signature, className);

	TAdorner* anAdorner = dynamic_cast_AC(TAdorner*,object);
	if(anAdorner) 
		anAdorner->Set(itsID, freeOnDeletion);
	else 
		delete object;
	
	return anAdorner;
}

//----------------------------------------------------------------------------------------
// TAdorner constructor 
//----------------------------------------------------------------------------------------

TAdorner::TAdorner(IDType itsID, bool freeOnDeletion, bool isOpaque)
	:	fIdentifier(itsID),
		fFreeOnDeletion(freeOnDeletion),
		fIsOpaque(isOpaque)
{
}
 
//----------------------------------------------------------------------------------------
// TAdorner destructor
//----------------------------------------------------------------------------------------

TAdorner::~TAdorner()
{
}

//----------------------------------------------------------------------------------------
// TAdorner constructor 
//----------------------------------------------------------------------------------------

void TAdorner::Set(IDType itsID, bool freeOnDeletion)
{
	fIdentifier = itsID;
	fFreeOnDeletion = freeOnDeletion;
}

//----------------------------------------------------------------------------------------
// TAdorner::AddedToView:
//----------------------------------------------------------------------------------------

void TAdorner::AddedToView(TView* itsView)
// AddedToView is intended to take appropriate actions when an adorner is 
// added to a view. TAdorner::AddedToView is an empty method. You can override
// this method to take appropriate action.
//
// itsView:	Specifies the view object to which the adorner was added.
//
// Call?		Seldom. MacApp calls this method when an adorner 
//				is added to a view.
// Override?	As needed.
{
	#pragma unused (itsView)
}

//----------------------------------------------------------------------------------------
// TAdorner::RemovedFromView:
//----------------------------------------------------------------------------------------

void TAdorner::RemovedFromView(TView* itsView)
{
	#pragma unused (itsView)
}

//----------------------------------------------------------------------------------------
// TAdorner::ReadFrom:
//----------------------------------------------------------------------------------------

void TAdorner::ReadFrom(CStream_AC* aStream)
{
	MStreamable_AC::ReadFrom(aStream);

	fIdentifier = aStream->ReadIDType();
	fFreeOnDeletion = aStream->ReadBoolean();
}

//----------------------------------------------------------------------------------------
// TAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TAdorner::GetStandardSignature() const
{
	return fIdentifier;
}

//----------------------------------------------------------------------------------------
// TAdorner::WriteTo:
//----------------------------------------------------------------------------------------

void TAdorner::WriteTo(CStream_AC* aStream) const
{
	MStreamable_AC::WriteTo(aStream);

	aStream->WriteIDType(fIdentifier);
	aStream->WriteBoolean(fFreeOnDeletion);
}

//----------------------------------------------------------------------------------------
// TAdorner::Draw:
//----------------------------------------------------------------------------------------

void TAdorner::Draw(TView*				itsView,
					const CViewRect&	area)
{
	#pragma unused (itsView, area)
}

//----------------------------------------------------------------------------------------
// TAdorner::DrawLine:
//----------------------------------------------------------------------------------------

void TAdorner::DrawLine(VHSelect vhs,
						short lh,
						short lv,
						short lto)
{
	::MoveToPt(CPoint_AC(lh, lv));
	if (vhs == hSel)
		::Line(lto - lh, 0);
	else
		::Line(0, lto - lv);
}

//----------------------------------------------------------------------------------------
// TAdorner::DoHighlightSelection:
//----------------------------------------------------------------------------------------

void TAdorner::DoHighlightSelection(TView*				itsView,
									const CViewRect&	area,
									HLState				fromHL,
									HLState				toHL)
{
	#pragma unused (itsView, area, fromHL, toHL)
}

//----------------------------------------------------------------------------------------
// TAdorner::InvalidateAdorner:
//----------------------------------------------------------------------------------------

void TAdorner::InvalidateAdorner(TView* itsView)
{
	if (itsView)
		itsView->ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TAdorner::ViewChangedFrame:
//----------------------------------------------------------------------------------------

void TAdorner::ViewChangedFrame(TView*			 	itsView,
								const CViewRect&	 oldFrame,
								const CViewRect&	 newFrame,
								bool			 	invalidate)
{
	#pragma unused (itsView, oldFrame, newFrame, invalidate)
}

//----------------------------------------------------------------------------------------
// TAdorner::DoesAdorn:
//----------------------------------------------------------------------------------------

bool TAdorner::DoesAdorn(const TView* itsView) const
{
	#pragma unused (itsView)
	return true;
}

//========================================================================================
// CLASS TCompatibilityAdorner
//========================================================================================

MA_DEFINE_CLASS(TCompatibilityAdorner);

//----------------------------------------------------------------------------------------
// TCompatibilityAdorner destructor
//----------------------------------------------------------------------------------------

TCompatibilityAdorner::~TCompatibilityAdorner()
{
}

//----------------------------------------------------------------------------------------
// TCompatibilityAdorner::TCompatibilityAdorner:
//----------------------------------------------------------------------------------------

TCompatibilityAdorner::TCompatibilityAdorner(CntlAdornment itsAdornment) :
	TAdorner(kCompatibilityAdorner, kFreeOnDeletion),

	fAdornment(itsAdornment)
{
}

//----------------------------------------------------------------------------------------
// TCompatibilityAdorner::ReadFrom:
//----------------------------------------------------------------------------------------

void TCompatibilityAdorner::ReadFrom(CStream_AC* aStream)
{
	TAdorner::ReadFrom(aStream);

	aStream->ReadBytes(&fAdornment, sizeof(CntlAdornment));
}

//----------------------------------------------------------------------------------------
// TCompatibilityAdorner::WriteTo:
//----------------------------------------------------------------------------------------

void TCompatibilityAdorner::WriteTo(CStream_AC* aStream) const
{
	TAdorner::WriteTo(aStream);

	CntlAdornment itsAdornment = fAdornment;
	aStream->WriteBytes(&itsAdornment, sizeof(CntlAdornment));
}

//----------------------------------------------------------------------------------------
// TCompatibilityAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TCompatibilityAdorner::GetStandardSignature() const
{
	return kCompatibilityAdorner;
}

//----------------------------------------------------------------------------------------
// TCompatibilityAdorner::Draw:
//----------------------------------------------------------------------------------------

void TCompatibilityAdorner::Draw(TView* itsView,
								 const CViewRect& area)
{
	if (fAdornment)
	{
		CViewRect itsAdornExtent(itsView->GetAdornExtent());
		if (!(area & itsAdornExtent).Empty())	// is there something to draw?
		{
			CRect_AC qdArea(itsView->ViewToQD(itsAdornExtent));// convert to QD coord's 

			if (macroIn(fAdornment, adnShadow))
			{
				::OpenRgn();
				::ShowPen();						// so drawing occurs 
			}


			if ((fAdornment & kFrame) == kFrame)// adnFrame
				::MacFrameRect(&qdArea);
			else
			{
				if (macroIn(fAdornment, adnLineTop))
					DrawLine(hSel, qdArea.left, qdArea.top, qdArea.right);

				if (macroIn(fAdornment, adnLineLeft))
					DrawLine(vSel, qdArea.left, qdArea.top, qdArea.bottom);

				if (macroIn(fAdornment, adnLineBottom))
				{
					PenState pnState;
					::GetPenState(&pnState);
					DrawLine(hSel, qdArea.left, qdArea.bottom - pnState.pnSize.v, qdArea.right);// account for pen height 
				}

				if (macroIn(fAdornment, adnLineRight))
				{
					PenState pnState;
					::GetPenState(&pnState);
					DrawLine(vSel, qdArea.right - pnState.pnSize.h, qdArea.top, qdArea.bottom);// account for pen width 
				}
			}

			if (macroIn(fAdornment, adnOval))
				::FrameOval(qdArea);

#if !qMSWindows
			if (macroIn(fAdornment, adnRRect))
				::FrameRoundRect(qdArea, 16, 16);
#endif

			if (macroIn(fAdornment, adnShadow))
			{
				PenState pnState;

				CTempRegion_AC tempRgn;
				CTempRegion_AC tempRgn2;

				::HidePen();
				::CloseRgn(tempRgn);

				::MacCopyRgn(tempRgn, tempRgn2);
				::GetPenState(&pnState);
				::MacOffsetRgn(tempRgn2, pnState.pnSize.h, pnState.pnSize.v);
				::DiffRgn(tempRgn2, tempRgn, tempRgn2);
				::MacPaintRgn(tempRgn2);
			}
		}
	}
}

//========================================================================================
// CLASS TDimAdorner
//========================================================================================

MA_DEFINE_CLASS(TDimAdorner);

//----------------------------------------------------------------------------------------
// TDimAdorner destructor
//----------------------------------------------------------------------------------------

TDimAdorner::~TDimAdorner()
{
}

//----------------------------------------------------------------------------------------
// TDimAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TDimAdorner::GetStandardSignature() const
{
	return kDimAdorner;
}

//----------------------------------------------------------------------------------------
// TDimAdorner::Draw:
//----------------------------------------------------------------------------------------

void TDimAdorner::Draw(TView* itsView,
					   const CViewRect&)
{
	itsView->Dim();
}

//========================================================================================
// CLASS TDrawAdorner
//========================================================================================

MA_DEFINE_CLASS(TDrawAdorner);

//----------------------------------------------------------------------------------------
// TDrawAdorner destructor
//----------------------------------------------------------------------------------------

TDrawAdorner::~TDrawAdorner()
{
}

//----------------------------------------------------------------------------------------
// TDrawAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TDrawAdorner::GetStandardSignature() const 
{
	return kDrawAdorner;
}

//----------------------------------------------------------------------------------------
// TDrawAdorner::Draw:
//----------------------------------------------------------------------------------------

void TDrawAdorner::Draw(TView* itsView,
						const CViewRect& area)
{
	::PenNormal();
	itsView->Draw(area);
}

//========================================================================================
// CLASS TEraseAdorner
//========================================================================================

MA_DEFINE_CLASS(TEraseAdorner);

//----------------------------------------------------------------------------------------
// TEraseAdorner destructor
//----------------------------------------------------------------------------------------

TEraseAdorner::~TEraseAdorner()
{
}

//----------------------------------------------------------------------------------------
// TEraseAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TEraseAdorner::GetStandardSignature() const 
{
	return kEraseAdorner;
}

//----------------------------------------------------------------------------------------
// TEraseAdorner::Draw:
//----------------------------------------------------------------------------------------

void TEraseAdorner::Draw(TView* itsView,
						 const CViewRect& area)
{
	::EraseRect(itsView->ViewToQD(area));
}

//========================================================================================
// CLASS THiliteAdorner:
//========================================================================================

MA_DEFINE_CLASS(THiliteAdorner);

//----------------------------------------------------------------------------------------
// THiliteAdorner destructor
//----------------------------------------------------------------------------------------

THiliteAdorner::~THiliteAdorner()
{
}

//----------------------------------------------------------------------------------------
// THiliteAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType THiliteAdorner::GetStandardSignature() const
{
	return kHiliteAdorner;
}

//----------------------------------------------------------------------------------------
// THiliteAdorner::Draw:
//----------------------------------------------------------------------------------------

void THiliteAdorner::Draw(TView* itsView,
						  const CViewRect&)
{
	itsView->Hilite();
}

//========================================================================================
// CLASS TResizeIconAdorner
//========================================================================================

MA_DEFINE_CLASS(TResizeIconAdorner);

//----------------------------------------------------------------------------------------
// TResizeIconAdorner destructor
//----------------------------------------------------------------------------------------

TResizeIconAdorner::~TResizeIconAdorner()
{
}

//----------------------------------------------------------------------------------------
// TResizeIconAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TResizeIconAdorner::GetStandardSignature() const 
{
	return kResizeIconAdorner;
}

//----------------------------------------------------------------------------------------
// TResizeIconAdorner::DoHighlightSelection:
//----------------------------------------------------------------------------------------

void TResizeIconAdorner::DoHighlightSelection(TView*			itsView,
											  const CViewRect&	area,
											  HLState			fromHL,
											  HLState			toHL)
{
	#pragma unused (area, fromHL, toHL)

#if qMSWindows
	#pragma unused (itsView)
#else
	TWindow* window = dynamic_cast_or_throw_AC(TWindow*,itsView);
	window->DrawResizeIcon();
#endif
}

//========================================================================================
// CLASS TSelectionAdorner
//========================================================================================

MA_DEFINE_CLASS(TSelectionAdorner);

//----------------------------------------------------------------------------------------
// TSelectionAdorner destructor
//----------------------------------------------------------------------------------------

TSelectionAdorner::~TSelectionAdorner()
{
}

//----------------------------------------------------------------------------------------
// TSelectionAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TSelectionAdorner::GetStandardSignature() const 
{
	return kSelectionAdorner;
}

//----------------------------------------------------------------------------------------
// TSelectionAdorner::DoHighlightSelection:
//----------------------------------------------------------------------------------------

void TSelectionAdorner::DoHighlightSelection(TView*				itsView,
											 const CViewRect&	area,
											 HLState			fromHL,
											 HLState			toHL)
{
	#pragma unused (area)
	::PenNormal();
	itsView->DoHighlightSelection(fromHL, toHL);
}

//========================================================================================
// CLASS TPrintAdorner
//========================================================================================

MA_DEFINE_CLASS(TPrintAdorner);

//----------------------------------------------------------------------------------------
// TPrintAdorner destructor
//----------------------------------------------------------------------------------------

TPrintAdorner::~TPrintAdorner()
{
}

//----------------------------------------------------------------------------------------
// TPrintAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TPrintAdorner::GetStandardSignature() const
{
	return kPrintAdorner;
}

//----------------------------------------------------------------------------------------
// TPrintAdorner::DoHighlightSelection:
//----------------------------------------------------------------------------------------

void TPrintAdorner::DoHighlightSelection(TView*				itsView,
										 const CViewRect&	area,
										 HLState			fromHL,
										 HLState			toHL)
{
	#pragma unused (toHL)
	// only do this in the "HandleDraw" case; in which case "fromHL" is hlOff 
	if (fromHL == hlOff)
		itsView->DoDrawPrintFeedback(area);
}

//========================================================================================
// CLASS TFrameAdorner
//========================================================================================

MA_DEFINE_CLASS(TFrameAdorner);

//----------------------------------------------------------------------------------------
// TFrameAdorner destructor
//----------------------------------------------------------------------------------------

TFrameAdorner::~TFrameAdorner()
{
}

//----------------------------------------------------------------------------------------
// TFrameAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TFrameAdorner::GetStandardSignature() const 
{
	return kFrameAdorner;
}

//----------------------------------------------------------------------------------------
// TFrameAdorner::Draw:
//----------------------------------------------------------------------------------------

void TFrameAdorner::Draw(TView* itsView, const CViewRect& area)
{
	CViewRect itsAdornExtent(itsView->GetAdornExtent());

	if (!(area & itsAdornExtent).Empty())		// is there something to draw?
		::MacFrameRect(itsView->ViewToQD(itsAdornExtent));
}


//========================================================================================
// CLASS TShadowedFrameAdorner
//========================================================================================

MA_DEFINE_CLASS(TShadowedFrameAdorner);

//----------------------------------------------------------------------------------------
// TShadowedFrameAdorner destructor
//----------------------------------------------------------------------------------------

TShadowedFrameAdorner::~TShadowedFrameAdorner()
{
}

//----------------------------------------------------------------------------------------
// TShadowedFrameAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TShadowedFrameAdorner::GetStandardSignature() const 
{
	return kShadowedFrameAdorner;
}

//----------------------------------------------------------------------------------------
// TShadowedFrameAdorner::Draw:
//----------------------------------------------------------------------------------------

void TShadowedFrameAdorner::Draw(TView* itsView, const CViewRect& area)
{
	CViewRect itsAdornExtent(itsView->GetAdornExtent());

	if (!(area & itsAdornExtent).Empty())		// is there something to draw?
	{
		CRect_AC qdArea(itsView->ViewToQD(itsAdornExtent));// convert to QD coord's 
		--qdArea[botRight];

		::PenSize(1, 1);
		::MacFrameRect(qdArea);
		::MoveTo(qdArea.left + 1, qdArea.bottom);
		::LineToPt(qdArea[botRight]);
		::MacLineTo(qdArea.right, qdArea.top + 1);
	}
}

//========================================================================================
// CLASS TLineBottomAdorner
//========================================================================================

MA_DEFINE_CLASS(TLineBottomAdorner);

//----------------------------------------------------------------------------------------
// TLineBottomAdorner destructor
//----------------------------------------------------------------------------------------

TLineBottomAdorner::~TLineBottomAdorner()
{
}

//----------------------------------------------------------------------------------------
// TLineBottomAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TLineBottomAdorner::GetStandardSignature() const
{
	return kLineBottomAdorner;
}

//----------------------------------------------------------------------------------------
// TLineBottomAdorner::Draw:
//----------------------------------------------------------------------------------------

void TLineBottomAdorner::Draw(TView* itsView, const CViewRect& area)
{
	CViewRect itsAdornExtent(itsView->GetAdornExtent());

	if (!(area & itsAdornExtent).Empty())		// is there something to draw?
	{
		PenState pnState;
		::GetPenState(&pnState);
		CRect_AC qdArea = itsView->ViewToQD(itsAdornExtent);// convert to QD coord's 
		DrawLine(hSel, qdArea.left, qdArea.bottom - pnState.pnSize.v, qdArea.right);// account for pen height 
	}
}

//========================================================================================
// CLASS TLineLeftAdorner
//========================================================================================

MA_DEFINE_CLASS(TLineLeftAdorner);

//----------------------------------------------------------------------------------------
// TLineLeftAdorner destructor
//----------------------------------------------------------------------------------------

TLineLeftAdorner::~TLineLeftAdorner()
{
}

//----------------------------------------------------------------------------------------
// TLineLeftAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TLineLeftAdorner::GetStandardSignature() const
{
	return kLineLeftAdorner;
}

//----------------------------------------------------------------------------------------
// TLineLeftAdorner::Draw:
//----------------------------------------------------------------------------------------

void TLineLeftAdorner::Draw(TView* itsView, const CViewRect& area)
{
	CViewRect itsAdornExtent(itsView->GetAdornExtent());

	if (!(area & itsAdornExtent).Empty())		// is there something to draw?
	{
		CRect_AC qdArea(itsView->ViewToQD(itsAdornExtent));// convert to QD coord's 
		DrawLine(vSel, qdArea.left, qdArea.top, qdArea.bottom);
	}
}


//========================================================================================
// CLASS TLineRightAdorner
//========================================================================================

MA_DEFINE_CLASS(TLineRightAdorner);

//----------------------------------------------------------------------------------------
// TLineRightAdorner destructor
//----------------------------------------------------------------------------------------

TLineRightAdorner::~TLineRightAdorner()
{
}

//----------------------------------------------------------------------------------------
// TLineRightAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TLineRightAdorner::GetStandardSignature() const
{
	return kLineRightAdorner;
}

//----------------------------------------------------------------------------------------
// TLineRightAdorner::Draw:
//----------------------------------------------------------------------------------------

void TLineRightAdorner::Draw(TView* itsView, const CViewRect& area)
{
	CViewRect itsAdornExtent(itsView->GetAdornExtent());

	if (!(area & itsAdornExtent).Empty())		// is there something to draw?
	{
		PenState pnState;
		::GetPenState(&pnState);
		CRect_AC qdArea(itsView->ViewToQD(itsAdornExtent));// convert to QD coord's 
		DrawLine(vSel, qdArea.right - pnState.pnSize.h, qdArea.top, qdArea.bottom);// account for pen width 
	}
}

//========================================================================================
// CLASS TLineTopAdorner
//========================================================================================

MA_DEFINE_CLASS(TLineTopAdorner);

//----------------------------------------------------------------------------------------
// TLineTopAdorner destructor
//----------------------------------------------------------------------------------------

TLineTopAdorner::~TLineTopAdorner()
{
}

//----------------------------------------------------------------------------------------
// TLineTopAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TLineTopAdorner::GetStandardSignature() const
{
	return kLineTopAdorner;
}

//----------------------------------------------------------------------------------------
// TLineTopAdorner::Draw:
//----------------------------------------------------------------------------------------

void TLineTopAdorner::Draw(TView* itsView, const CViewRect& area)
{
	CViewRect itsAdornExtent(itsView->GetAdornExtent());

	if (!(area & itsAdornExtent).Empty())		// is there something to draw?
	{
		CRect_AC qdArea(itsView->ViewToQD(itsAdornExtent));// convert to QD coord's 
		DrawLine(hSel, qdArea.left, qdArea.top, qdArea.right);
	}
}

//========================================================================================
// CLASS TOvalAdorner
//========================================================================================

MA_DEFINE_CLASS(TOvalAdorner);

//----------------------------------------------------------------------------------------
// TOvalAdorner destructor
//----------------------------------------------------------------------------------------

TOvalAdorner::~TOvalAdorner()
{
}

//----------------------------------------------------------------------------------------
// TOvalAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TOvalAdorner::GetStandardSignature() const 
{
	return kOvalAdorner;
}

//----------------------------------------------------------------------------------------
// TOvalAdorner::Draw:
//----------------------------------------------------------------------------------------

void TOvalAdorner::Draw(TView* itsView, const CViewRect& area)
{
	CViewRect itsAdornExtent(itsView->GetAdornExtent());

	if (!(area & itsAdornExtent).Empty())		// is there something to draw?
		::FrameOval(itsView->ViewToQD(itsAdornExtent));
}

//========================================================================================
// CLASS TRRectAdorner
//========================================================================================

MA_DEFINE_CLASS(TRRectAdorner);

//----------------------------------------------------------------------------------------
// TRRectAdorner destructor
//----------------------------------------------------------------------------------------

TRRectAdorner::~TRRectAdorner()
{
}

//----------------------------------------------------------------------------------------
// TRRectAdorner::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TRRectAdorner::GetStandardSignature() const
{
	return kRRectAdorner;
}

//----------------------------------------------------------------------------------------
// TRRectAdorner::Draw:
//----------------------------------------------------------------------------------------

void TRRectAdorner::Draw(TView* itsView, const CViewRect& area)
{
#if qMSWindows
	#pragma unused (itsView, area)
#else
	CViewRect itsAdornExtent(itsView->GetAdornExtent());

	if (!(area & itsAdornExtent).Empty())		// is there something to draw?
		::FrameRoundRect(itsView->ViewToQD(itsAdornExtent), 16, 16);
#endif
}

//========================================================================================
// CLASS TAdornerList
//========================================================================================

MA_DEFINE_CLASS(TAdornerList);

//----------------------------------------------------------------------------------------
// TAdornerList destructor
//----------------------------------------------------------------------------------------

TAdornerList::~TAdornerList()
{
}

//----------------------------------------------------------------------------------------
// TAdornerList::ReadFrom:
//----------------------------------------------------------------------------------------

void TAdornerList::ReadFrom(CStream_AC* aStream)
{
	TemplateSortedArray_AC<AdornerElement>::ReadFrom(aStream);

	// read the size of the list
	ArrayIndex_AC itsSize;
	itsSize = aStream->ReadLong();

	// add in each element
	for (short count = 0; count < itsSize; ++count)
	{
		AdornPriority itsPriority = aStream->ReadByte();

		bool wasValid;
		TAdorner * itsAdorner = dynamic_cast_or_throw_AC(TAdorner*,aStream->ReadStreamObject(wasValid));
		if (wasValid && itsAdorner)
			AddAdorner(itsAdorner, itsPriority);
#if qDebugMsg
		else
			::ProgramBreak_AC("###Unknown TAdorner in TAdornerList::ReadFrom.");
#endif

	}
}

//----------------------------------------------------------------------------------------
// TAdornerList::WriteTo:
//----------------------------------------------------------------------------------------

void TAdornerList::WriteTo(CStream_AC* aStream) const
{
	TemplateSortedArray_AC<AdornerElement>::WriteTo(aStream);

	// write the size of the list
	ArrayIndex_AC itsSize;
	itsSize = GetSize();
	aStream->WriteLong(itsSize);

	// write out each element
	if (itsSize > 0)
		for (short count = 1; count <= itsSize; ++count)
		{
			AdornerElement(& theAdornerElement)(At(count));

			aStream->WriteByte(theAdornerElement.priority);

			aStream->WriteStreamObject(theAdornerElement.adorner, kStandardObject);
		}
}

//----------------------------------------------------------------------------------------
// TAdornerList::CompareElements:
//----------------------------------------------------------------------------------------

CompareResult_AC TAdornerList::Compare(const AdornerElement& record1,
											const AdornerElement& record2) const
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;

	if (record1.priority > record2.priority)
		returnVal = kItem1GreaterThanItem2_AC;
	else if (record1.priority < record2.priority)
		returnVal = kItem1LessThanItem2_AC;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TAdornerList::AddAdorner:
//----------------------------------------------------------------------------------------

void TAdornerList::AddAdorner(TAdorner* itsAdorner, AdornPriority itsPriority)
// See TAdornerList.							  
{
	// Need to avoid adding itsAdorner with itsPriority if it's already in the array, so test each
	// item in the array and then bail out if it's already in the array.
	bool wasInList = false;
	ArrayIndex_AC itsSize = GetSize();
	if (itsSize > 0)
		for (short count = 1; count <= itsSize; ++count)
		{
			AdornerElement(& theAdornerElement)(At(count));

			if ((theAdornerElement.adorner == itsAdorner) && (theAdornerElement.priority == itsPriority))
			{
				wasInList = true;
				break;							// it's already in the list, so bail out.
			}
		}

	if (!wasInList)
		// It's not already in the list, so insert it.
		Insert(AdornerElement(itsPriority, itsAdorner));
}

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUAdorners:
//----------------------------------------------------------------------------------------

void InitUAdorners()
{
	// Register the system-supplied adorners 
	REGISTER_CLASS_AC(TAdornerList);

	REGISTER_SIGNATURE_AC(TCompatibilityAdorner, kCompatibilityAdorner);
	REGISTER_SIGNATURE_AC(TDimAdorner, kDimAdorner);
	REGISTER_SIGNATURE_AC(TDrawAdorner, kDrawAdorner);
	REGISTER_SIGNATURE_AC(TEraseAdorner, kEraseAdorner);
	REGISTER_SIGNATURE_AC(TFrameAdorner, kFrameAdorner);
	REGISTER_SIGNATURE_AC(THiliteAdorner, kHiliteAdorner);
	REGISTER_SIGNATURE_AC(TLineBottomAdorner, kLineBottomAdorner);
	REGISTER_SIGNATURE_AC(TLineLeftAdorner, kLineLeftAdorner);
	REGISTER_SIGNATURE_AC(TLineRightAdorner, kLineRightAdorner);
	REGISTER_SIGNATURE_AC(TLineTopAdorner, kLineTopAdorner);
	REGISTER_SIGNATURE_AC(TOvalAdorner, kOvalAdorner);
	REGISTER_SIGNATURE_AC(TPrintAdorner, kPrintAdorner);
	REGISTER_SIGNATURE_AC(TResizeIconAdorner, kResizeIconAdorner);
	REGISTER_SIGNATURE_AC(TRRectAdorner, kRRectAdorner);
	REGISTER_SIGNATURE_AC(TSelectionAdorner, kSelectionAdorner);
	REGISTER_SIGNATURE_AC(TShadowedFrameAdorner, kShadowedFrameAdorner);
}

//----------------------------------------------------------------------------------------
// End of UAdorners.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/09/96	Removed UStreamable to a separate file from UObject
		05/02/95	Don't call Free in TAdorner::RemovedFromSubview. if necessary the caller should free the object
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/29/96	Create and use functions that return their data as results for:
							TStream::ReadCharacter/CViewPoint/Rect/CViewRect/RGBColor/String. Create compatible inlines
							so users don't have to change their code.
		04/29/96	when using stream->Readxxx calls read directly into the data members when possible
		04/26/96	Made TControl::ControlArea/ControlQDArea non virtual. Made TView/TControl::GetAdornExtent
							return their CViewRect as function results
		04/23/96	Update iterators to be OD stylish
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/29/96	Made argument to CAdornerIterator const TView*, made several initializers
							inline
		03/25/96	TToolboxEvent::fCharacter is obsolete
							Made empty UAdorners constructors inline
		03/25/96	TToolboxEvent::fCharacter is obsolete
		03/18/96	Made better use of TView calls that return CRect_AC/CViewPoint/CViewRect
		12/08/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		10/19/95	Use MoveToPt, LineToPt.
		----- 3.3b1 -----
		04/12/95	Base class constructors called from mem initializers don't
		 					rely on default arguments.
		03/13/95	Change Free methods to destructors. 
		03/01/95	Always register TAdornerList. 
		02/28/95	Use MA_REGISTER_SIGNATURE instead of macroDontDeadStrip
							and RegisterStdType. 
		11/09/94	Add workaround for possible MW compiler problem. 
*/