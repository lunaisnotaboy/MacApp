//----------------------------------------------------------------------------------------
// UDebugView.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		08/09/99	Changed MA_REGISTER_CLASS to REGISTER_CLASS_AC.
					Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __UDEBUGVIEW__
#include "UDebugView.h"
#endif

#if qDebug

// MacApp

#ifndef __UCHECKBOX__
#include "UCheckBox.h"
#endif

#ifndef __UCLUSTER__
#include "UCluster.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDIALOG__
#include "UDialog.h"
#endif

#ifndef __UDIALOGBEHAVIOR__
#include "UDialogBehavior.h"
#endif

#ifndef __USTATICTEXT__
#include "UStaticText.h"
#endif

//========================================================================================
// CLASS TDebugFlagsView
//========================================================================================

MA_DEFINE_CLASS(TDebugFlagsView);

//----------------------------------------------------------------------------------------
// TDebugFlagsView::DoEvent:
//----------------------------------------------------------------------------------------

void TDebugFlagsView::DoEvent(EventNumber eventNumber,
									 TEventHandler* source,
									 TEvent* event)
{
	if (eventNumber == mCheckBoxHit)
	{
		switch (source->GetIdentifier())
		{
			case 'usr1':
				gUserFlag1 = !gUserFlag1;
				break;
				
			case 'usr2':
				gUserFlag2 = !gUserFlag2;
				break;
				
			case 'usr3':
				gUserFlag3 = !gUserFlag3;
				break;
				
			case 'focu':
				gAssumeFocused = !gAssumeFocused;
				break;

			case 'prnt':
				gDebugPrinting = !gDebugPrinting;
				break;
				
			case 'ints':
				gIntenseDebugging = !gIntenseDebugging;
				break;
				
			case 'evnt':
				gReportEvent = !gReportEvent;
				break;
				
			case 'menu':
				gReportMenuChoices = !gReportMenuChoices;
				break;
				
			case 'curs':
				gShowCursorRegion = !gShowCursorRegion;
				break;
				
			case 'help':
				gShowHelpRegion = !gShowHelpRegion;
				break;
				
			case 'invl':
				gShowInvalidations = !gShowInvalidations;
				break;
				
			case 'slee':
				gShowSleepRegion = !gShowSleepRegion;
				break;
				
			case 'memb':
				gMemMgtBreak = !gMemMgtBreak;
				break;
				
			case 'rsrc':
				gRsrcReport = !gRsrcReport;
				break;
		}
	}
	else
		TView::DoEvent(eventNumber, source, event);
}


//----------------------------------------------------------------------------------------
// TDebugFlagsView::DoPostCreate:
//----------------------------------------------------------------------------------------

void TDebugFlagsView::DoPostCreate(TDocument* itsDocument)
{
	TView::DoPostCreate(itsDocument);

	// Synchronize the global flags and the check boxes used to set toggle them.

	#define SyncState(id,flag) do { TCheckBox* workBox = dynamic_cast_or_throw_AC(TCheckBox*,FindSubView(id)); \
								 	workBox->SetState(flag, false); } while(0)

	SyncState('usr1', gUserFlag1);
	SyncState('usr2', gUserFlag2);
	SyncState('usr3', gUserFlag3);
	SyncState('focu', gAssumeFocused);
	SyncState('prnt', gDebugPrinting);
	SyncState('ints', gIntenseDebugging);
	SyncState('evnt', gReportEvent);
	SyncState('menu', gReportMenuChoices);
	SyncState('curs', gShowCursorRegion);
	SyncState('help', gShowHelpRegion);
	SyncState('invl', gShowInvalidations);
	SyncState('slee', gShowSleepRegion);
	SyncState('memb', gMemMgtBreak);
	SyncState('rsrc', gRsrcReport);
	
	#undef SyncState
}

//----------------------------------------------------------------------------------------
// TDebugFlagsView::InitUDebugView:
//----------------------------------------------------------------------------------------

void TDebugFlagsView::InitUDebugView()
{		
	// Register views so we can create them from templates
	if (qTemplateViews)
	{
		InitUCluster();
		InitUCheckbox();
		InitUStaticText();	

		REGISTER_CLASS_AC(TDebugFlagsView);
		REGISTER_SIGNATURE_AC(TDialogBehavior, kStdDialogBehavior);
	}
}

#endif // qDebug

//----------------------------------------------------------------------------------------
// End of UDebugView.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		----- R10 -----
		06/25/96	[1345531] Added missing includes for noload buids
		10/17/95	Remove unnecessary includes. 
		10/14/95	Add back includes of fcntl and ioctl for non-Metrowerks. 
		 10/4/95	Include CWMacAppFCntl.h, CWMacAppIOCtl.h
		 					Remove includes of FCntl.h, IOCtl.h, DisAsmLookup.h
		----- 3.3b1 -----
		  7/9/95	Don't include Unmangler with Rainbow. 
		  7/7/95	Mark Anderson's CW6 changes.
		 5/17/95	#Include for USegments
		 4/23/95	Don't do anything if noDebug. 
		 3/13/95	Change Free methods to destructors. 
		  3/6/95	Include UDebug.h.
		 2/27/95	Split off from UDebug. 
*/