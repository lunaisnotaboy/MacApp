//----------------------------------------------------------------------------------------
// UMenuCommands.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/09/01	TraceMenuName used only in debug mode. 
		01/24/01	[W] Use AsStr255 in SetCommandName.
		01/15/01	Use CString_AC instead of CStr255_AC.
		01/02/01	Update copyright.
		12/27/00	Also check menu enabling in CommandEnabled.
		11/09/00	Need to convert menuText to char* for printing. 
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		02/24/00	[W] SetCommandIcon and SetStyle are empty implementations.
		02/22/00	[W] Added Windows implementations.  Include UDispatcher.h for 
							gDispatcher.
		01/04/00	Include UMacAppUtilities to get gBoolString. 
		11/09/99	Use IsMenuItemEnabled_AC. 
		11/05/99	Split off the menu command table to its own unit. 
							Iterate over all commands for enabling, etc. 
*/

#ifndef __UMenuCommands__
#include "UMenuCommands.h"
#endif

// MacApp

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMenuCommandTable__
#include "UMenuCommandTable.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#if qDebugMsg
	#ifndef __UMACAPPUTILITIES__
	#include "UMacAppUtilities.h"
	#endif
#endif

// ACS

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __MenuUtils_AC__
#include "MenuUtils_AC.h"
#endif

//========================================================================================
// GLOBAL Variables
//========================================================================================

TCmdTable pCmdTable;		// command numbers and their associated menu and item numbers

//========================================================================================
// GLOBAL Procedures
//========================================================================================

#if qDebugMsg

static char TraceMenuName(CommandNumber aCommand);

//----------------------------------------------------------------------------------------
// TraceMenuName: 
//----------------------------------------------------------------------------------------

char TraceMenuName(CommandNumber aCommand)
// For debugging purposes only--used to dump the name and number of a command 
{
	ProgramReport_AC(" %1d [%s],", aCommand, CChar255_AC(CommandToName(aCommand)));

	return ' ';
}

#endif

//----------------------------------------------------------------------------------------
// CommandEnabled: 
//----------------------------------------------------------------------------------------

bool CommandEnabled(CommandNumber command)
{
	bool returnVal = false;

#if !qMSWindows
	MenuID menuNo;
	short itemNo;
	MenuRef theMenu = CommandToComponents(command, menuNo, itemNo);

	if (theMenu)
		returnVal = IsMenuItemEnabled_AC(theMenu, itemNo) && IsMenuEnabled_AC(theMenu);
#else
	HMENU mainMenu = gDispatcher->GetWindowsMenuBar();

	UINT menuItem = (UINT)command;

	UINT oldState = GetMenuState(mainMenu, menuItem, MF_BYCOMMAND);
	if ((oldState != kMenuNotFound) && ((oldState&MF_GRAYED) != MF_GRAYED))
		returnVal = true;
#endif

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CommandFromMenuItem: 
//----------------------------------------------------------------------------------------

CommandNumber CommandFromMenuItem(short menu, short item)
{
	return pCmdTable.CommandFromMenuItem(menu, item);
}

//----------------------------------------------------------------------------------------
// CommandToMenuItem: 
//----------------------------------------------------------------------------------------

void CommandToMenuItem(CommandNumber aCommand, MenuID& menu, short& item)
{
	pCmdTable.CommandToMenuItem(aCommand, menu, item);
}

//----------------------------------------------------------------------------------------
// CommandToComponents: 
//----------------------------------------------------------------------------------------

MenuRef CommandToComponents(CommandNumber command, MenuID& menuNo, short& itemNo)
{
	MenuRef returnVal = NULL;

#if !qMSWindows
	CommandToMenuItem(command, menuNo, itemNo);
	if (menuNo > 0)									// was found 
		returnVal = MAGetMenu(menuNo);
#endif

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CommandToName: 
//----------------------------------------------------------------------------------------

CString_AC CommandToName(CommandNumber aCommand)
{
#if !qMSWindows
	Str255		theText;
	short		item;
	ResNumber	aMenu;
	MenuRef		itsMenuRef = CommandToComponents(aCommand, aMenu, item);

	if (itsMenuRef)
	{
		if (item)
		{
			GetMenuItemText(itsMenuRef, item, theText);
			return CString_AC(theText);
		}
		else
		{
#if !qCarbon
			// Toolbox has no interface for retrieving the title of a menu!!
			return CString_AC((*static_cast<MenuHandle>(itsMenuRef))->menuData);
#else
			// Carbon does have an interface!
			::GetMenuTitle(itsMenuRef, theText);
			return CString_AC(theText);
#endif
		}
	}
	else
		return CString_AC();
#else
	HMENU mainMenu = gDispatcher->GetWindowsMenuBar();
	
	UINT menuItem = (UINT)aCommand;
	
	char menuItemText[256];
	
	UINT state = ::GetMenuString(mainMenu, menuItem, menuItemText, sizeof(menuItemText), MF_BYCOMMAND);

	return CString_AC(menuItemText);
#endif
}

//----------------------------------------------------------------------------------------
// Enable: 
//----------------------------------------------------------------------------------------

void Enable(CommandNumber aCommand, bool canDo)
{
#if !qMSWindows
#if qDebugMsg
	if (gTraceSetupMenus)
		ProgramReport_AC("..... Enable(%c%s)\n", TraceMenuName(aCommand), CChar255_AC(gBoolString[canDo]));
#endif

	for (CCommandIterator iter(&pCmdTable, aCommand); iter; ++iter)
	{
		iter->Enable(canDo);
	}
#else
	HMENU mainMenu = gDispatcher->GetWindowsMenuBar();

	UINT flags = MF_GRAYED;
	if (canDo)
		flags = MF_ENABLED ;

	UINT menuItem = (UINT)aCommand;

	UINT oldState = GetMenuState(mainMenu, menuItem, MF_BYCOMMAND);
	if ((oldState != kMenuNotFound) && ((oldState&MF_GRAYED) != flags))
		::EnableMenuItem(mainMenu, menuItem, flags);
#endif
}

//----------------------------------------------------------------------------------------
// EnableCheck: 
//----------------------------------------------------------------------------------------

void EnableCheck(CommandNumber aCommand, bool canDo, bool checkIt)
{
#if !qMSWindows
#if qDebugMsg
	if (gTraceSetupMenus)
		ProgramReport_AC("..... EnableCheck(%c%s, %s)\n", 
						 TraceMenuName(aCommand), CChar255_AC(gBoolString[canDo]),
						 CChar255_AC(gBoolString[checkIt]));
#endif

	for (CCommandIterator iter(&pCmdTable, aCommand); iter; ++iter)
	{
		iter->EnableCheck(canDo, checkIt);
	}
#else
	Enable(aCommand, canDo);

	HMENU mainMenu = gDispatcher->GetWindowsMenuBar();

	UINT checked = MF_UNCHECKED;
	if (checkIt)
		checked = MF_CHECKED;

	UINT menuItem = (UINT)aCommand;
	
	UINT oldState = ::GetMenuState(mainMenu, menuItem, MF_BYCOMMAND);
	if ((oldState != kMenuNotFound) && ((oldState & MF_CHECKED) != checked))
		::CheckMenuItem(mainMenu, menuItem, checked);
#endif
}

//----------------------------------------------------------------------------------------
// SetCommandIcon: 
//----------------------------------------------------------------------------------------

void SetCommandIcon(CommandNumber aCommand, Byte menuIcon)
{
#if !qMSWindows
#if qDebugMsg
	if (gTraceSetupMenus)
		ProgramReport_AC("..... SetCommandIcon(%c%d)\n", TraceMenuName(aCommand), menuIcon);
#endif

	for (CCommandIterator iter(&pCmdTable, aCommand); iter; ++iter)
	{
		iter->SetIcon(menuIcon);
	}
#else
	#pragma unused (aCommand, menuIcon)
	#pragma message ("SetCommandIcon: Not available under Windows.")
#endif
}

//----------------------------------------------------------------------------------------
// SetCommandName: 
//----------------------------------------------------------------------------------------

void SetCommandName(CommandNumber aCommand, const CString_AC& menuText)
{
#if !qMSWindows
#if qDebugMsg
	if (gTraceSetupMenus)
		ProgramReport_AC("..... SetCommandName(%c'%s')\n", TraceMenuName(aCommand), CChar255_AC(menuText));
#endif

#if qDebug
	if (menuText.empty())
		::ProgramReport_AC("SetCommandName: Empty menuText - may corrupt the menu handle!");
#endif

	for (CCommandIterator iter(&pCmdTable, aCommand); iter; ++iter)
	{
		iter->SetName(CStr255_AC(menuText));
	}
#else
	HMENU mainMenu = gDispatcher->GetWindowsMenuBar();
	
	UINT menuItem = (UINT)aCommand;
	
	Str255		menuItemText;
	menuText.AsStr255(menuItemText);

	UINT state = ::GetMenuState(mainMenu, menuItem, MF_BYCOMMAND);
	if (state != kMenuNotFound)
		::ModifyMenu(mainMenu, menuItem, state, menuItem, reinterpret_cast<const char*>(&menuItemText[0]));
#endif
}

//----------------------------------------------------------------------------------------
// SetCommandName: 
//----------------------------------------------------------------------------------------

void SetCommandName(CommandNumber aCommand, ResNumber rsrcID, short strIndex)
{
	SetCommandName(aCommand, CString_AC(rsrcID, strIndex));
}

//----------------------------------------------------------------------------------------
// SetCommandName: 
//----------------------------------------------------------------------------------------

void SetCommandName(CommandNumber aCommand, ResNumber rsrcID,
					short falseBuzzItem, short trueBuzzItem, bool stateVariable)
{
	SetCommandName(aCommand, rsrcID, stateVariable ? trueBuzzItem : falseBuzzItem);
}

//----------------------------------------------------------------------------------------
// SetStyle: 
//----------------------------------------------------------------------------------------

void SetStyle(CommandNumber aCommand, StyleParameter aStyle)
{
#if !qMSWindows
#if qDebugMsg
	if (gTraceSetupMenus)
		ProgramReport_AC("..... SetStyle(%c%d)\n", TraceMenuName(aCommand), *((Ptr) & aStyle));
#endif

	for (CCommandIterator iter(&pCmdTable, aCommand); iter; ++iter)
	{
		iter->SetStyle(aStyle);
	}
#else
	#pragma unused (aCommand, aStyle)
	#pragma message ("SetStyle: Not available under Windows.")
#endif
}

//----------------------------------------------------------------------------------------
// AddCommand: 
//----------------------------------------------------------------------------------------

void AddCommand(CommandNumber commandNumber, MenuID menuNumber, short itemNumber)
{
	pCmdTable.AddCommand(commandNumber, menuNumber, itemNumber);
}

//----------------------------------------------------------------------------------------
// InsertCommand:
//----------------------------------------------------------------------------------------

void InsertCommand(CommandNumber commandNumber, MenuID menuNumber, short itemNumber)
{
	pCmdTable.InsertCommand(commandNumber, menuNumber, itemNumber);
}

//----------------------------------------------------------------------------------------
// DeleteMenuCommand:
//----------------------------------------------------------------------------------------

void DeleteMenuCommand(CommandNumber theMenuItemCommandNumber)
{
	pCmdTable.DeleteMenuCommand(theMenuItemCommandNumber);
}

//----------------------------------------------------------------------------------------
// UMenuCommands.cpp