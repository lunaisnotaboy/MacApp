//----------------------------------------------------------------------------------------
// UClipboardMgr.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/20/01	Add a WriteToDeskScrap utility method. 
		04/25/01	Replace ClearCurrent with ClearForPutting. 
					Don't go around CClipboard_AC. 
		04/23/01	Redesigned CClipboard_AC for Carbon. 
					Move fOldScrapStuff and fNewScrapStuff out of CClipboard_AC. 
					Now they are CClipboard_AC instances. 
					Remove error return from PutDeskScrapData. Errors are thrown. 
		03/01/01	Need to include CReporter_AC. 
		01/02/01	Update copyright.
		11/10/00	Cosmetic.  Removed Inherited.
		11/09/00	[PB] Change initialization order to match declaration. 
					[PB] Suppress GCC warnings about unused return variables. 
		09/18/00	[C] Call ScrapStillValid instead of ScrapCountStillValid.
					Reworked PutDeskScrapData.  Changed logic in CheckDeskScrap.
					TEST: Always convert clipboard in AboutToLoseControl.
		09/06/00	Added embedded documentation.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		01/13/00	Changed compare to assignment in PutDeskScrapData.
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Delete the document and view related to the clipboard in
					~TClipboardMgr.
		11/23/99	Carbon: Check for error in TClipboardMgr::PutDeskScrapData system calls.
		11/04/99	Carbon: Move GivePasteData and PutDeskScrapData APIs back to what they were (remove ScrapRef).
					The clipboard will get the current scrap, instead of the caller.
		10/27/99	Initialize gClipboardMgr.
		08/09/99	Changed MA_REGISTER_CLASS to REGISTER_CLASS_AC.
		07/23/99	[C] GetDataToPaste and PutDeskScrapData implementations changed.
		03/24/99	Update copyright notice.
		03/19/99	Rename GetMessage to GetExceptionMessage
					since it conflicts with a Windows define.
		10/08/98	Merge TCommandHandler into TEventHandler. 
*/

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

// MacApp

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDESKSCRAPVIEW__
#include "UDeskScrapView.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __CClipboard_AC__
#include "CClipboard_AC.h"
#endif

#ifndef __CDependencies_AC__
#include "CDependencies_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// ANSI

TClipboardMgr* gClipboardMgr = NULL;					// declared in interface

//========================================================================================
// CLASS TClipboardMgr
//========================================================================================

MA_DEFINE_CLASS(TClipboardMgr);

//----------------------------------------------------------------------------------------
// TClipboardMgr constructor
//----------------------------------------------------------------------------------------


TClipboardMgr::TClipboardMgr()
	:	TBehavior(kClipboardManager),	
		fOldScrapStuff(),
		fScrapStuff(),
		fClipWindow(NULL),
		fClipOrphanage(NULL),
		fClipView(NULL),
		fClipContext(NULL), 
		fPrefClipType(kNoIdentifier_AC),
		fGotClipType(false),
		fClipWrittenToDeskScrap(false)
{
	gClipboardMgr = this;

	AbsorbScrapStuff();							// get the initial state of the desk scrap
}

//----------------------------------------------------------------------------------------
// TClipboardMgr destructor
//----------------------------------------------------------------------------------------

TClipboardMgr::~TClipboardMgr()
{
	// This is nearly identical to the code in TClipboardMgr::CheckDeskScrap()
	// and is used to delete the document and view related to the clipboard.
	if (fClipView)
	{
		fClipView->FreeFromClipboard();	// AbandonCurrentClipboard 
		fClipView = NULL;				// no reason to have an Undo clipboard 
	}

	// Reset the document of the clip window, since this document has been deleted in fClipView->FreeFromClipboard()
	if (fClipWindow)
	{
		fClipWindow->SetDocument(NULL);

		if (fClipWindow->HasSubViews()) // since clipView's document has been set by TClipboardMgr::SetClipView()
			fClipWindow->FirstSubView()->SetDocument(NULL);
	}
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::AboutToLoseControl:
//----------------------------------------------------------------------------------------

void TClipboardMgr::AboutToLoseControl(bool convertClipboard)
// AboutToLoseControl takes the following actions just before control passes to another
// application or a desk accessory: notifies dependents that the Clipboard changed,
// writes the Clipboard to the desk scrap, and sets fields so that the Clipboard can be
// retrieved from the desk scrap.
//
// Call?		Seldom.
// Override?	Seldom.
{
	if (convertClipboard)
	{
		Changed(mAboutToLoseControl,this);
		WriteToDeskScrap();
	}
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::WriteToDeskScrap:
//----------------------------------------------------------------------------------------

void TClipboardMgr::WriteToDeskScrap()
// WriteToDeskScrap writes the Clipboard to the desk scrap, and sets fields so that the 
// Clipboard can be retrieved from the desk scrap.
//
// Call?		Seldom.
// Override?	Never.
{
	if (fClipView && !fClipWrittenToDeskScrap)
	{
		ClearForPutting();
		try
		{
			fClipView->WriteToDeskScrap();
		}
		catch(CException_AC& theException)
		{
			DoCatchMessage_AC(theException);

	#if qDebugMsg
			ProgramReport_AC("Can't use clipboard data outside this app\n");
	#endif
			if (!theException.GetExceptionMessage())
				theException.SetMessage( messageExportClipFailed);

			if (gDispatcher)
				gDispatcher->ShowError(theException.GetError(), theException.GetExceptionMessage());
		}

		fClipWrittenToDeskScrap = true;
		AbsorbScrapStuff();
	}
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::AbsorbScrapStuff:
//----------------------------------------------------------------------------------------

void TClipboardMgr::AbsorbScrapStuff()
{
	fOldScrapStuff = fScrapStuff;			// stash previous version, for later

	fScrapStuff.GetCurrent();				// get latest scrap state
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::CheckDeskScrap:
//----------------------------------------------------------------------------------------

void TClipboardMgr::CheckDeskScrap()
// CheckDeskScrap checks if the desk scrap has changed. If the desk scrap 
// did change, the current Clipboard becomes the “undo” Clipboard and the contents
// of the desk scrap are transferred to the current Clipboard.
//
// Call?		Seldom.
// Override?	Seldom.
{
	AbsorbScrapStuff();

	if (fOldScrapStuff != fScrapStuff)
	{
		Changed(mScrapChanged,this);
		
		if (fClipView)
		{
			fClipView->FreeFromClipboard();	// AbandonCurrentClipboard 
			fClipView = NULL;				// no reason to have an Undo clipboard 
		}

		// Reset the document of the clip window.
		if (fClipWindow)
			fClipWindow->SetDocument(NULL);

		// If the scrap is in memory and we are low on memory, then write
        // the scrap to disk.
		if (fScrapStuff.IsInMemory() && MemSpaceIsLow())
			CClipboard_AC::Unload();			// Write the scrap to disk.
		
		ReadFromDeskScrap();
	}
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::GetDataToPaste:
//----------------------------------------------------------------------------------------

long TClipboardMgr::GetDataToPaste(Handle aDataHandle, ResType& dataType)
{
	long length = -1;

	if (fGotClipType)
	{
		dataType = fPrefClipType;
		length = fClipView->GivePasteData(aDataHandle, dataType);
		if (length < 0)
			::ThrowException_AC((OSErr)length, 0);
	}
#if qDebugMsg
	else
	{
		::ProgramBreak_AC("GetDataToPaste called when fGotClipType was false");
	}
#endif

	return length;
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::Launch:
//----------------------------------------------------------------------------------------

void TClipboardMgr::Launch()
{
	// Create the clip window and default view 
	fClipWindow = MakeClipboardWindow();
	::ThrowIfNULL_AC(fClipWindow);
	fClipOrphanage = fClipWindow->FindSubView(kIDClipView);
	::ThrowIfNonObject_AC(fClipOrphanage);

	// Add the clipboard manager as an application behavior
	gDispatcher->AddBehavior(this);

	AbsorbScrapStuff();
	ReadFromDeskScrap();
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::MakeClipboardWindow:
//----------------------------------------------------------------------------------------

TWindow* TClipboardMgr::MakeClipboardWindow()
{
	TWindow* aWindow = NULL;

	if (qTemplateViews)
		aWindow = TViewServer::fgViewServer->NewTemplateWindow(kIDClipWindow, NULL);
	else
	{
		TDeskScrapView* aDeskScrapView = TH_new TDeskScrapView;
		aDeskScrapView->SetIdentifier(kIDClipView);
		aWindow = TViewServer::fgViewServer->NewSimpleWindow(kIDClipWindow, true, true, aDeskScrapView);
	}
	
	if (aWindow)
	{
		aWindow->SetHideOnSuspend(true);
		aWindow->SetHandlesCursor(false);
		aWindow->SetLetsSubViewsHandleCursor(false);
		aWindow->SetClosesDocument(false);
	}
	return aWindow;
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::ReadFromDeskScrap:
//----------------------------------------------------------------------------------------

void TClipboardMgr::ReadFromDeskScrap()
{
	TView* aViewForClipboard = NULL;
	
	try
	{
		aViewForClipboard = MakeViewForAlienClipboard();
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);

		aViewForClipboard = fClipOrphanage;
		if (!theException.GetExceptionMessage())
			theException.SetMessage( messageImportClipFailed );

		if (gDispatcher)
			gDispatcher->ShowError(theException.GetError(), theException.GetExceptionMessage());
	}

	SetClipView(aViewForClipboard, NULL);
	fClipWrittenToDeskScrap = true;	// We're in synch with the scrap
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::MakeViewForAlienClipboard:
//----------------------------------------------------------------------------------------

TView* TClipboardMgr::MakeViewForAlienClipboard()
{
	TView* aView = gDispatcher->MakeViewForAlienClipboard();
	if (!aView)
		aView = fClipOrphanage;

	::ThrowIfNonObject_AC(aView);

	return aView;
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::RegainControl:
//----------------------------------------------------------------------------------------

void TClipboardMgr::RegainControl(bool checkClipboard)
{
	if (checkClipboard)
		CheckDeskScrap();
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::SetClipView:
//----------------------------------------------------------------------------------------

void TClipboardMgr::SetClipView(TView* clipView, TEventHandler* itsContext)
{
	if (clipView)
	{
		if (fClipWindow)
		{
			// get the old clip window scroller if possible
			TView * theSuperView = fClipWindow->HasSubViews() ? fClipWindow->FirstSubView() : fClipWindow.get();

			// Set the document of the clip window and its subview.
			fClipWindow->SetDocument(clipView->GetDocument());
			theSuperView->SetDocument(clipView->GetDocument());
				
			// throw out any views contained in the scroller (or window)
			TView* theSubView;
			while ((theSubView = theSuperView->FirstSubView()) != NULL)
			{
				theSubView->ForceRedraw();
				if (fClipWindow->IsShown())
					theSubView->Close();
				theSuperView->RemoveSubView(theSubView);
			}
	
			// pop in the new clipview
			theSuperView->AddSubView(clipView);
			if (fClipWindow->IsShown())
				clipView->Open();
	
			clipView->AdjustFrame();
			clipView->RevealTop(kDontRedraw);
			clipView->ForceRedraw();
	
			fClipWindow->SetWindowTarget(fClipWindow);
			fClipWrittenToDeskScrap = clipView == fClipOrphanage;
		}
#if qDebug
		else
		{
			::ProgramBreak_AC("SetClipView in absence of fClipWindow");
		}
#endif

		clipView->SetEnable(false);					// Ignore clicks while in clipboard views
		Changed(mClipViewChanged, this);
		fClipView = clipView;
		fClipContext = itsContext;
		
		TDocument* itsDocument = clipView->GetDocument();
		if (itsDocument)
			itsDocument->SetIsGhostDocument(true);
	}
#if qDebug
	else
	{
		::ProgramBreak_AC("SetClipView: Attempt to set NULL clipView.");
	}
#endif
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::DoSetupMenus:
//----------------------------------------------------------------------------------------

void TClipboardMgr::DoSetupMenus()
{
	TBehavior::DoSetupMenus();

	Enable(cShowClipboard, !gDispatcher->InModalState());
	SetMenuState(cShowClipboard, kIDBuzzString, bzShowClip, bzHideClip, fClipWindow == gDispatcher->GetActiveWindow(kNoFloaters));
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::CanPaste:
//----------------------------------------------------------------------------------------

void TClipboardMgr::CanPaste(ResType aClipType)
// CanPaste registers the ability to paste the specified type of Clipboard 
// data. The specified type becomes the Clipboard’s preferred data type.
//
// aClipType:	Specifies the data type.
//
// Call?		ALWAYS, from your view’s DoSetupMenus method.
// Override?	Seldom.
{
	if (fClipView && !fGotClipType)
		if (fClipView->ContainsClipType(aClipType))
		{
			fGotClipType = true;
			fPrefClipType = aClipType;
		}

	if (!gDispatcher->GetSysWindowActive())
		Enable(cPaste, fGotClipType);
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::DoMenuCommand:
//----------------------------------------------------------------------------------------

void TClipboardMgr::DoMenuCommand(CommandNumber aCommandNumber)
{
	switch (aCommandNumber)
	{
		case cShowClipboard:
			if (fClipWindow == gDispatcher->GetActiveWindow(kNoFloaters))
			{
				fClipWindow->Close();	// Hide the clipboard
				if (fClipWindow->GetFreeOnClosing())
					fClipWindow.reset();
			}
			else
			{
				fClipWindow->Open();
				fClipWindow->Select();
			}
			break;
		default:
			TBehavior::DoMenuCommand(aCommandNumber);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::Close:
//----------------------------------------------------------------------------------------

void TClipboardMgr::Close()
// Close reads the desk scrap from the scrap file into memory. If the desk 
// scrap is already in memory, this method does nothing.
//
// Call?		As needed.
// Override?	Seldom.
{
	// ••• The idea of this seems to be that we may call UnloadScrap if we are low
	// on memory, so when we go away we should reverse it. It is not clear if this
	// is really necessary or appropriate. •••
	OSStatus err = CClipboard_AC::Load();
#if qProjectBuilder
	(void) err;
#endif
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::ClearForPutting:
//----------------------------------------------------------------------------------------

void TClipboardMgr::ClearForPutting()
{
	CClipboard_AC::ClearCurrent();
	fScrapStuff.GetCurrent();
}

//----------------------------------------------------------------------------------------
// TClipboardMgr::PutDeskScrapData:
//----------------------------------------------------------------------------------------

void TClipboardMgr::PutDeskScrapData(ResType scrapFlavor, Handle aDataHandle)
// PutDeskScrapData is called when you want to add a flavor of scrap data to the
// system scrap.  Be sure to call ClearForPutting() prior to putting the
// first flavor of a new cut/copy in order to clear our any old flavors from
// some unrelated previous cut/copy.  Returns an error code.
//
// scrapFlavor:	The flavor of the scrap data to put on the scrap.
// aDataHandle:	A handle containing the data to be put on the scrap.
//
// Call?		As needed, usually from within the command responding to a
//				cut/copy.  Don't forget to call ClearForPutting prior
//				to putting the first flavor.
// Override?	Never.
{
	CTempHandleLock_AC tempHandleLock(aDataHandle);	
	fScrapStuff.PutScrap(::GetHandleSize(aDataHandle), scrapFlavor, *aDataHandle);
}


//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUClipboardMgr:
//----------------------------------------------------------------------------------------

void InitUClipboardMgr()
{
	TClipboardMgr* aClipboardMgr = TH_new TClipboardMgr();
#if qProjectBuilder
	(void) aClipboardMgr;
#endif

#if qTemplateViews
	REGISTER_CLASS_AC(TDeskScrapView);
#endif
}

//----------------------------------------------------------------------------------------
// End of UClipboardMgr.cpp



/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		05/02/95	Call FreeIfObject, don't call Free directly since it will eventually be removed.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/15/96	Made TClipboardMgr MDependable_AC
		----- R10 -----
		 12/8/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		10/17/95	[1292181] SetClipView: it was possible to attempt to set it
							to null (as before application had created one) if a command
							failed.
		 9/22/95	Set IsGhostDocument.
		----- 3.3b1 -----
		 3/20/95	Use LockHandle_AC instead of LockHandleHigh wherever possible. 
		 3/17/95	MAVolatile. 
		 3/16/95	Use FailNonObject instead of FailNULL and FailNULLResource (!) to 
		 					check if fClipOrphanage is ok. Use while loop instead of iterator
							for removing subviews. 
		 3/15/95	Check if gDispatcher is there before calling it. 
		 3/13/95	Change Free methods to destructors. 
		  3/9/95	Use FirstSubView instead of directly accessing fSubView. 
		 2/28/95	Use MA_REGISTER_CLASS instead of macroDontDeadStrip. 
		02/22/95	(SPEED) MacApp doesn't need to use lists to link subviews.
		02/13/95	Remove unnecessary initialization of static variables. See ARM §8.4 
*/