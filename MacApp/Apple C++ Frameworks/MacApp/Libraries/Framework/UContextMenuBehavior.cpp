//----------------------------------------------------------------------------------------
// UContextMenuBehavior.cpp
// Copyright � 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/09/99	Check if there is a click view before calling it. 
		11/09/99	Always target the click view, but restore the target afterwards
					if the view didn't want to be the target. 
		11/08/99	Change the API for GetContextualMenu so it has access to the click
					event and can fill in all of the parameters for the menu. 
					Give the view a chance to update the selection for the click. 
		09/29/99	FindWindow now called MacFindWindow.
		08/09/99	Changed MA_REGISTER_CLASS to REGISTER_CLASS_AC.
		03/24/99	Update copyright notice.
		01/15/99	CAEDesc_AC is now in ACS. 
		10/15/98	[2279097] Return true if contextual menu event in DoToolboxEvent.
*/

#ifndef __UCONTEXTMENUBEHAVIOR__
#include "UContextMenuBehavior.h"
#endif

#if qWantsContextualMenus

// MacApp

#ifndef __UContextualMenu__
#include "UContextualMenu.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// Toolbox

#ifndef __MENUS__
#include <Menus.h>
#endif

//========================================================================================
// class CSaveTarget
//========================================================================================

class CSaveTarget
// CSaveTarget is a utility class for saving and restoring the target. 
{
public:
	CSaveTarget()
		:	fSaveTarget(TEventHandler::GetTarget())
	{}

	~CSaveTarget()
	{
		if (fSaveTarget)
			TEventHandler::SetTarget(fSaveTarget);
	}

	void NeverMind()
	{
		fSaveTarget = NULL;
	}

private:
	TEventHandler*	fSaveTarget;
};

//========================================================================================
// GLOBAL Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUContextMenuBehavior
//----------------------------------------------------------------------------------------

void InitUContextMenuBehavior()
{
	REGISTER_CLASS_AC(TContextMenuBehavior);
}

//========================================================================================
// CLASS TContextMenuBehavior
//========================================================================================

MA_DEFINE_CLASS(TContextMenuBehavior);

//----------------------------------------------------------------------------------------
// TContextMenuBehavior constructor
//----------------------------------------------------------------------------------------

TContextMenuBehavior::TContextMenuBehavior(IDType itsIdentifier)
	:	TBehavior(itsIdentifier)
{
	if (HasContextualMenus())
	{
		OSStatus err = ::InitContextualMenus();
		::ThrowIfOSErr_AC((OSErr) err);
	}
}

//----------------------------------------------------------------------------------------
// TContextMenuBehavior copy constructor
//----------------------------------------------------------------------------------------

TContextMenuBehavior::TContextMenuBehavior(const TBehavior& inBehavior)
	:	TBehavior(inBehavior)
{
}

//----------------------------------------------------------------------------------------
// TContextMenuBehavior destructor
//----------------------------------------------------------------------------------------

TContextMenuBehavior::~TContextMenuBehavior()
{
}

//----------------------------------------------------------------------------------------
// TContextMenuBehavior::DoToolboxEvent:
//----------------------------------------------------------------------------------------

bool TContextMenuBehavior::DoToolboxEvent(TToolboxEvent* event)
{
	bool handled = true;	// Indicate that we handled the event.

	if (HasContextualMenus() && IsShowContextualMenuClick(&event->GetEventRecord()))
		DispatchContextualMenuEvent(event);
	else
		handled = TBehavior::DoToolboxEvent(event);

	return handled;
}

//----------------------------------------------------------------------------------------
// TContextMenuBehavior::DispatchContextualMenuEvent: 
//----------------------------------------------------------------------------------------

void TContextMenuBehavior::DispatchContextualMenuEvent(TToolboxEvent* event)
{
	// Set up the contextual menu. This is likely to set the target. 
	CContextualMenu contextualMenu;
	TView* clickView = SetupContextualMenu(event, contextualMenu);

	// The click view has to be the target so SetupTheMenus and MenuEvent will work. 
	// If the click view doesn't want to become the target, we will restore the target
	// after the menu event has been handled. 
	CSaveTarget saveTarget;
	if (clickView)
	{
		if (clickView->WantsToBeTarget())
			saveTarget.NeverMind();

		clickView->BecomeTarget();
	}

	// Make sure that the menus are setup correctly before we handle the event.
	TMenuBarManager::InvalidateMenus();
	gDispatcher->SetupTheMenus(); 
	
	// Always show "some" contextual menu (NULL shows a default system menu)
	CPoint_AC globalMouse = event->GetEventRecord().where;
	UInt32 outUserSelectionType;
	SInt16 outMenuID;
	UInt16 outMenuItem;
	OSStatus result = contextualMenu.Select(globalMouse,
											&outUserSelectionType,
											&outMenuID,
											&outMenuItem);
	// ���  I don't want a userCanceledErr exception shower just for contextual menus, revisit.
	if (result != userCanceledErr)
	{
		::ThrowIfOSErr_AC((OSErr) result);
	
		HandleContextualMenuEvent(outUserSelectionType, outMenuID, outMenuItem);
	}
}

//----------------------------------------------------------------------------------------
// TContextMenuBehavior::SetupContextualMenu: 
//----------------------------------------------------------------------------------------

TView* TContextMenuBehavior::SetupContextualMenu(TToolboxEvent* event,
												 CContextualMenu& contextualMenu)
{
	TView* clickView = NULL;

	CPoint_AC globalMouse = event->GetEventRecord().where;
	
	// Get the relevant window and iterate to find the target subview
	WindowRef aWMgrWindow;
	if (MacFindWindow(globalMouse, &aWMgrWindow) == inContent)
	{
		TWindow* window = TWindow::WMgrToWindow(aWMgrWindow);
		if (window)
		{
			CViewPoint windowMouse = window->SuperViewToLocal(globalMouse);
			clickView = FindHelpView(window, windowMouse);
			if (clickView)
			{
				CViewPoint viewMouse(clickView->RootViewToLocal(windowMouse));

				if (clickView->Focus() && clickView->IsEnabled())
					clickView->UpdateSelection(viewMouse, event);

				clickView->GetContextualMenu(viewMouse, event, contextualMenu);
			}
		}
	}

	return clickView;
}

//----------------------------------------------------------------------------------------
// TContextMenuBehavior::FindHelpView: 
//----------------------------------------------------------------------------------------

TView* TContextMenuBehavior::FindHelpView(TView* thisView,
										  const CViewPoint& theMouse)
{
	TView* helpView = NULL;

	// Try to find a subview that will handle the click. 
	if (thisView->LetsSubViewsHandleHelp())
	{
		for (CSubViewIterator iter(thisView, kIterateBackward_AC); iter; ++iter)
		{
			if (iter->HandlesHelp())
			{
				CViewPoint subViewPt(iter->SuperViewToLocal(theMouse));
				if (iter->ContainsMouse(subViewPt))
				{				
					helpView = FindHelpView(iter, subViewPt);
					if (helpView)
						break;
				}
			}
		}
	}

	// If no subview handled it, it must be us. 
	if (!helpView && thisView->HandlesHelp())
		helpView = thisView;

	return helpView;
}

//----------------------------------------------------------------------------------------
// TContextMenuBehavior::HandleContextualMenuEvent
//----------------------------------------------------------------------------------------

void TContextMenuBehavior::HandleContextualMenuEvent(UInt32 inUserSelectionType,
													 SInt16 inMenuID,
													 UInt16 inMenuItem)
{
	switch (inUserSelectionType)
	{
		case kCMMenuItemSelected:
			gDispatcher->MenuEvent(inMenuID, inMenuItem);
			break;

		case kCMShowHelpSelected:
			//gDispatcher->GetTarget()->HandleMenuCommand(cHelp);
			break;

		default:
			break;
	}
}

//----------------------------------------------------------------------------------------
// TContextMenuBehavior::HasContextualMenus
//----------------------------------------------------------------------------------------

bool TContextMenuBehavior::HasContextualMenus()
{
	static bool defined = false;
	static bool hasContextMenus = false;
	if (!defined)
	{
		defined = true;
		hasContextMenus = MAGestaltAttribute(gestaltContextualMenuAttr, gestaltContextualMenuTrapAvailable);
	}
	return hasContextMenus;
}

#endif // qWantsContextualMenus

//----------------------------------------------------------------------------------------
// End of UContextMenuBehavior.cpp
