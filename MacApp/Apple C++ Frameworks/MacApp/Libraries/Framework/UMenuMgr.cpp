//----------------------------------------------------------------------------------------
// UMenuMgr.cpp
// Copyright � 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/17/01	Reworked EndMenuSetup a bit to better detect when a menu enabled
					state has changed.  LMGetTheMenu works in Carbon so modified HiliteMenu.
		06/10/01	Need to include MacHelp. 
		05/09/01	[C] Refine conditionalization of HMGetHelpMenu in AddHelpMenuItem.
		05/07/01	Comment out pragma messages for Carbon. 
		05/02/01	[C] Use HMGetHelpMenu in AddHelpMenuItem.
		03/04/01	Clean up string casting. 
					Fix alignment code in ConvertToMenu to work with file mapped
					resources that may start at odd addresses. 
		03/01/01	Don't include Memory_AC. 
		01/09/01	Use CString_AC instead of CStr255_AC.
		01/02/01	Update copyright.
		11/28/00	Added mOtherCommands setup to TMenuBarManager ctor.  Changed
					description and warning in GetMenu to mention mOtherCommands.
		11/10/00	Cosmetic.
		11/09/00	[PB] Suppress GCC warnings about unused return variables. 
		11/03/00	[C] Don�t include Balloons.h or Traps.h.  [G] Use C-style
					cast in TestID--weird.
		09/19/00	Clarified explanatory note in TMenuIDList::GetMenu.
		09/07/00	Added embedded documentation.
		09/07/00	Carbon: Added a HiliteMenu(0) to CSetupMenus::EndMenuSetup to stop
					the menu from not reverting in Carbon.
		09/03/00	Changed comment conditional in TMenuIDList::ConvertToMenu.
		09/01/00	Changed pragma warning to pragma message.  Cosmetic.
		08/09/00	[2511280] Don�t test handleness if qCarbon in IsSetupMenu.
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Reworked menu
					instantiation.  Include CMultiLocal.h.
		06/02/00	[2477871] Added debug report in TMenuIDList::GetMenu if menu was not
					loaded. Cleanup MAGetMenu.
		05/23/00	[2279264] Remove false from ProgramReport_AC.
		02/22/00	[W] Provided separate implementaions of most everything.
		12/27/99	Stripped out unused code.
		12/27/99	Minor cosmetic cleanup.
		12/03/99	Change MenuBarHandle to MenuBarResourceHandle, as
					MenuBarHandle is now defined in 3.3.1 headers.
		11/23/99	Use the same Carbon code for all About box selections, as
					the CStr255_AC s(CommandToName(cAboutApp)); won't work because
					the Apple menu isn't installed yet, so the CommandToName will fail.
		11/19/99	Carbon: fix getting the menu apple menu item name.
					Use ::MacCheckMenuItem, not CheckMenuItem.
		11/09/99	Must use EnableMenuItems_AC instead of MacEnableMenuItem so it
					will build for 68K.
		11/05/99	Split off the menu command table to its own unit.
		10/26/99	Carbon: on OS X, LMGetTheMenu isn't supported yet.
		10/25/99	PRAGMA_ALIGN_SUPPORTED now PRAGMA_STRUCT_ALIGN.
		10/21/99	Replace the old EnableItem, DisableItem type calls with the calls to
					IsMenuEnabled_AC, to get common menu checking and use newer routines when
					running on Carbon or Mac OS 8.5 or later.
		10/20/99	Replace DrawMenuBar_AC, GetMenu_AC, InsertMenu_AC, InsertMenuItem_AC,
					DeleteMenu_AC, and AppendMenu_AC with their direct system routines.
		09/29/99	EnableMenuItem now called MacEnableMenuItem.
		07/23/99	Use CheckMenuItem instead of CheckItem in EnableCheck and
					StartMenuSetup.  Use CountMenuItems in place of CountMItems
					in StartMenuSetup, AddHelpMenuItem and AddMenuItem.
		03/24/99	Update copyright notice.
		03/23/99	Go back to native Toolbox region calls.
		03/22/99	[W] GetMenuItemCommandID not available for use in InsertInMenuTable.
					SetMCEntries, HMGetHelpMenuHandle, LMSetMBarHeight, PaintOne,
					and GetIconSuite not available.
		02/03/99	[C] Ballooon help is not available for Carbon.  Made some adjustments
					to menu bar showing and hiding.
		01/22/99	[C] Replaced GetMenuEnable with IsMenuItemEnabled.
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					AppendMenu_AC, GetMenu_AC, InsertMenuItem_AC, SetPort_AC, DrawMenuBar_AC,
					UnionRgn_AC, InsertMenu_AC.
					Include MenuUtils_AC.h, ImagingUtils_AC.h.
		10/26/98	Carbonize
*/

//----------------------------------------------------------------------------------------
// Theory of Operation
//
// This unit provides two features: It implements a command numbering system that is
// independent of menu/ item placement, and implements a framework for optimizing menu
// setups. The command numbering system works by assigning commands a unique command
// number, and providing a mechanism for mapping command numbers to menu/ item pairs. A
// set of routines are provide to manipulate commands via their command number rather
// than their menu and item numbers.
//
// Each command can be assigned an integer command number from 1 to 32767. To associate a
// command number with a menu item, menu resources are defined with the 'CMNU' resource
// type--not the 'MENU' type. The 'CMNU' type is just like the 'MENU' type, with an
// additional command number field for each menu item. This unit converts the 'CMNU'
// resource into a 'MENU' dynamically at run time.
//
// The items of some menus cannot be determined until run-time. The font menu is an
// example. In such cases, no command number is assigned by you. Instead, the command
// number is equal to -(256 * menu + item). The procedure CommandToMenuItem converts a
// command number to a menu id and item number by the following method:
//
// - If the command number is positive, the command table is searched for the number. If
// it is found, CommandToMenuItem returns the corresponding menu id and item
// number. Otherwise the menu and item are zero.
//
// - If the command number is negative, the menu number is the upper eight bits, and the
// item number the lower eight bits, of the absolute value of the command number. (This
// implies that menu id's must be <= 127 and item numbers must be <= 255.) The function
// CommandFromMenuItem converts menu/ items to command numbers by the following method:
//
// - If the item number is positive, the command table is search for the given menu/ item
// pair.  If found, the corresponding command number is returned. If not found, the number
// returned is equal to
//  -(256 * menu + item).
//  - If the item number is negative, the number returned is equal to
//  -item number.
//
// Note that CommandToMenuItem and CommandFromMenuItem work regardless of whether the
// command is actually installed in the menu bar. MacApp takes advantage of this feature
// by having a set of generic "buzz" commands, whose primary use is to set the name of the
// Undo command (e.g. 'Undo Drawing').
//
// The second feature of this unit is to optimize menu setups (changing the appearance of
// menus and items). Normally, each call to CheckItem, SetItemStyle and SetCommandIcon in
// turn calls CalcMenuSize because the width or height of the menu may have changed. If
// menu setups are done all at one time, then CalcMenuSize can be deferred until the end
// of the setup process. The procedure PerformMenuSetup implements this mechanism. It relies
// on the fact that menu setups are done all at once, and that you will call
// SetCommandName, SetItemStyle and SetCommandIcon instead of SetItem, SetItemStyle and
// SetCommandIcon. It works only for menus whose id is from 1 to mLastMenu. Menus with IDs
// greater than mLastMenu are not affected by this scheme.
//
// PerformMenuSetup accepts one parameter, a procedure which actually implements the menu
// appearance changes. SetupMenus performs the following steps:
//
// - Before calling your menu setup procedure, StartupMenuSetup is called. It disables all
// menus and items and remembers the enabled flags of each menu
//
// - Your procedure is called.It in turn calls SetCommandName, SetCmdStyle, SetCommandIcon,
// Enable, EnableCheck, or a Toolbox routine (provided it isn't SetItem, SetItemStyle or
// SetCommandIcon).
//
// - Menus with at least one enabled item are enabled and InvalMenuBar is called if the
// enabled state of any menu changed.
//----------------------------------------------------------------------------------------

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

// MacApp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UPATCH__
#include "UPatch.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CIterator_AC__
#include "CIterator_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

#ifndef __CPoint_AC__
#include "CPoint_AC.h"
#endif

#ifndef __CRect_AC__
#include "CRect_AC.h"
#endif

#ifndef __MenuUtils_AC__
#include "MenuUtils_AC.h"
#endif

// Toolbox

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif

#ifndef __MACHELP__
#include <MacHelp.h>
#endif

#ifndef __OSUTILS__
#include <OSUtils.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __TEXTEDIT__
#include <TextEdit.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

#ifndef __ICONS__
#include <Icons.h>
#endif

#if !qCarbon
	#ifndef __BALLOONS__
	#include <Balloons.h>
	#endif

	#ifndef __TRAPS__
	#include <Traps.h>
	#endif
#endif

//----------------------------------------------------------------------------------------

// The Help menu is not implemented for Windows.
#if !qMSWindows

enum
{
	kHierarchical = true,
	kNotHierarchical = !kHierarchical,

	kDoHierarchical = true,
	kDontDoHierarchical = !kDoHierarchical
};

enum
{
	kEnablingManagedByMacApp = 0xFFFFFFFF
};

//========================================================================================
// struct CMNUHeader
//========================================================================================

#if PRAGMA_STRUCT_ALIGN
#pragma options align=mac68k
#endif

struct CMNUHeader
{
	short							menuID;
	short							menuWidth;
	short							menuHeight;
	Handle							menuProc;
	long							enableFlags;
	CStr255_AC						menuData;	// this is variable length and the array of menu items follows it directly
};

struct CMNUItemAttributes
{
	char							icon;
	char							keyEquivalent;
	char							mark;
	char							style;
};

#if PRAGMA_STRUCT_ALIGN
#pragma options align=reset
#endif

typedef CMNUHeader *CMNUHeaderPtr, **CMNUHeaderHandle;

//========================================================================================
// GLOBAL Procedures
//========================================================================================

static bool IsSetupMenu(MenuRef aMenuRef, bool isHierarchical);

//========================================================================================
// GLOBAL Variables
//========================================================================================

CAutoPtr_AC<TMenuBarManager> TMenuBarManager::fgMenuBarManager;

short 		TMenuBarManager::fgMenuBarState = TMenuBarManager::kShown;
short		TMenuBarManager::fgMenuBarHeight = 0;
RgnHandle	TMenuBarManager::fgSavedGrayRgn = NULL;
RgnHandle	TMenuBarManager::fgNewGrayRgn = NULL;
RgnHandle	TMenuBarManager::fgCoveredRgn = NULL;

TMenuIDList pMenuIDList;						// list of menus sorted by ID
//TCmdTable pCmdTable;							// command numbers and their associated menu and item numbers

//----------------------------------------------------------------------------------------

static RegionCode GetMenuRegionCodeBehavior();

bool TMenuBarManager::fgMenusAreInvalid = true;
// Used by InvalidateMenus to track whether menus need to be setup.

#if qDebug
bool gTraceSetupMenus;
#endif

//========================================================================================
// CLASS TMenuIDList
//========================================================================================

//----------------------------------------------------------------------------------------
// TMenuIDList::Compare:
//----------------------------------------------------------------------------------------

CompareResult_AC TMenuIDList::Compare(const MenuRef menu1, const MenuRef menu2) const
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;

	if (GetMenuID_AC(menu1) > GetMenuID_AC(menu2))
		returnVal = kItem1GreaterThanItem2_AC;
	else if (GetMenuID_AC(menu1) < GetMenuID_AC(menu2))
		returnVal = kItem1LessThanItem2_AC;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TMenuIDList::GetMenu:
//----------------------------------------------------------------------------------------

MenuRef TMenuIDList::GetMenu(MenuID menuID)
// GetMenu searches for a MENU resource or CMNU resource with the given menuID and returns
// the MenuRef if found.
// NOTE: When built with qDebugMsg you will experience ProgramReport_AC's for three
// situations that you can probably ignore: 1) the menu ID is 128 (mBuzzwords) and you haven't
// defined a "buzzwords" menu, 2) the menu ID is 129 (mOtherCommands) and you haven't defined an
// "other commands" menu, and 3) you are using dynamic MenuIDs.  In the latter case, GetMenu
// is called in order to find a MenuID that has not been registered.  Of course, once
// GetMenu stumbles across an unused MenuID it will complain.
//
// menuID:	A MenuID for the menu for which you desire to find the MenuRef.
//
// Call?		As needed.
// Override?	Never.
{
	// Check to see if already installed in the menubar
	MenuRef theMenuRef = TMenuBarManager::GetMenuHandle(menuID);
		// do this first ... the menu is likely to
		// be in the menubar and more likely of
		// success, hence, faster

	if (!theMenuRef)
	{
		// OK... is it in the list?
		ArrayIndex_AC index = kEmptyIndex_AC;
		theMenuRef = DoSearch(TestID, reinterpret_cast<void*>(menuID), index);

		// wasn't there. Try to load MENU and failing that, a CMNU
		if (!theMenuRef)
		{
			theMenuRef = GetAndConvertMENU(menuID);

			if (!theMenuRef)
				theMenuRef = GetAndConvertCMNU(menuID);

			if (theMenuRef && (GetMenuID_AC(theMenuRef) > 0))
				TMenuIDList::InsertInMenuTable(theMenuRef, GetMenuID_AC(theMenuRef));
		}
	}

#if qDebugMsg
	if (!theMenuRef && gIntenseDebugging)
		ProgramReport_AC("TMenuIDList::GetMenu: Failed to load menu with ID: %d.\n"
						 "  You might be able to ignore this warning for mBuzzwords, mOtherCommands,"
						 " and dynamic menus.  Refer to the comment in the function"
						 " implementation.\n", menuID);
#endif

	return theMenuRef;
}

//----------------------------------------------------------------------------------------
// InsertInMenuTable:
//----------------------------------------------------------------------------------------

void TMenuIDList::InsertInMenuTable(MenuRef theMenu, ResNumber menuResID)
{
	if ((menuResID != kNoResource_AC) && (GetMenuID_AC(theMenu) != menuResID))
	{
#if qDebugMsg
	ProgramReport_AC("Changing menu ID %d to match its resID %d\n", GetMenuID_AC(theMenu), menuResID);
#endif
#if !qCarbon
		(*theMenu)->menuID = menuResID;
#else
		::SetMenuID(theMenu, menuResID);
#endif
	}

	// Add the menu to the translation table
	pMenuIDList.Insert(theMenu);

#if qMSWindows
	#pragma message ("TMenuIDList::InsertInMenuTable: Implementation needed.")
#else
	// attempt to find and install command numbers
	if (theMenu && HasAppearanceMgr_AC())
	{
		for (short itemNo = CountMenuItems(theMenu);  itemNo; --itemNo)
		{
			UInt32 commandID;
			OSErr err = GetMenuItemCommandID(theMenu, itemNo, &commandID);
			if (!err && commandID)
				AddCommand(commandID, menuResID, itemNo);
		}
	}
#endif
}

//----------------------------------------------------------------------------------------
// TMenuIDList::TestID:
//----------------------------------------------------------------------------------------

CompareResult_AC TMenuIDList::TestID(const MenuRef menu, void* yourDataPtr)
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;

#ifdef __GNUC__
	short menuID = (short)yourDataPtr;
#else
	short menuID = reinterpret_cast<short>(yourDataPtr);
#endif

	if (menuID > GetMenuID_AC(menu))
		returnVal = kItem1GreaterThanItem2_AC;
	else if (menuID < GetMenuID_AC(menu))
		returnVal = kItem1LessThanItem2_AC;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TMenuIDList::GetAndConvertCMNU:
//----------------------------------------------------------------------------------------

MenuRef TMenuIDList::GetAndConvertCMNU(ResNumber menuResID)
{
	MenuRef newMenu = NULL;

	if (menuResID != kNoResource_AC)
	{
		Handle aCMNUHandle = CMultiLocale_AC::GetResource('CMNU', menuResID);
		if (aCMNUHandle)
		{
			HNoPurge(aCMNUHandle);					// If it was purgeable it might squirt away

#if qMSWindows
			(*(CMNUHeaderHandle)aCMNUHandle)->menuID = EndianS16_BtoN((*(CMNUHeaderHandle)aCMNUHandle)->menuID);
			(*(CMNUHeaderHandle)aCMNUHandle)->menuWidth = EndianS16_BtoN((*(CMNUHeaderHandle)aCMNUHandle)->menuWidth);
			(*(CMNUHeaderHandle)aCMNUHandle)->menuHeight = EndianS16_BtoN((*(CMNUHeaderHandle)aCMNUHandle)->menuHeight);
			(*(CMNUHeaderHandle)aCMNUHandle)->enableFlags = EndianS32_BtoN((*(CMNUHeaderHandle)aCMNUHandle)->enableFlags);
			char message[100];
#endif

			short menuID = (*(CMNUHeaderHandle)aCMNUHandle)->menuID;
			if (menuID > 0)// not in reserved range
			{
				// load the menudef and store its reference in the menu
				newMenu = ConvertToMenu(aCMNUHandle, true);
#if !qCarbon && !qMSWindows
// ���  Don't know how to convert this to Carbon or Windows
				Handle menuProc = (*(CMNUHeaderHandle)aCMNUHandle)->menuProc;
				if (menuProc) // Was it specialized?
				{
					Handle h = CMultiLocale_AC::GetResource('MDEF', *reinterpret_cast<short*>(&menuProc));
					(*newMenu)->menuProc = h;
				}
#endif

#if !qMSWindows
				// Since only GetMenu automatically loads the appropriate color information,
				// and (sigh) since we can only call GetMenu once, and if you call DeleteMenu
				// all the good color stuff goes away (double sigh) we'll have to help out
				// the Menu Manager by doing its job for it

				// n.b. This is using the menuID of the menu as a resource ID, which is incorrect
				MenuCRsrcHandle theColorRsrc = (MenuCRsrcHandle)CMultiLocale_AC::GetResource('mctb', menuResID);
				if (theColorRsrc)
				{
					{ // Extra block to destroy handlelocker before releasersrc
						CTempHandleLock_AC tempHandleLock((Handle)theColorRsrc);
						SetMCEntries((*theColorRsrc)->numEntries, &((*theColorRsrc)->mcEntryRecs[0]));
					}
					ReleaseResource((Handle)theColorRsrc);
				}
#endif
			}
			::ReleaseResource(aCMNUHandle);		// won't be needing this since it's we have a MENU now (if we're using it)
		}
	}
	return newMenu;
}

//----------------------------------------------------------------------------------------
// TMenuIDList::ConvertToMenu:
//----------------------------------------------------------------------------------------

MenuRef TMenuIDList::ConvertToMenu(Handle CMNUHandle, bool addCommandsToCommandTable)
{
	CTempHandleLock_AC tempHandleLock(CMNUHandle);
	CMNUHeader* theCMNUHeader = reinterpret_cast<CMNUHeaderPtr>(StripLong(*CMNUHandle));
#if qProjectBuilder
	bool alignment = ::Odd_AC(theCMNUHeader);
#else
	enum { alignment = 0 };
#endif

	MenuID menuNo = theCMNUHeader->menuID;

	MenuRef theMenuRef = MANewIconMenu(menuNo, theCMNUHeader->menuData);

#if qCarbon || qMSWindows
	// ���  Don't know how to convert this to Carbon or Windows.
	//#pragma message ("TMenuIDList::ConvertToMenu: Specialized code needed.")
#else
	if (theCMNUHeader->menuProc) // it is specialized
		(*theMenuRef)->menuProc = theCMNUHeader->menuProc;

	if (theCMNUHeader->enableFlags != kEnablingManagedByMacApp) // it is specialized
		(*theMenuRef)->enableFlags = theCMNUHeader->enableFlags;
#endif

	StringPtr theCMNUPtr = reinterpret_cast<StringPtr>(&theCMNUHeader->menuData) + theCMNUHeader->menuData.Length() + 1;

	short itemNo = 0;

	StringPtr endPtr = reinterpret_cast<StringPtr>(theCMNUHeader) + GetHandleSize(CMNUHandle);
	while (theCMNUPtr < endPtr && *theCMNUPtr) // non empty string
	{
		++itemNo;
		//const CStr2_AC aBlank = " "; // Must be at least non-empty
		::MacAppendMenu(theMenuRef, "\p ");

		// Set the text this way to defeat metacharacter processing
		SetMenuItemText(theMenuRef, itemNo, theCMNUPtr);
		theCMNUPtr += theCMNUPtr[0] + 1;

		CMNUItemAttributes& theCMNUAttributes = *(CMNUItemAttributes*)theCMNUPtr;
		if (theCMNUAttributes.icon)
			SetItemIcon(theMenuRef, itemNo, theCMNUAttributes.icon);

		if (theCMNUAttributes.keyEquivalent)
			SetItemCmd(theMenuRef, itemNo, theCMNUAttributes.keyEquivalent);

		if (theCMNUAttributes.mark)
			SetItemMark(theMenuRef, itemNo, theCMNUAttributes.mark);

		if (theCMNUAttributes.style)
			SetItemStyle(theMenuRef, itemNo, theCMNUAttributes.style);

		theCMNUPtr += sizeof(CMNUItemAttributes);

		if (::Odd_AC(theCMNUPtr) != alignment)// word align
			++theCMNUPtr;

#if qMSWindows
		*reinterpret_cast<CommandNumber*>(theCMNUPtr) = EndianS32_BtoN(*reinterpret_cast<CommandNumber*>(theCMNUPtr));
#endif
		if (addCommandsToCommandTable)
			AddCommand(*reinterpret_cast<CommandNumber*>(theCMNUPtr), menuNo, itemNo);

		theCMNUPtr += sizeof(CommandNumber);
	}

	return theMenuRef;
}

//----------------------------------------------------------------------------------------
// TMenuIDList::GetAndConvertMENU:
//----------------------------------------------------------------------------------------

MenuRef TMenuIDList::GetAndConvertMENU(ResNumber menuResID)
{
	return ::MacGetMenu(CMultiLocale_AC::GetExistingResourceID('MENU', menuResID));
}

//========================================================================================
// CLASS TMenuTable
//========================================================================================

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// GetMenuRegionCodeBehavior:
//----------------------------------------------------------------------------------------

RegionCode GetMenuRegionCodeBehavior()
{
	// ���  Hack
	return IsCapsLockKeyDown() ? CMultiLocale_AC::GetKeyRegionCode() : CMultiLocale_AC::GetApplicationRegionCode();
}

//----------------------------------------------------------------------------------------
// MANewIconMenu:
//----------------------------------------------------------------------------------------

MenuRef MANewIconMenu(short menuID, ConstStr255Param menuTitle)
{
	/*
		Looks for a menu title of "#nnn" where nnn is the id of an icon suite,
		represented in text form so it is easy to enter in a resource editor.
		If the icon suite can be loaded, the menu is created with the icon for
		its title. Otherwise, the menu is created with a normal title string.
	*/

	MenuRef theMenuRef = NULL;

	// Could be an icon suite resource id
	if ((menuTitle[0] > 1) && (menuTitle[1] == '#'))
	{
		// Convert to a number
		Str15 iconMenuTitle;
		iconMenuTitle[0] = menuTitle[0] - 1;
		if (iconMenuTitle[0] > 15)
			iconMenuTitle[0] = 15;
		BlockMove_AC(&menuTitle[2], &iconMenuTitle[1], iconMenuTitle[0]);
		long iconID = 0;
		StringToNum(iconMenuTitle, &iconID);

#if !qMSWindows
		// Load the icon suite
		Handle iconSuite = NULL;
		::GetIconSuite(&iconSuite, iconID, svAllSmallData);
		if (iconSuite)
		{
			// Create the menu with an icon title
			iconMenuTitle[0] = 5;
			iconMenuTitle[1] = 0x01;
			*(long *)&iconMenuTitle[2] = (long)iconSuite;
			theMenuRef = NewMenu(menuID, iconMenuTitle);
		}
#endif
	}

	// Create the menu with a text title
	if (!theMenuRef)
		theMenuRef = NewMenu(menuID, menuTitle);

	return theMenuRef;
}

//----------------------------------------------------------------------------------------
// MAGetMenu:
//----------------------------------------------------------------------------------------

MenuRef MAGetMenu(ResNumber inResNumber)
{
	return pMenuIDList.GetMenu(inResNumber);
}

//----------------------------------------------------------------------------------------
// IsManagedMenu:
//----------------------------------------------------------------------------------------

bool IsManagedMenu(MenuRef theMenu)
{
	return pMenuIDList.GetIdentityItemNo(theMenu) != kEmptyIndex_AC;
}

//----------------------------------------------------------------------------------------
// If hierarchical the range of IDs for applications is restricted.  See IM V-236.
// If the menu isn't managed by MacApp and is in a TPopup, its ID must be outside this range.
//----------------------------------------------------------------------------------------

enum
{
	kHierarchicalMin = 0,
	kHierarchicalMax = 235
};

//----------------------------------------------------------------------------------------
// IsSetupMenu:
//----------------------------------------------------------------------------------------

bool IsSetupMenu(MenuRef	aMenuRef,
				 bool		isHierarchical)
{
	bool returnVal = false;

#if qDebug && !qCarbon
	if (!IsHandle_AC((Handle)aMenuRef))
	{
		VerboseIsHandle((Handle)aMenuRef);
		::ProgramBreak_AC("IsSetupMenu: �aMenuRef� is not a handle.");
		return false;
	}
#endif

	MenuID menuID = GetMenuID_AC(aMenuRef);

	if (menuID == mApple)						// _NEVER_ managed!
		;

#if qDebug
	else if (menuID == mDebug)
		returnVal = true;
#endif

	else if (isHierarchical)
	{
		if (menuID >= kHierarchicalMin && menuID <= kHierarchicalMax)
		returnVal = true;						// must be in valid range for hierarchicals
	}
	else
		returnVal = (menuID >= mFirstMenu && menuID <= mLastMenu); // Range of managed menus

	return returnVal;
}

//========================================================================================
// CSetupMenus:
//========================================================================================

enum
{
	kMaxSetupMenus = mLastMenu + 1
};

class CSetupMenus
{
public:
	CSetupMenus()
		:	fCount(0)
	{ }

	void StartMenuSetup(MenuRef aMenuRef);
	void EndMenuSetup();

protected:
	MenuRef fMenuRef[kMaxSetupMenus];
	bool fEnabled[kMaxSetupMenus];
	short fCount;
};

//----------------------------------------------------------------------------------------
// CSetupMenus::StartMenuSetup:
//----------------------------------------------------------------------------------------

void CSetupMenus::StartMenuSetup(MenuRef aMenuRef)
{
#if qDebug
	if (fCount >= kMaxSetupMenus)
	{
		::ProgramBreak_AC("Array overflow: too many setup menus.");
		return;
	}
#endif

	// Remember if the menu itself was enabled.
	fMenuRef[fCount] = aMenuRef;
	fEnabled[fCount] = IsMenuEnabled_AC(aMenuRef);

	++fCount;

	// Disable the menu and all of its items.
	DisableMenu_AC(aMenuRef);

	// Uncheck all items.
	short nItems = CountMenuItems(aMenuRef);
	for (short item = 1; item <= nItems; ++item)// Make sure we don't check items with sub-menus
	{
		short theCmd;
		GetItemCmd(aMenuRef, item, &theCmd);
		if (theCmd != hMenuCmd)
			::MacCheckMenuItem(aMenuRef, item, false);	// moves/purges memory
	}
}

//----------------------------------------------------------------------------------------
// CSetupMenus::EndMenuSetup:
//----------------------------------------------------------------------------------------

void CSetupMenus::EndMenuSetup()
{
	bool	needToRedrawMenuBar = false;

	for (short i = 0; i < fCount; ++i)
	{
		MenuRef		aMenuRef = fMenuRef[i];
		bool		menuNowEnabled = AnyMenuItemsEnabled_AC(aMenuRef);

		// If any items are enabled, enable the menu
		if (menuNowEnabled)
			EnableMenu_AC(aMenuRef);

		// If the menu's enabled state changed, we have to draw the menu bar.
		if (menuNowEnabled != fEnabled[i])
			needToRedrawMenuBar = true;
	}

	if (needToRedrawMenuBar)
		InvalMenuBar();
}

//----------------------------------------------------------------------------------------
// PerformMenuSetup:
//----------------------------------------------------------------------------------------

void PerformMenuSetup(MenuSetupType TheMenuSetterUpper, void* yourDataPtr)
{
	CSetupMenus setup;

	{											// in a block to destroy the iterator
		for (CMenuIterator iter; iter.Current(); ++iter)
			if (IsSetupMenu(iter, kHierarchical))
				setup.StartMenuSetup(iter);
	}

	TheMenuSetterUpper(yourDataPtr);

	setup.EndMenuSetup();

	TMenuBarManager::ValidateMenus();
}

//========================================================================================
// CLASS CMenuIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CMenuIterator::CMenuIterator: A simple iterator for menus.
//----------------------------------------------------------------------------------------

CMenuIterator::CMenuIterator()
	:	Iterator(&pMenuIDList, kIterateForward_AC)
// CMenuIterator is a constructor that initializes an instance for iteration
// over TWindow objects.
//
// Call?		As needed. If you subclass CMenuIterator, you must
//				invoke this constructor from the subclass constructor.
// Override?	NEVER. It is a constructor.
{
	First();
}

//----------------------------------------------------------------------------------------
// CMenuIterator::First:
//----------------------------------------------------------------------------------------

MenuRef CMenuIterator::First()
{
#if defined(__SC__) || defined(__MRC__)
	TMenuIDList::
#endif
		Iterator::First();

	// only point at menus that are in the menulist
	while (Current() && !TMenuBarManager::IsInMenuBar(GetMenuID_AC(Current())))
		Next();

	return Current();
}

//----------------------------------------------------------------------------------------
// CMenuIterator::Next:
//----------------------------------------------------------------------------------------

MenuRef CMenuIterator::Next()
{
#if defined(__SC__) || defined(__MRC__)
	TMenuIDList::
#endif
		Iterator::Next();

	// only point at menus that are in the menulist
	while (Current() && !TMenuBarManager::IsInMenuBar(GetMenuID_AC(Current())))
		Next();

	return Current();
}

//========================================================================================
// CLASS TMenuBarManager
//========================================================================================

//----------------------------------------------------------------------------------------
// TMenuBarManager destructor
//----------------------------------------------------------------------------------------

TMenuBarManager::~TMenuBarManager()
{
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::TMenuBarManager:
//----------------------------------------------------------------------------------------

TMenuBarManager::TMenuBarManager(ResNumber otherMenus)
	:	fDisplayedMenus(kNoResource),
		fPreferredMenuBarID(kNoResource),
		fDisplayedHierMenus(kNoResource),
		fPreferredHierMenuBarID(kNoResource),
		fPreferredRegion(GetMenuRegionCodeBehavior()),
		fDisplayedRegion(GetMenuRegionCodeBehavior())
{
	static const CString_AC kParamText1("^0");

	// set my global reference
	fgMenuBarManager = this;

	// Add in the "other" menus, then clear them from the MenuBar
	AddMenuBar(otherMenus, kNotHierarchical);
	MAGetMenu(mBuzzwords); // in case it's not included in otherMenus MBAR

	// Add the 'other' commands, which are commands that can be enabled
	// or disabled but which are not in any visible menu.
	MAGetMenu(mOtherCommands);

	// Clear the 'other' menus from the menu bar now.
	ClearMenuBar();

#if !qMSWindows
	// Initialize the Apple menu
	MenuRef		aMenu = MAGetMenu(mApple);
	Str255		menuString;
	::GetMenuItemText(aMenu, cAboutApp, menuString);
#endif

#if qCarbon
/*
 From Carbon menu manager documentation:
 Carbon provides automatic support for the Apple Menu. The Menu Manager will
 automatically insert an Apple Menu into the menu bar at launch, and will populate
 it with the contents of the Apple Menu Folder.  Carbon applications may remove all calls to
 AppendResMenu(appleMenu, 'DRVR').  A Carbon application can customize the section of the
 Apple menu before the DAs, just as in the past, by calling InsertMenu on a menu whose
 title is the Apple character.
*/
#elif !qMSWindows
	if (aMenu)
		AppendResMenu(aMenu, 'DRVR');
#endif
	// If the "About" item contains the paramtext keystring (^0) then substitute the
	// Application's name
	CString_AC				aboutString(menuString);
	CString_AC::size_type	i = aboutString.find(kParamText1);
	if (i != CString_AC::npos)
	{
		aboutString.replace(i, i + kParamText1.size(), gDispatcher->GetApplicationName());
		SetCommandName(cAboutApp, aboutString);
	}
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::SetPreferredMenuBarID:
//----------------------------------------------------------------------------------------

void TMenuBarManager::SetPreferredMenuBarID(ResNumber theID)
{
	fPreferredMenuBarID = theID;
	fPreferredRegion = GetMenuRegionCodeBehavior();
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::GetPreferredMenuBarID:
//----------------------------------------------------------------------------------------

ResNumber TMenuBarManager::GetPreferredMenuBarID()
{
	return fPreferredMenuBarID;
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::SetPreferredHierMenuBarID:
//----------------------------------------------------------------------------------------

void TMenuBarManager::SetPreferredHierMenuBarID(ResNumber theID)
{
	fPreferredHierMenuBarID = theID;
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::GetPreferredHierMenuBarID:
//----------------------------------------------------------------------------------------

ResNumber TMenuBarManager::GetPreferredHierMenuBarID()
{
	return fPreferredHierMenuBarID;
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::InstallPreferredMenus:
//----------------------------------------------------------------------------------------

void TMenuBarManager::InstallPreferredMenus()
{
	if (((fDisplayedMenus != fPreferredMenuBarID || fDisplayedRegion != fPreferredRegion) && (fPreferredMenuBarID != kNoResource)) || ((fDisplayedHierMenus != fPreferredHierMenuBarID) && (fPreferredHierMenuBarID != kNoResource)))
	{
		ClearMenuBar();

		fDisplayedRegion = fPreferredRegion;

		AddMenuBar(fPreferredMenuBarID != kNoResource ? fPreferredMenuBarID : fDisplayedMenus, kNotHierarchical);
		fDisplayedMenus = fPreferredMenuBarID;

		AddMenuBar(fPreferredHierMenuBarID != kNoResource ? fPreferredHierMenuBarID : fDisplayedHierMenus, kHierarchical);
		fDisplayedHierMenus = fPreferredHierMenuBarID;

		// We must reinsert the help menus whenever ClearMenuBar is called
		gDispatcher->InstallHelpMenuItems();
	}
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::Reset:
//----------------------------------------------------------------------------------------

void TMenuBarManager::Reset()
{
	fPreferredMenuBarID = kNoResource;
	fPreferredHierMenuBarID = kNoResource;
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::AddHelpMenuItem:
//----------------------------------------------------------------------------------------

void TMenuBarManager::AddHelpMenuItem(const CString_AC& helpText, CommandNumber helpCommand)
// AddHelpMenuItem adds an item to the Help menu. If the Help menu is not available,
// this method adds the item to the Apple menu immediately following the About
// This Application item.
//
// helpText:	The text of the item to display in the menu bar. If the string
//				contains �^0� the application name is inserted into the menu. Your
//				application should read the string for the helpText parameter from
//				a resource.
// helpCommand:	The command number that MacApp will send to your application
//				when the installed Help menu item is selected. This command number
//				must not appear in any other command menu.
//
// Call?		ALWAYS, if your application provides a help menu.
//				if your application responds to shortcuts such as holding down the
//				Option key and clicking the mouse, it should provide a shortcuts
//				dialog that lists all the available options. Call AddHelpMenuItem
//				from your override of TApplication::InstallHelpMenuItems.
// Override?	Seldom.
{
	MenuRef				helpMenu = NULL;
	short				newHelpItemNo = 9999;
	const CString_AC	kParamText1 = "^0";
	OSErr				err = noErr;
	CString_AC			localHelpText(helpText);

	// If the help item contains the paramtext keystring (^0) then substitute the
	// Application's name
	CString_AC::size_type	i = localHelpText.find(kParamText1);
	if (i != CString_AC::npos)
		localHelpText.replace(i, i + kParamText1.size(), gDispatcher->GetApplicationName());

	// Put the help item at the end of the help menu
#if qCarbon
	#if UNIVERSAL_INTERFACES_VERSION > 0x0332
		MenuItemIndex	firstCustomItemIndex;	// Ignored.
		err = ::HMGetHelpMenu(&helpMenu, &firstCustomItemIndex);
	#endif
#elif !qMSWindows
	err = ::HMGetHelpMenuHandle(&helpMenu);
#endif

	// If we have a reference to a menu, insert the help command
	if (err == noErr && helpMenu)
	{
		short oldMenu;
		short oldItem;

		// If the new help item is to be inserted at the end of
		// the list, make sure that its number is correct
		short nHelpItems = CountMenuItems(helpMenu);
		if (newHelpItemNo > nHelpItems)
			newHelpItemNo = nHelpItems + 1;

		// Insert the menu, then change its name.  This avoids problems
		// that might occur if the application name included metacharacters
		// ��� The "Help" should be a string resource!
		::MacInsertMenuItem(helpMenu, CStr255_AC(CString_AC("Help")), newHelpItemNo - 1);
		::SetMenuItemText(helpMenu, newHelpItemNo, CStr255_AC(localHelpText));

		// Add the help command number to the command table, but only if it's not already there
		if (!CommandToComponents(helpCommand, oldMenu, oldItem))
			AddCommand(helpCommand, GetMenuID_AC(helpMenu), newHelpItemNo);
	}
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::AddMenuItem:
//----------------------------------------------------------------------------------------

void TMenuBarManager::AddMenuItem(const CString_AC& theMenuItemText,
								  MenuID			menuNumber,
								  short				insertAfterItem,
								  CommandNumber		theMenuItemCommandNumber)
{
	short theMenuItem = insertAfterItem;
	MenuRef theMenuRef = MAGetMenu(menuNumber);

	// If we have a reference to a menu, insert the new menu item
	if (theMenuRef && theMenuItemText.size() > 0)
	{
		// Figure out where to insert the new menu item
		short curNumItems = CountMenuItems(theMenuRef);
		if (theMenuItem > curNumItems)
			theMenuItem = curNumItems + 1;
		else
			// The user passed in where to insert it after so add one to take this into account
			++theMenuItem;

		// Insert the menu, then change its name.  This avoids problems
		// that might occur if the application name included metacharacters
		// One is subtracted here to take into account insert after item that InsMenuItem does
		#if !qMSWindows
			::MacInsertMenuItem(theMenuRef, "\ptemp", theMenuItem - 1);
		#else
			const CStr8_AC aTempStr = "temp";
			::MacInsertMenuItem(theMenuRef, aTempStr, theMenuItem - 1);
		#endif
		::SetMenuItemText(theMenuRef, theMenuItem, CStr255_AC(theMenuItemText));

		// Add the help command number to the command table, but only if it's not already there
		short oldMenu;
		short oldItem;

		if (!CommandToComponents(theMenuItemCommandNumber, oldMenu, oldItem))
			InsertCommand(theMenuItemCommandNumber, GetMenuID_AC(theMenuRef), theMenuItem);
	}
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::DeleteMenuItem:
//----------------------------------------------------------------------------------------

void TMenuBarManager::DeleteMenuItem(CommandNumber theMenuItemCommandNumber)
{
	short theMenuNumber;
	short theItemNumber;

	CommandToMenuItem(theMenuItemCommandNumber, theMenuNumber, theItemNumber);
	if (theMenuNumber)
	{
		MenuRef theMenu = MAGetMenu(theMenuNumber);

		// Delete the menu item from the menu
		if (theMenu)
			::DeleteMenuItem(theMenu, theItemNumber);

		// Delete the command number from the table
		DeleteMenuCommand(theMenuItemCommandNumber);
	}
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::ShowMenuBar:
//----------------------------------------------------------------------------------------

void TMenuBarManager::ShowMenuBar()
{
#if !qCarbon
	WindowPtr	frontWindow;
	GrafPtr		windowPort;
	GrafPtr		oldPort;
	CGrafPtr	windowCPort;
#endif

	// Make sure the menu bar is hidden
	if (fgMenuBarState == kHidden)
	{
#if qCarbon
	//#pragma message ("TMenuBarManager::ShowMenuBar: Cannot call LMSetGrayRgn, GetWMgrPort, GetCWMgrPort.")
		::ShowMenuBar();		// Note: ShowMenuBar is 8.5+ only.
#else
#if !qMSWindows
		// Reset the menu bar height
		::LMSetMBarHeight(fgMenuBarHeight);
		// Restore the gray region

		::LMSetGrayRgn(fgSavedGrayRgn);

		// Recalculate the windows

		frontWindow = ::FrontWindow();
		::CalcVis(frontWindow);
		::CalcVisBehind(frontWindow, fgNewGrayRgn);
#endif

		// Reset the window manager port�s clipping

		::GetPort(&oldPort);
		::GetWMgrPort(&windowPort);
		::SetPort_AC(windowPort);
		::SetClip(fgNewGrayRgn);
		::GetCWMgrPort(&windowCPort);
		::SetPort_AC((GrafPtr)windowCPort);
		::SetClip(fgNewGrayRgn);
		::SetPort_AC(oldPort);
#endif	// non-Carbonized code

		// Redraw the menu bar

		::HiliteMenu(0);
		::MacDrawMenuBar();

		// Mark that the menu bar is shown

		fgMenuBarState = kShown;
	}
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::HideMenuBar:
//----------------------------------------------------------------------------------------

void TMenuBarManager::HideMenuBar()
{
#if !qCarbon && !qMSWindows
	GDHandle	mainDisplay;
	Rect		mainDisplayBounds;
	RgnHandle	workRgn;
	GrafPtr		windowPort;
	GrafPtr		oldPort;
	CGrafPtr	windowCPort;
	WindowPtr	frontWindow;
#endif

	if (fgMenuBarState == kShown && !gDispatcher->IsFrontProcess())
	{
		// If the menu bar is currently shown but we are in the background,
		// set the state to latent hidden: it will be hidden when we are brought
		// into the foreground.

		fgMenuBarState = kLatentHidden;
	}
	else if (fgMenuBarState != kHidden && gDispatcher->IsFrontProcess())
	{
		// If the menu bar is not already hidden and we are in the foreground,
		// go ahead and hide the menu bar.

#if qCarbon
	//#pragma message ("TMenuBarManager::HideMenuBar: Cannot call LMSetGrayRgn, GetWMgrPort, GetCWMgrPort.")
		fgMenuBarHeight = ::GetMBarHeight();
		::HideMenuBar();		// Note: HideMenuBar is 8.5+ only.
#elif qMSWindows
	#pragma message ("TMenuBarManager::HideMenuBar: Work needed for Windows.")
		fgMenuBarHeight = ::GetMBarHeight();
#else
		// Store the menu bar height and then set it to zero

		fgMenuBarHeight = ::LMGetMBarHeight();
		::LMSetMBarHeight(0);

		// Get the rectangle for the main display

		mainDisplay = ::GetMainDevice();
		mainDisplayBounds = (*mainDisplay)->gdRect;

		// Calculate the new regions

		workRgn = ::NewRgn();
		::ThrowIfNULL_AC(workRgn);
		fgSavedGrayRgn = ::LMGetGrayRgn();
		::RectRgn(workRgn, &mainDisplayBounds);
		fgNewGrayRgn = ::NewRgn();
		::ThrowIfNULL_AC(fgNewGrayRgn);
		fgCoveredRgn = ::NewRgn();
		::ThrowIfNULL_AC(fgCoveredRgn);
		::MacUnionRgn(workRgn, fgSavedGrayRgn, fgNewGrayRgn);
		::DiffRgn(fgNewGrayRgn, fgSavedGrayRgn, fgCoveredRgn);
		::DisposeRgn(workRgn);

		// Set the new gray region

		::LMSetGrayRgn( fgNewGrayRgn );

		// Get the window manager port clip region

		::GetPort(&oldPort );
		::GetWMgrPort(&windowPort);
		::SetPort_AC(windowPort);
		::SetClip(fgNewGrayRgn);

		::GetCWMgrPort(&windowCPort);
		::SetPort_AC((GrafPtr) windowCPort);
		::SetClip(fgNewGrayRgn);

		// Force an update of the desktop
		::PaintOne(NULL, fgNewGrayRgn);

		// Update the windows

		frontWindow = ::FrontWindow();
		if (frontWindow != NULL)
		{
			::PaintOne(frontWindow, fgCoveredRgn);
			::PaintBehind(frontWindow, fgCoveredRgn);
			::CalcVis(frontWindow);
			::CalcVisBehind(frontWindow, fgCoveredRgn);
		}

		// Restore the port
		::SetPort_AC(oldPort);

#endif	// non-Carbonized code

		// Mark the menu bar as hidden

		fgMenuBarState = kHidden;
	}
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::AboutToLoseControl:
//----------------------------------------------------------------------------------------

void TMenuBarManager::AboutToLoseControl()
{
	if (fgMenuBarState == kHidden)
	{
		// Application is becoming inactive and we have a hidden menu bar:
		// show the menu bar and set the state to latent.
		ShowMenuBar();
		fgMenuBarState = kLatentHidden;
	}
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::RegainControl:
//----------------------------------------------------------------------------------------

void TMenuBarManager::RegainControl()
{
	if (fgMenuBarState == kLatentHidden)
	{
		// Application is becoming active and we have latent hidden state:
		// hide the menu bar.
		HideMenuBar();
	}
}

//----------------------------------------------------------------------------------------
// GetIndMenu:
//----------------------------------------------------------------------------------------

MenuRef TMenuBarManager::GetIndMenu(ResNumber itsID, ResNumber itsIndex)
{
	MenuRef theMenu = NULL;

	MenuBarResourceHandle hmbar = GetMBarResource(itsID);
	if (hmbar)
	{
		ResNumber menuResID = (*hmbar)->menuResID[itsIndex - 1];
		//MenuID menuID = pMenuIDList.MenuIDFromResID(menuResID);
		theMenu = MAGetMenu(menuResID);
		::ReleaseResource((Handle)hmbar);
	}

	return theMenu;
}

//----------------------------------------------------------------------------------------
// CountMenus:
//----------------------------------------------------------------------------------------

short TMenuBarManager::CountMenus(ResNumber itsID)
{
	short numMenus = 0;

	MenuBarResourceHandle hmbar = GetMBarResource(itsID);
	if (hmbar)
	{
		numMenus = (*hmbar)->nMenus;
		::ReleaseResource((Handle)hmbar);
	}

	return numMenus;
}

//----------------------------------------------------------------------------------------
// AddMenuBar:
//----------------------------------------------------------------------------------------

void TMenuBarManager::AddMenuBar(ResNumber itsID, bool isHierarchical)
{
	short hier = 0;
	MenuBarResourceHandle hmbar;

	if (isHierarchical)
		hier = -1;

	hmbar = GetMBarResource(itsID);
	if (hmbar)
	{
		for (ResNumber i = 0; i < (*hmbar)->nMenus; ++i)
		{
			ResNumber menuResID = (*hmbar)->menuResID[i];
			//MenuID menuID = pMenuIDList.MenuIDFromResID(menuResID);
			if (!IsInMenuBar(menuResID))		// do nothing if it's already in menubar
			{
				MenuRef aMenu = MAGetMenu(menuResID);
				if (aMenu)
				{
					::MacInsertMenu(aMenu, hier);

					// a visible menu needed insertion thus the menubar became invalid
					if (!isHierarchical)
						InvalidateMenuBar();
				}
			}
		}

		::ReleaseResource((Handle)hmbar);
		// hmbar = NULL;
	}
}

//----------------------------------------------------------------------------------------
// GetMenuHandle:
//----------------------------------------------------------------------------------------

MenuRef TMenuBarManager::GetMenuHandle(MenuID menuID)
{
	short mappedID = CMultiLocale_AC::GetExistingResourceID('MENU', menuID);

	return ::GetMenuHandle(mappedID);
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::IsInMenuBar:
//----------------------------------------------------------------------------------------

bool TMenuBarManager::IsInMenuBar(MenuID menuID)
{
	return GetMenuHandle(menuID) != NULL;
}

//----------------------------------------------------------------------------------------
// GetMBarResource:
//----------------------------------------------------------------------------------------

MenuBarResourceHandle TMenuBarManager::GetMBarResource(ResNumber menuRsrcID)
{
	return (MenuBarResourceHandle)CMultiLocale_AC::GetResource('MBAR', menuRsrcID);
}

//----------------------------------------------------------------------------------------
// GetNewMBar:
//----------------------------------------------------------------------------------------

Handle TMenuBarManager::GetNewMBar(ResNumber menuRsrcID)
{
	SignedByte savedState;

	MCTableHandle theColorTab = GetMCInfo();

	// make the 'MBAR' resource non-purgeable, so the Toolbox doesn't die
	Handle itsRsrcHandle = (Handle)GetMBarResource(menuRsrcID);
	if (itsRsrcHandle)
	{
		savedState = HGetState(itsRsrcHandle);
		HNoPurge(itsRsrcHandle);
	}

	Handle itsNewMBar = ::GetNewMBar(menuRsrcID);

	// restore the 'MBAR' resource
	if (itsRsrcHandle)
		HSetState(itsRsrcHandle, savedState);

	if (theColorTab)
	{
		{ // Extra block to destroy handlelocker before DisposeMCInfo
			CTempHandleLock_AC tempHandleLock((Handle)theColorTab);
			SetMCEntries(static_cast<short>(GetHandleSize((Handle)theColorTab)
											/ sizeof(MCEntry)),
						 (*theColorTab));
		}
		DisposeMCInfo(theColorTab);
	}

	return itsNewMBar;
}

//----------------------------------------------------------------------------------------
// InvalidateMenus:
//----------------------------------------------------------------------------------------

void TMenuBarManager::InvalidateMenus()
{
	fgMenusAreInvalid = true;
}

//----------------------------------------------------------------------------------------
// ValidateMenus:
//----------------------------------------------------------------------------------------

void TMenuBarManager::ValidateMenus()
{
	fgMenusAreInvalid = false;
}

//----------------------------------------------------------------------------------------
// MenusHavePendingUpdate:
//----------------------------------------------------------------------------------------

bool TMenuBarManager::MenusHavePendingUpdate()
{
	return fgMenusAreInvalid;
}

//----------------------------------------------------------------------------------------
// InvalidateMenuBar:
//----------------------------------------------------------------------------------------

void TMenuBarManager::InvalidateMenuBar()
{
	InvalidateMenus();							// if the menubar is invalidated then the
												// menu items must be also

	// Systems have "InvalMenuBar"... use that functionality. The system will redraw
	// the menu bar at the next convenient time.
	::InvalMenuBar();
}

//----------------------------------------------------------------------------------------
// TMenuBarManager::HiliteMenu
//----------------------------------------------------------------------------------------

void TMenuBarManager::HiliteMenu(short menuID)
{
#if !qMSWindows
	if (menuID || ::LMGetTheMenu())
#else
	if (menuID)
#endif
		::HiliteMenu(menuID);
}

#else

//----------------------------------------------------------------------------------------
// windows implemenation begins here...

bool TMenuBarManager::fgMenusAreInvalid = true;

//----------------------------------------------------------------------------------------
// InvalidateMenus:
//----------------------------------------------------------------------------------------

void TMenuBarManager::InvalidateMenus()
{
	fgMenusAreInvalid = true;
}

//----------------------------------------------------------------------------------------
// ValidateMenus:
//----------------------------------------------------------------------------------------

void TMenuBarManager::ValidateMenus()
{
	fgMenusAreInvalid = false;
}

//----------------------------------------------------------------------------------------
// MenusHavePendingUpdate:
//----------------------------------------------------------------------------------------

bool TMenuBarManager::MenusHavePendingUpdate()
{
	return fgMenusAreInvalid;
}

//----------------------------------------------------------------------------------------
// PerformMenuSetup:
//----------------------------------------------------------------------------------------

void PerformMenuSetup(MenuSetupType TheMenuSetterUpper,
					  void* yourDataPtr)
{
	HMENU mainMenu = gDispatcher->GetWindowsMenuBar();
	DisableMenuItems(mainMenu);

	TheMenuSetterUpper(yourDataPtr);

	TMenuBarManager::ValidateMenus();
}

//----------------------------------------------------------------------------------------
// DisableMenuItems:
//----------------------------------------------------------------------------------------

void DisableMenuItems(HMENU theMenu)
{
	if (theMenu == NULL)
		return;
	int numItems = GetMenuItemCount(theMenu);
	for (int index = 0; index < numItems; index++)
	{
		// see if this item has a submenu ...
		HMENU subMenu = GetSubMenu(theMenu, index);
		if (subMenu != NULL)
		{
			// ..if so, make sure it is enabled...
			EnableMenuItem(theMenu, index, MF_ENABLED|MF_BYPOSITION);
			DisableMenuItems(subMenu);
		}
		else
		{
			// ... otherwise dim it if the command number is in the range 1 to 32767
			UINT id = GetMenuItemID(theMenu, index);
			if ((id >= 1) && (id <= 32767))
			{
				EnableMenuItem(theMenu, index, MF_GRAYED|MF_BYPOSITION);
				CheckMenuItem(theMenu, index, MF_UNCHECKED|MF_BYPOSITION);
			}
		}
	}
}

#endif // !qMSWindows

//----------------------------------------------------------------------------------------
// UMenuMgr.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/24/96	[1287100] (Menus, TPopup) GetMenuLabel doesn't access menu name for popup
							Fixed for UMenuMgr's CommandToName too.
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		06/12/96	Started the release process, removing triple-�, initials,
							inappropriate comments.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/26/96	Made TMenuBarManager::AddHelpMenuItem(helpText,.. a const& parameter. It was passing
							the string by value!!
							Make and use an overload of CommandToName that returns a CStr255_AC function result.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Update iterators to be OD stylish.
		04/18/96	Use post-increment with iterators in while loops
		04/17/96	Removed NeedCalcMenuSize and the null menu proc, they're not worth it anymore!
		04/16/96	Cleanup ConvertToMenu
		04/16/96	Use |= operator when possible
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/30/96	Inline trivial constructors and Current/First/Nextxxx methods in iterators.
		03/27/96	Switch last remaining Str255s to CStr255s_AC
		03/26/96	Cleanup references to gEmptyString and ""
		03/26/96	Removed IsHandle_AC testing in IsSetupMenu. It was a debugging aid.
		03/26/96	coerce CStrxxx_AC to const char* to get copies of the strings as c style strings
		03/14/96	Replaced curly quotes with straight single quote.
		01/15/95	Changed MA_CAInitMenus to MA_CASetSharedMenuBar() and
							MA_CARegisterSharedMenuCommands(), so the user can override the
							Shared commands easily. Added fAppMenuBar datamember.
		12/15/95	Add cRedo.
		12/12/95	Replaced call to FailCAError with FailOSErr.
		12/08/95	Added MA_CAInitMenus, RegisterCommand, RegisterMenu. Added code to
							MA_CAInitMenus to correctly share the menubar with CALib. Still
							Needs to be cleaned up. REQUIRES MODIFIED VERSION OF CALIB.
		12/08/95	Split up includes for modular MacApp.
		05/24/95	CALib support.
		----- 3.3 -----
		10/31/95	Add CurResFile_AC, Fix UseResFile_AC to avoid unnecessary UseResFile calls.
		10/13/95	Cosmetic.
		----- 3.3b1 -----
		08/05/95	1250391	UMenuMgr.cp needs alignment directive.
		07/28/95	Add configuration functions to use instead of gConfiguration.
		07/01/95	Only ReleaseResource once when converting a CMNU :)
		07/06/95	111569 MacApp's command table is corrupted if a menu item
		 					is removed.
		07/01/95	Make CMNUs non-purgeable during init and ReleaseResource thereafter
		05/16/95	MenuRef
		05/05/95	Remove support for pre-system 7
		04/12/95	Base class constructors called from mem initializers don't
		 					rely on default arguments.
		04/04/95	ReleaseResource on CMNU's after we're done with them.
		03/20/95	Use LockHandle_AC instead of LockHandleHigh wherever possible.
		03/15/95	Add MAHiliteMenu. Make local functions static.
		03/07/95	1161932	(SPEED) HiliteMenu takes 13% of execution time + fix
		03/13/95	Change Free methods to destructors.
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		02/13/95	make "p" (private) globals static
		02/13/95	Remove unnecessary initialization of static variables. See ARM �8.4
		02/08/95	replace usage of staticLink with yourDataPtr.
		02/07/95	1213552 Use MAGetMenu in TMenuBarManager::AddMenuItem.
		02/07/95	Create missing prototypes for static functions used internally.
		11/17/94	Change NULL to nil.
		11/10/94	Work around a memory stomper by using new class
							CSetupMenus as a stack rather than an array indexed
							by the menuID (debug menu is 900).
		11/02/94	Make the debug menu always managed (as per
							Mark Anderson).
		10/27/94	Compile with ETO 15 prerelease headers.
		09/14/94	Added Apple event menu accessors.
		07/18/94	Change NULL to nil.
		07/12/94	Make the debug menu a managed menu on the PowerPC.
		07/06/94	As per Kevin Redden, add AddMenuItem and DeleteMenuItem
							methods to TMenuBarManager. Add support methods to
							TCmdTable.
							Move ConvertToMenu from segment TRes to MAInit.
		07/05/94	IsSetupMenu now checks for bad handles.
		06/03/94	Fix InitUMenuMgr to set up routine descriptor properly
							instead of hammering the MDEF. Fix proposed by Henk
							Kampman (HOL0156).
*/