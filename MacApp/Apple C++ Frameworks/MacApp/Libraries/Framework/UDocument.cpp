//----------------------------------------------------------------------------------------
// UDocument.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//
//	Our sincere thanks to George Varga & Juergen A. Mayrbaeurl of ARTMA Biomedical who
//  allowed us to pattern MacApp's Navigation Services support on their recommendations.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/04/01	Modifying the change count should invalidate menus. 
		04/23/01	Protected gClipboardMgr fields. 
		04/03/01	Include UDebug.h.
		03/26/01	Changed GetObjectProperty so documentless windows are only reported
					on gDebugMsg and gIntenseDebugging.
		03/01/01	Don't include Core_AC. 
		01/11/01	Some functions have been made const.
		01/09/01	Include StdStringUtils_AC.h.
		12/28/00	GetTitle returns a CString_AC.  SetTitle takes a CString_AC.  UntitledName
					now returns a CString_AC rather than taking one. 
		01/02/01	Update copyright.
		11/27/00	Remove customization of gEmptyString for __GNUC__.
		11/09/00	[PB] Change initialization order to match declaration. 
		11/03/00	Cosmetic, pragma unuseds.  [PB] cast gEmptyString for paramText.
		09/21/00	[W] fSavePrintInfo and fSaveUserSelection are always false.
		09/08/00	Added embedded documentation.
		09/05/00	Reworked GetObjectProperty so proper document index is retrieved.
					Include <set>.
		08/15/00	Add a convenience macro for generating temp UPP classes. 
		06/21/00	Remove unnecessary GetRegion calls.
		04/18/00	Include UPrintMgr.h instead of UPrintHandler.h.
		04/17/00	Made fPrintInfo a CRefCountingPtr_AC.  Do not delete fPrintInfo
					in dtor since now automatically handled.
		12/08/99	Took out MA_DEFINE_CLASS of TDocument.  Check gDispatcher before
					DeleteDocument in ~TDocument.  Make sure there is a gPrintHandler
					in ~TDocument before DeleteIfPrintInfo.
		11/04/99	TDocument::UntitledName(): CopyFrom needs a length.
		10/07/99	Use TemplateTempUPP_AC instead of TmplTmpRtnDescrptr.
		03/24/99	Update copyright notice.
		01/15/99	CAEDesc_AC is now in ACS. 
		10/29/98	Don't call Navigation stuff unless qNavigation.
		10/08/98	Undo context. 
					Merge TCommandHandler into TEventHandler. 
*/

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

// MacApp

#ifndef __PLATFORMMEMORY__
#include "PlatformMemory.h"
#endif

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

#ifndef __UBEHAVIOR__
#include "UBehavior.h"
#endif

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDESIGNATOR__
#include "UDesignator.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UERRORMGR__
#include "UErrorMgr.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPOINTEROBJECT__
#include "UPointerObject.h"
#endif

#ifndef __UPrintMgr__
#include "UPrintMgr.h"
#endif

#if qAppleEventAware
	#ifndef __USCRIPTING__
	#include "UScripting.h"
	#endif
#endif	// #if qAppleEventAware

#ifndef __UUNDO__
#include "UUndo.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

#ifndef __TemplateUPP_AC__
#include "TemplateUPP_AC.h"
#endif

// Toolbox

#if qAppleEventAware
	#ifndef __AEREGISTRY__
	#include <AERegistry.h>
	#endif
#endif	// #if qAppleEventAware

#include <set>

//========================================================================================
// Namespaces
//========================================================================================

using std::set;

//========================================================================================
// static data members
//========================================================================================

short TDocument::gNumUntitled = 1;							// call the first document "Untitled-1"

//========================================================================================
// CLASS TDocument
//========================================================================================

//----------------------------------------------------------------------------------------
// TDocument constructor
//----------------------------------------------------------------------------------------

TDocument::TDocument()
	:	TEventHandler(gDispatcher),
#if qAppleEventAware
		MScriptableObject(cDocument),
#endif
		fChangeCount(0),
#if !qMSWindows
		fSavePrintInfo(true),
		fSaveUserSelection(true),
#else
		fSavePrintInfo(false),
		fSaveUserSelection(false),
#endif
#if qAttachable
		fSaveAttachedScript(true),
#endif
		fSharePrintInfo(true),
		fReopenAlert(false),
		fAskOnClose(true),
		fCommitOnSave(true),
		fIsGhostDocument(false)
{
	// NOTE: We no longer add the document to the event dispatcher in this constructor;
	//       rather, the virtual AddDocument must be called immediately after every
	//       call to DoMakeDocument.
}

//----------------------------------------------------------------------------------------
// TDocument::Free:
//----------------------------------------------------------------------------------------

TDocument::~TDocument()
{
	// Check so that TDocument can be deleted even after gDispatcher 
	// has gone (see TClipboardMgr::~TClipboardMgr()).
	if (gDispatcher)
		gDispatcher->DeleteDocument(this);

	for  (TemplateIterator_AC<TWindow*> iter1(&fWindowList); iter1; ++iter1)
		delete iter1.Current();

	for  (TemplateIterator_AC<TView*> iter2(&fViewList); iter2; ++iter2)
		delete iter2.Current();
}

//----------------------------------------------------------------------------------------
// TDocument::AddView:
//----------------------------------------------------------------------------------------

void TDocument::AddView(TView* aView)
// AddView adds the specified view to the end of the document’s view list. 
// It prevents the same view from being added twice to the list.
//
// aView:	Specifies the view to be associated with the document.
//
// Call?		Seldom. MacApp calls AddView for you whenever you 
//				create a view for a document.
// Override?	Seldom.
{
	// Protect against double installation and keep in synch with window list
	if (!fViewList.GetIdentityItemNo(aView))
		fViewList.Insert(aView);

	// Also insert this into the window list if it is a window.
	if (dynamic_cast_AC(TWindow*, aView)
		&& !fWindowList.GetIdentityItemNo(aView))
	{
		::Assertion_AC(aView->GetSuperView() == NULL,
					   "TDocument::AddView: Adding view which is already in another superview.");
		fWindowList.Insert(aView);
	}
}

//----------------------------------------------------------------------------------------
// TDocument::AddWindow:
//----------------------------------------------------------------------------------------

void TDocument::AddWindow(TWindow* aWindow)
// AddWindow adds the specified window to the end of the document’s window 
// list. It prevents the same window from being added twice to the list.
//
// aWindow:	Specifies the window to be associated with the document.
//
// Call?		Seldom. MacApp calls AddWindow for you whenever you 
//				create a window for a document.
// Override?	Seldom.
{
	// Protect against double installation and keep in synch with window list
	// doesn't already exist in list

	if (!fWindowList.GetIdentityItemNo(aWindow))
		fWindowList.Insert(aWindow);

	// Also insert this into the view list.
	if (!fViewList.GetIdentityItemNo(aWindow))
		fViewList.Insert(aWindow);
}

//----------------------------------------------------------------------------------------
// TDocument::FindDocument:
//----------------------------------------------------------------------------------------

bool TDocument::FindDocument(TFile* aFile)
{
	#pragma unused (aFile)
	return false;
}

//----------------------------------------------------------------------------------------
// TDocument::AttachPrintHandler:
//----------------------------------------------------------------------------------------

void TDocument::AttachPrintHandler(TPrintHandler* itsPrintHandler)
// AttachPrintHandler associates the specified print handler with this document 
// and sets up a behavior to handle printing commands. It also sets up a print 
// information record if the document’s views share printing.
//
// itsPrintHandler:	Specifies the print handler to be associated with the 
// document.
//
// Call?		Seldom.
// Override?	Seldom.
{
	if (itsPrintHandler)
		itsPrintHandler->fDocument = this;

	AddBehavior(TH_new TPrintMenuBehavior(itsPrintHandler));
	if (!fPrintInfo && fSharePrintInfo)
		fPrintInfo = itsPrintHandler->GetPrintInfo();
}

//----------------------------------------------------------------------------------------
// TDocument::DetachPrintHandler:
//----------------------------------------------------------------------------------------

void TDocument::DetachPrintHandler(TPrintHandler* itsPrintHandler)
{
	TBehavior* itsManager = itsPrintHandler->GetManager();
	if (itsManager)
	{
		RemoveBehavior(itsManager);
		delete itsManager;
	}
}

//----------------------------------------------------------------------------------------
// TDocument::Changed:
//----------------------------------------------------------------------------------------

void TDocument::Changed(ChangeID_AC theChange, void* changeData)
{
	switch (theChange)
	{
		case cUndo:
			SetChangeCount(GetChangeCount() - 1);
			TMenuBarManager::InvalidateMenus();
			break;

		case mClosed:
			//don't want to up the the changed count on closing.
			break;

		default:
			// protect from rollover (it goes negative). If your document has
			// this many changes (over 2 billion) you are truly sick!
			SetChangeCount(Max_AC(static_cast<long>(GetChangeCount() + 1), static_cast<long>(1)));
			TMenuBarManager::InvalidateMenus();
			break;
	}
	MDependable_AC::Changed(theChange, changeData);	// Notify dependents
}

//----------------------------------------------------------------------------------------
// TDocument::OpenWindowCount:
//----------------------------------------------------------------------------------------

short TDocument::OpenWindowCount()
{
	short openDocWindows = 0;

	// See how many open windows this document has
	for (CWindowIterator iter(this); iter.Current(); ++iter)
		if ((*iter).CountAsOpen())
			++openDocWindows;

	return openDocWindows;
}

//----------------------------------------------------------------------------------------
// TDocument::CloseWindow:
//----------------------------------------------------------------------------------------

void TDocument::CloseWindow(TWindow* aWindow)
// CloseWindow closes a window associated with a document. It also closes 
// the document if this window is the last open window for the document. This
// method does nothing if the specified window is not associated with the document.
//
// aWindow:	specifies the window to be closed.
//
// Call?		Seldom.
// Override?	Seldom.
{
	// The default behavior is: if the window's fClosesDocument is true
	// OR if this is the document's last open window then close the
	// document, otherwise just close the window.  In either case
	// the action must be recordable.

	if (aWindow && (aWindow->GetDocument() == this))	// free window
	{
		if (aWindow->GetClosesDocument() ||
			(OpenWindowCount() <= 1
			 && !aWindow->GetFloats()
			 && aWindow->IsShown()))
			DoClose(cClose);			// The window will be closed and freed
		else								// as a side effect
			aWindow->DoClose(cClose);
	}
}

//----------------------------------------------------------------------------------------
// TDocument::Close:
//----------------------------------------------------------------------------------------

void TDocument::Close()
// Close is intended to close this document. TDocument::Close prompts the 
// user to save the document if there are any changes, closes the windows for a document,
// and frees the document along with its windows and views.
// Note: Close must never be called for a document related to a view in the Clipboard to
// avoid freeing the Clipboard view, whose existence is taken for granted by most
// methods that use it.
//
// Call?		Seldom. MacApp attempts to close a document when the user
//				issues a Close command or when the last window closed.
// Override?	Seldom. You do not need to override Close unless 
//				you want to change what happens when a document is closed or
// 				to add to the standard document-handling behavior of MacApp.
{
	Changed(mClosed,this);

	// Must never be called for a document related to a view in the Clipboard.
	for (CWindowIterator iter(this); iter.Current(); ++iter)
	{
		(*iter).Close();
		if ((*iter).GetFreeOnClosing())
			delete iter.Current();
	}
}

//----------------------------------------------------------------------------------------
// TDocument::CloseAndFree:
//----------------------------------------------------------------------------------------

void TDocument::CloseAndFree()
// CloseAndFree closes a document and frees its memory.
//
// Call?		Seldom. Eventually, this method will be removed from 
//				MacApp. If you need to close and free a document, you should call
// 				Close on the document and then, if necessary, free the object.
// Override?	NEVER. It is not virtual.
{
#if qDebug
	::ProgramBreak_AC("TDocument::CloseAndFree is deprecated: please call Close() and then if necessary free the object");
#endif

	Close();
	delete this;
}

//----------------------------------------------------------------------------------------
// TDocument::MakeCloseCommand:
//----------------------------------------------------------------------------------------
// Note that whatever command you chose to make here must be a descendant
// of TCloseDocCommand.

TCloseDocCommand* TDocument::MakeCloseCommand(CommandNumber itsCommandNumber)
{
	return TH_new TCloseDocCommand(itsCommandNumber, this);
}

#if qAppleEventAware

TCloseDocCommand* TDocument::MakeCloseCommand(TAppleEvent* message, TAppleEvent* reply)
{
	return TH_new TCloseDocCommand(this, message, reply);
}

#endif

//----------------------------------------------------------------------------------------
// TDocument::DoClose:
//----------------------------------------------------------------------------------------

void TDocument::DoClose(CommandNumber aCommand, bool useAppleEvent)
{
	CTempAllocation tempAllocation(true);
	CTempObjectAllocation tempObjectAllocation(true);
	
	CAutoPtr_AC<TCloseDocCommand> aCloseCommand = MakeCloseCommand(aCommand);
	aCloseCommand->SetUseAppleEvent(useAppleEvent);

	PostCommand(aCloseCommand);
	aCloseCommand.release();
}

//----------------------------------------------------------------------------------------
// TDocument::DeleteView:
//----------------------------------------------------------------------------------------

void TDocument::DeleteView(TView* viewToDelete)
// DeleteView deletes the view from the document’s view list. If the view 
// is a window, DeleteView deletes the window from the document’s window list.
//
// viewToDelete:	Specifies the view to be disassociated from the document.
//
// Call?		Seldom. MacApp calls the method for you when it frees 
//				a view.
// Override?	Seldom.
{
	fViewList.Delete(viewToDelete);

	// Make sure the lists are in synch.
	fWindowList.Delete(viewToDelete);
}

//----------------------------------------------------------------------------------------
// TDocument::DeleteWindow:
//----------------------------------------------------------------------------------------

void TDocument::DeleteWindow(TWindow* windowToDelete)
// DeleteWindow deletes the window from the document’s window list and deletes 
// the window from the document’s view list.
//
// windowToDelete:	Specifies the window to be disassociated from the document.
//
// Call?		Seldom. MacApp calls this method for you when you 
//				free a window.
// Override?	Seldom.
{
	fWindowList.Delete(windowToDelete);

	// Make sure the lists are in synch.
	fViewList.Delete(windowToDelete);
}

//----------------------------------------------------------------------------------------
// TDocument::DoInitialState: Called for 'New' && 'Revert' [to blank] commands && for
// default open tool icon
//----------------------------------------------------------------------------------------

void TDocument::DoInitialState()
{
}

//----------------------------------------------------------------------------------------
// TDocument::DoMakeViews:
//
// 	E X A M P L E
//	{
//		TYOURView*	aYOURView;
//		aYOURView = new TYourView;
//		aYOURView->IYOURView(this, YOURExtentRect);
//		return aYOURView;
//	}
//----------------------------------------------------------------------------------------

void TDocument::DoMakeViews(bool forPrinting)
{
#if qTemplateViews
	TView * aView = NULL;

	if (forPrinting)						// Don't need window when Finder printing.
		aView = TViewServer::fgViewServer->DoCreateViews(this, NULL, kDefaultViewID, gZeroVPt);
	else
		aView = TViewServer::fgViewServer->NewTemplateWindow(kDefaultWindowID, this);

	InstallIfPrintHandler(TPrintHandler::gPrintHandler, aView);
#else
	#pragma unused (forPrinting)
#endif
}

//----------------------------------------------------------------------------------------
// TDocument::DoPostMakeViews:
//----------------------------------------------------------------------------------------

void TDocument::DoPostMakeViews(bool forPrinting)
{
	if (!forPrinting)
		ShowWindows();

	TDesignator* userSelection = GetUserSelection();
	if (userSelection)
		RevealSelection(userSelection);
}

//----------------------------------------------------------------------------------------
// TDocument::DoMenuCommand:
//----------------------------------------------------------------------------------------

void TDocument::DoMenuCommand(CommandNumber aCommandNumber)
{
	//====================================================================================
    // Some commands will be posted to perform actions that must _ALWAYS_ be available.
    // The allocation cannot be allowed to fail. So we do a temp allocation which by
    // definition cannot be allowed to fail. This strategy is used wherever we want to use
    // command objects but don't want to leave the user twisting in the breeze. NOTE:
    // Don't forget to allow for this memory in your mem! resource if you copy this style
    // in your own code.
    //====================================================================================

	switch (aCommandNumber)
	{
// ••• I think this is already covered by the undo behavior and TUndoRedoCommand::MakeAppleEvent •••
//		case cUndo:
//			if (!gDispatcher->DoUndoRedo(this, aCommandNumber
//#if qAppleEventAware
//															 , this
//#endif
//																   ))
//				TEventHandler::DoMenuCommand(aCommandNumber);
//			break;

		case cSave:
		case cSaveAs:
		case cSaveCopy:
			DoSave(aCommandNumber);
			break;

		case cRevert:
			DoRevert();
			break;

		default:
			TEventHandler::DoMenuCommand(aCommandNumber);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TDocument::FreeData:
//----------------------------------------------------------------------------------------

void TDocument::FreeData()
{
}

//----------------------------------------------------------------------------------------
// TDocument::FreeFromClipboard:
//----------------------------------------------------------------------------------------

void TDocument::FreeFromClipboard()
{
	DeleteWindow(gClipboardMgr->GetClipWindow());

	delete this;
}

//----------------------------------------------------------------------------------------
// TDocument::GetIsGhostDocument:
//----------------------------------------------------------------------------------------

bool TDocument::GetIsGhostDocument() const
{
	return fIsGhostDocument;
}

//----------------------------------------------------------------------------------------
// TDocument::SetIsGhostDocument:
//----------------------------------------------------------------------------------------

void TDocument::SetIsGhostDocument(const bool newIsGhostDocument)
{
	fIsGhostDocument = newIsGhostDocument;
}

//----------------------------------------------------------------------------------------
// TDocument::RegainControl:
//----------------------------------------------------------------------------------------

void TDocument::RegainControl()
{
}

//----------------------------------------------------------------------------------------
// TDocument::GetChangeCount:
//----------------------------------------------------------------------------------------

long TDocument::GetChangeCount()
{
	return fChangeCount;
}

//----------------------------------------------------------------------------------------
// TDocument::IsChanged:
//----------------------------------------------------------------------------------------

bool TDocument::IsChanged()
{
	return GetChangeCount() > 0;
}

//----------------------------------------------------------------------------------------
// TDocument::DoWriteData:
//----------------------------------------------------------------------------------------

void TDocument::DoWriteData(const OSType aScrapType, TDesignator* aDesignator, CStream_AC* aStream)
{
	#pragma unused (aScrapType, aDesignator, aStream)
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TDocument::DoReadData:
//----------------------------------------------------------------------------------------

void TDocument::DoReadData(	const OSType	aScrapType,
							TDesignator*	aDesignator,
							CStream_AC*		aStream,
							long			count)
{
	#pragma unused (aScrapType, aDesignator, aStream, count)
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TDocument::GetUserSelection:
//----------------------------------------------------------------------------------------

TDesignator* TDocument::GetUserSelection() const
{
	return fUserSelection;
}

//----------------------------------------------------------------------------------------
// TDocument::SetUserSelection:
//----------------------------------------------------------------------------------------

void TDocument::SetUserSelection(TDesignator* newSelection)
{
	if (newSelection != fUserSelection)
		fUserSelection = newSelection;
}

//----------------------------------------------------------------------------------------
// TDocument::UserSelectionChanged:
//----------------------------------------------------------------------------------------

void TDocument::UserSelectionChanged(TView* changedView)
{
	#pragma unused (changedView)
}

//----------------------------------------------------------------------------------------
// TDocument::RevealSelection:
//----------------------------------------------------------------------------------------

void TDocument::RevealSelection(TDesignator* designator)
{
	#pragma unused (designator)
	// Default behavior: select the first window of the application.
	// Call TDocument::RevealSelection() to get this default behavior if you need it.

	TWindow* window = static_cast<TWindow*>(fWindowList.First());
	if (window && !window->IsActive())
		window->Select();
}

//----------------------------------------------------------------------------------------
// TDocument::RevealUndoRedo:
//----------------------------------------------------------------------------------------

void TDocument::RevealUndoRedo(TCommand* command)
{
	TEventHandler::RevealUndoRedo(command);

	TWindow* window = static_cast<TWindow*>(fWindowList.First());
	if (window)
		window->Select();
}

//----------------------------------------------------------------------------------------
// TDocument::OpenAgain:
//----------------------------------------------------------------------------------------

void TDocument::OpenAgain(CommandNumber commandNumber, TDocument* document)
{
	#pragma unused (commandNumber, document)

	if (fReopenAlert)
	{
		OSErr interactErr = MAInteractWithUser();
		if (interactErr == noErr)
		{
			ParamText(CStr255_AC(fTitle), gEmptyString, gEmptyString, gEmptyString);
			StdAlert(phReopenDoc);
		}
		else if (interactErr != errAENoUserInteraction)
			::ThrowIfOSErr_AC(interactErr);
	}

	TWindow* window = static_cast<TWindow*>(fWindowList.First());
	if (window)
		window->Select();
}

//----------------------------------------------------------------------------------------
// TDocument::PoseSaveDialog:
//----------------------------------------------------------------------------------------

short TDocument::PoseSaveDialog()
{
	short returnVal = kNoButton;

	if (IsChanged())
	{
		::ThrowIfOSErr_AC(MAInteractWithUser());
		CString_AC applicationName = gDispatcher->GetApplicationName();	// Get the application name
		
#if qNavigation
		if (gApplication && gApplication->WantsNavigationServices() && ::NavServicesAvailable())
		{
			OSErr theErr = noErr;
			CTempNavEventUPP eventUPP(MacAppNavigationEventFilter);

			NavAskSaveChangesResult 	reply;
			NavDialogOptions			dialogOptions;
	
			::NavGetDefaultDialogOptions(&dialogOptions);
			GetTitle().AsStr255(static_cast<Str255&>(dialogOptions.savedFileName));
			applicationName.AsStr255(static_cast<Str255&>(dialogOptions.clientName));
	
			theErr = ::NavAskSaveChanges(&dialogOptions,
										 gDispatcher->GetDone()
											? kNavSaveChangesQuittingApplication
											:	kNavSaveChangesClosingDocument,
										 &reply, eventUPP, NULL);
	
			switch (reply)
			{
				case kNavAskSaveChangesSave:
					returnVal = kStdOkItemIndex;
					break;
				case kNavAskSaveChangesCancel:
					returnVal = kStdCancelItemIndex;
					break;
				case kNavAskSaveChangesDontSave:
					returnVal = kNoButton;
					break;
			}
		}
		else
#endif
		{
			CString_AC reason(static_cast<ResNumber>(kIDBuzzString), gDispatcher->GetDone() ? bzQuitting : bzClosing);
			ParamText(CStr255_AC(fTitle), CStr255_AC(reason), CStr255_AC(applicationName), gEmptyString);
			returnVal = MacAppAlert(phSaveChanges, NULL);
		}
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TDocument::ReadDocument:
//----------------------------------------------------------------------------------------

void TDocument::ReadDocument(bool)
{
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TDocument::ReadStationery:
//----------------------------------------------------------------------------------------

void TDocument::ReadStationery(TFile* itsNewFile)
{
	#pragma unused (itsNewFile)
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TDocument::RevertDocument:
//----------------------------------------------------------------------------------------

void TDocument::RevertDocument()
{
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TDocument::Abandon:
//----------------------------------------------------------------------------------------

void TDocument::Abandon()
// Abandon is intended to perform actions when the user decides not to save 
// changes to a document. TDocument::Abandon is an empty method, which is
// usually sufficient for documents that are not file-based.
//
// Call?		Seldom. MacApp calls this method for you when the 
//				user closes a document without saving changes.
// Override?	As needed. For example, if you use a file-based 
//				document, you can override this method to restore the original
//				contents from a scratch file.
{
	// If your document needs to do some cleanup when its being abandoned then
	// put some code in an override of this method
}

//----------------------------------------------------------------------------------------
// TDocument::GetSaveLocation
//----------------------------------------------------------------------------------------

void TDocument::GetSaveLocation(CommandNumber itsCommandNumber, CAEDesc_AC& theSaveDesc)
// Creates an CAEDesc_AC describing where the document would be saved.
{
	#pragma unused (itsCommandNumber, theSaveDesc)
}

//----------------------------------------------------------------------------------------
// TDocument::MakeSaveCommand
//----------------------------------------------------------------------------------------

TSaveCommand* TDocument::MakeSaveCommand(CommandNumber itsCommandNumber)
{
	return TH_new TSaveCommand(this, itsCommandNumber);
}

#if qAppleEventAware

TSaveCommand* TDocument::MakeSaveCommand(TAppleEvent* message, TAppleEvent* reply,
										 CommandNumber itsCommandNumber)
{
	return TH_new TSaveCommand(this, message, reply, itsCommandNumber);
}

#endif

//----------------------------------------------------------------------------------------
// TDocument::DoSave
//----------------------------------------------------------------------------------------

void TDocument::DoSave(CommandNumber itsCommandNumber)
{
	// Generate a save document command.
	CTempAllocation	tempAllocation(true);
	CTempObjectAllocation tempObjectAllocation(true);
	
	TSaveCommand* aSaveCommand = MakeSaveCommand(itsCommandNumber);
	aSaveCommand->SetUseAppleEvent(true);

	PostCommand(aSaveCommand);
}

//----------------------------------------------------------------------------------------
// TDocument::DoRevert
//----------------------------------------------------------------------------------------

void TDocument::DoRevert()
{
	CTempAllocation tempAllocation(true);
	CTempObjectAllocation tempObjectAllocation(true);
	
	TRevertCommand* aRevertCommand = TH_new TRevertCommand(this);
	aRevertCommand->SetUseAppleEvent(true);

	PostCommand(aRevertCommand);
}

//----------------------------------------------------------------------------------------
// TDocument::SaveDocument:
//----------------------------------------------------------------------------------------

void TDocument::SaveDocument(CommandNumber)
{
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TDocument::SaveAgain:
//----------------------------------------------------------------------------------------

void TDocument::SaveAgain(CommandNumber aCommand, const TDocument* savingDoc)
{
	#pragma unused (aCommand)

	// Don't save the file if another one of the same name is already open.
	if (savingDoc != this)
		::ThrowException_AC(errSaveAgain, 0);
}

//----------------------------------------------------------------------------------------
// TDocument::GetTitle:
//----------------------------------------------------------------------------------------

CString_AC TDocument::GetTitle() const
{
	return fTitle;
}

//----------------------------------------------------------------------------------------
// TDocument::SetTitle:
//----------------------------------------------------------------------------------------

void TDocument::SetTitle(const CString_AC& aTitle)
// SetTitle sets the title of this document to the given string.  It also iterates through
// all associated windows and gives the windows a chance to adjust their titles.
//
// aTitle:	A constant string containing the new title of the document.
//
// Call?		As needed.
// Override?	As needed.
{
	fTitle = aTitle;

	for (CWindowIterator iter(this); iter.Current(); ++iter)
		(*iter).SetTitleForDoc(aTitle);
}

//----------------------------------------------------------------------------------------
// TDocument::SetChangeCount:
//----------------------------------------------------------------------------------------

void TDocument::SetChangeCount(long newChangeCount)
{
	fChangeCount = newChangeCount;
}

//----------------------------------------------------------------------------------------
// TDocument::ShowReverted:
//----------------------------------------------------------------------------------------

void TDocument::ShowReverted()
{
	for (CWindowIterator iter(this); iter.Current(); ++iter)
		(*iter).ShowReverted();
}

//----------------------------------------------------------------------------------------
// TDocument::ShowWindows:
//----------------------------------------------------------------------------------------

void TDocument::ShowWindows()
{
	// Make the windows open from back to front
	for (CWindowIterator iter(this, kIterateBackward_AC); iter.Current(); ++iter)
		if ((*iter).GetOpenInitially())
			(*iter).Open();
}

//----------------------------------------------------------------------------------------
// TDocument::UntitledName:
//----------------------------------------------------------------------------------------

CString_AC TDocument::UntitledName()
// UntitledName returns a string containing an untitled document name.  If this is the
// first such request then an unnumbered name is returned, otherwise, sequentially
// numbered names are returned upon each call.  This is done by fetching the bzUntitled
// string from the buzzwords STR# resource and substituting the marker string with
// a sequential number.  Note that the document number is always incremented, even 
//if the bzUntitled does not contain the proper marker string.
//
// Call?	Rarely.  UntitledName is called by the application when creating new documents.
{
	CString_AC		theNewName;

	if (gNumUntitled == 1)
	{
		// This is the first time we've been called then we simply pull
		// the bzFirstUntitled string and do not append a number.
		theNewName = CString_AC(static_cast<ResNumber>(kIDBuzzString), bzFirstUntitled);
			++gNumUntitled;
	}
	else
	{
		// This is not the first time we've been called so pull
		// the bzUntitled string and substitute in the document number.
		CString_AC		numString;
		theNewName = CString_AC(static_cast<ResNumber>(kIDBuzzString), bzUntitled);
		stringprintf(numString, "%ld", gNumUntitled++);
		theNewName = theNewName.DoSubstitution(numString);
	}
	return theNewName;
}

//----------------------------------------------------------------------------------------
// Undo Support
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TDocument::GetUndoHandler:
//----------------------------------------------------------------------------------------

TUndoHandler* TDocument::GetUndoHandler()
{
	TUndoHandler* undoHandler = TEventHandler::GetUndoHandler();

	if (!undoHandler)
	{
		undoHandler = TH_new TUndoHandler();
		AddBehavior(undoHandler);
	}

	return undoHandler;
}

//----------------------------------------------------------------------------------------
// Scripting Support
//----------------------------------------------------------------------------------------

#if qAppleEventAware

//----------------------------------------------------------------------------------------
// TDocument::GetObjectProperty:
//----------------------------------------------------------------------------------------

bool TDocument::GetObjectProperty(CAEDesc_AC&		thePropertyValue,
								  DescType			whichProperty,
								  const CAEDesc_AC&	desiredType)
{
	bool hasProperty = true;

	try
	{
		switch (whichProperty)
		{
			case pIsModified:
				thePropertyValue.PutBoolean(IsChanged());
				break;

			case pName:
				thePropertyValue.PutString(GetTitle());
				break;

			case pIndex:
				{
					// Locate the first window that has ourself as its document, counting
					// documents as we go so that we can determine our 'order' in the
					// document list in visual order.
					hasProperty = false;
					MScriptableObject*	myContainer = GetObjectsContainer();
					long				numWindows = myContainer->CountContainedObjects(cWindow);
					set<TDocument*>		documentSet;	// Will contain documents in window order up
														// to but not including the target document.

					// Scan window list until we find ourself.
					for (long index = 1; index <= numWindows; ++index)
					{
						TWindow*	indexedWindow =
								dynamic_cast_or_throw_AC(TWindow*,myContainer->GetIndContainedObject(cWindow, index));
						TDocument*	indexedDocument = indexedWindow->GetDocument();
						
						if (indexedDocument)
						{
							// If we have found ourself then simply return the size of
							// the list of documents plus one.
							if (this == indexedDocument)
							{
								thePropertyValue.PutLong(documentSet.size()+1);
								hasProperty = true;
								break;
							}
							else
								// Insert the newly found document, since it's not ourself,
								// into the set.
								documentSet.insert(indexedDocument);
						}
#if qDebugMsg
						else if (gIntenseDebugging)
							ProgramBreak_AC("TDocument::GetObjectProperty: Window %1d has no document.",index);
#endif
					}
				}
				break;

			default:
				hasProperty = MScriptableObject::GetObjectProperty(thePropertyValue, whichProperty, desiredType);
				break;
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		hasProperty = false;
	}

	return hasProperty;
}

//----------------------------------------------------------------------------------------
// TDocument::GetSetPropertyInfo:
//----------------------------------------------------------------------------------------

void TDocument::GetSetPropertyInfo(	DescType			whichProperty,
									CommandNumber&		cmdNum,
									bool&				canUndo,
									bool&				causesChange,
									TEventHandler*&		theContext)
{
	MScriptableObject::GetSetPropertyInfo(whichProperty, cmdNum, canUndo,
		causesChange, theContext);

	if (whichProperty == pName)
	{
		canUndo = false;
		causesChange = false;
	}
}

//----------------------------------------------------------------------------------------
// TDocument::SetObjectProperty:
//----------------------------------------------------------------------------------------

void TDocument::SetObjectProperty(const CAEDesc_AC& thePropertyValue, DescType whichProperty)
{
	switch (whichProperty)
	{
		case pName:
			{
				CString_AC theDocName = thePropertyValue.GetString();
				SetTitle(theDocName);
			}
			break;

		case pIsModified:
			::ThrowIfOSErr_AC(errAECantSetReadOnly);
			break;

		default:
			MScriptableObject::SetObjectProperty(thePropertyValue, whichProperty);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TDocument::GetContainedObject:
//----------------------------------------------------------------------------------------

MScriptableObject* TDocument::GetContainedObject(DescType			desiredType,
												 DescType			selectionForm,
												 const CAEDesc_AC&	selectionData)
{
	MScriptableObject * result = NULL;
	CAEDesc_AC theSelectionData = selectionData;
	if ((desiredType == cProperty) && (theSelectionData.GetType() == pSelection))
		result = GetUserSelection();
	else
		result = MScriptableObject::GetContainedObject(desiredType, selectionForm, selectionData);
	return result;
}

//----------------------------------------------------------------------------------------
// TDocument::DoAESetData:
//----------------------------------------------------------------------------------------

void TDocument::DoAESetData(TAppleEvent* message, TAppleEvent* reply)
{
	#pragma unused (message, reply)
	// Handles the SetData AppleEvent from the Core Suite.
	// TDocument overrides this method so it can handle this event
	// and avoid an event not handled error, but
	// it doesn't actually do anything with the data.
}

//----------------------------------------------------------------------------------------
// TDocument::DoAEClose:
//----------------------------------------------------------------------------------------

void TDocument::DoAEClose(TAppleEvent* message, TAppleEvent* reply)
{
	CTempAllocation tempAllocation(true);
	CTempObjectAllocation tempObjectAllocation(true);
	
	TCloseDocCommand* aCloseCommand = MakeCloseCommand(message, reply);

	// Process the command immediately rather than posting it.
	aCloseCommand->Process();
}

//----------------------------------------------------------------------------------------
// TDocument::DoAERevert
//----------------------------------------------------------------------------------------

void TDocument::DoAERevert(TAppleEvent*	message, TAppleEvent* reply)
{
	CTempAllocation tempAllocation(true);
	CTempObjectAllocation tempObjectAllocation(true);
	bool inProcess = true;

	PostCommand(TH_new TRevertCommand(this, message, reply, &inProcess));

	// Now we're going modal until we're sure the command
	// has completed successfully.
	while (inProcess)
		gDispatcher->PollEvent(kAllowApplicationToSleep);
}

//----------------------------------------------------------------------------------------
// TDocument::DoAESave
//----------------------------------------------------------------------------------------

void TDocument::DoAESave(TAppleEvent* message, TAppleEvent* reply)
{
	// Generate a save document command.
	CTempAllocation tempAllocation(true);
	CTempObjectAllocation tempObjectAllocation(true);
	TSaveCommand* aSaveCommand = MakeSaveCommand(message, reply);

	// Process the command immediately rather than posting it.
	aSaveCommand->Process();
}

//----------------------------------------------------------------------------------------
// TDocument::DoScriptCommand
//----------------------------------------------------------------------------------------

void TDocument::DoScriptCommand(CommandNumber 	aCommandNumber,
								TAppleEvent* 	message,
								TAppleEvent* 	reply)
{
	switch (aCommandNumber)
	{
//		case cAEUndo:
//		case cAERedo:
//			if (CommandEnabled(cUndo))
//				gDispatcher->UndoRedoInContext(this, aCommandNumber);
//			break;

		case cAERevert:
			DoAERevert(message, reply);
			break;

		default:
			MScriptableObject::DoScriptCommand(aCommandNumber, message, reply);
			break;
	}
}

#endif	// #if qAppleEventAware

//========================================================================================
// CLASS TRevertCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TRevertCommand::TRevertCommand:
//----------------------------------------------------------------------------------------

TRevertCommand::TRevertCommand(TDocument* itsDocument)
	:	TCommand(cRevert, itsDocument, kCantUndo, kDoesNotCauseChange, itsDocument),

	fChangedDocument(itsDocument),
	fInProcessP(NULL)
{
	// Ask them if they are sure they want to revert.
	::ThrowIfOSErr_AC(MAInteractWithUser());

#if qNavigation
	if (gApplication && gApplication->WantsNavigationServices() && ::NavServicesAvailable())
	{
		OSErr theErr = noErr;
		CTempNavEventUPP eventUPP(MacAppNavigationEventFilter);

		NavAskDiscardChangesResult 	reply;
		NavDialogOptions			dialogOptions;

		::NavGetDefaultDialogOptions(&dialogOptions);
		::CopyStr255(fChangedDocument->GetTitle(), (char*)dialogOptions.savedFileName);

		theErr = ::NavAskDiscardChanges(&dialogOptions, &reply, eventUPP, NULL);

		if (reply == kNavAskDiscardChangesCancel)
			::ThrowIfOSErr_AC(userCanceledErr);
	}
	else
#endif
	{
		ParamText(CStr255_AC(fChangedDocument->GetTitle()), gEmptyString, gEmptyString, gEmptyString);

		if (MacAppAlert(phRevert, NULL) != kYesButton)
			::ThrowIfOSErr_AC(userCanceledErr);
	}
}

//----------------------------------------------------------------------------------------
// TRevertCommand destructor
//----------------------------------------------------------------------------------------

TRevertCommand::~TRevertCommand()
{
	if (fInProcessP)
		*fInProcessP = false;
}

//----------------------------------------------------------------------------------------
// TRevertCommand::DoIt:
//----------------------------------------------------------------------------------------

void TRevertCommand::DoIt()
{
	fChangedDocument->RevertDocument();
	fChangedDocument->ShowReverted();
	if (fInProcessP)
		*fInProcessP = false;
}

#if qAppleEventAware

//----------------------------------------------------------------------------------------
// TRevertCommand::TRevertCommand
//----------------------------------------------------------------------------------------

TRevertCommand::TRevertCommand(TDocument*		itsDocument,
							   TAppleEvent*		message,
							   TAppleEvent*		reply,
							   bool*			statusP)
	:	TCommand(cRevert, itsDocument, kCantUndo, kDoesNotCauseChange, itsDocument),
		fChangedDocument(itsDocument),
		fInProcessP(statusP)
{
	#pragma unused (message, reply)

	if (fInProcessP)
		*fInProcessP = true;
}

//----------------------------------------------------------------------------------------
// TRevertCommand::MakeAppleEvent:
//----------------------------------------------------------------------------------------

TAppleEvent* TRevertCommand::MakeAppleEvent()
{
	CAutoPtr_AC<TAppleEvent> theEvent(TH_new TAppleEvent(kAEMiscStandards, kAERevert, gServerAddress, kAEWaitReply));

	// Add the document as the direct object
	CTempDesc_AC docDesc;
	fChangedDocument->MakeObjectSpecifier(docDesc, formName);
	theEvent->WriteParameter(keyDirectObject, docDesc);

	return theEvent.release();
}

#endif	// #if qAppleEventAware

//========================================================================================
// CLASS TSaveCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TSaveCommand::TSaveCommand:
//----------------------------------------------------------------------------------------

TSaveCommand::TSaveCommand(TDocument* itsDocument, EventNumber saveType)
	:	TCommand(saveType, itsDocument,  kCantUndo, kDoesNotCauseChange, NULL),
		fDocument(itsDocument)
{
}

//----------------------------------------------------------------------------------------
// TSaveCommand::DoIt:
//----------------------------------------------------------------------------------------

void TSaveCommand::DoIt()
{
	if (fDocument && fDocument->GetCommitOnSave())
		fDocument->CommitLastCommand();
}

#if qAppleEventAware

//----------------------------------------------------------------------------------------
// TSaveCommand::TSaveCommand:
//----------------------------------------------------------------------------------------

TSaveCommand::TSaveCommand(	TDocument*		itsDocument,
							TAppleEvent*	message,
							TAppleEvent*	reply,
							EventNumber		saveType)
	// This doesn't actually prepare to save anything since we don't have any idea
	// what kind of document you have.
	:	TCommand(saveType, itsDocument, kCantUndo, kDoesNotCauseChange, NULL),
		fDocument(itsDocument)
{
	#pragma unused (message, reply)
}

//----------------------------------------------------------------------------------------
// TSaveCommand::MakeAppleEvent:
//----------------------------------------------------------------------------------------

TAppleEvent* TSaveCommand::MakeAppleEvent()
{
	CAutoPtr_AC<TAppleEvent> theEvent(TH_new TAppleEvent(kAECoreSuite, kAESave, gServerAddress, kAEWaitReply));

	CTempDesc_AC theDocDesc;
	fDocument->MakeObjectSpecifier(theDocDesc, fDocument->GetSpecifierForm());
	theEvent->WriteParameter(keyDirectObject, theDocDesc);

	return theEvent.release();
}

#endif	// #if qAppleEventAware

//========================================================================================
// CLASS TCloseDocCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TCloseDocCommand constructor
//----------------------------------------------------------------------------------------

TCloseDocCommand::TCloseDocCommand(CommandNumber itsCommandNumber,
								   TDocument* itsDocument)
	:	TCommand(itsCommandNumber, itsDocument,  kCantUndo, kDoesNotCauseChange, NULL),
		fDocument(itsDocument),
		fSavingState(kUnknown)
{
	fUseAppleEvent = true;		// We want to default here.

	if (fDocument->IsChanged())
	{
		if (fDocument->GetAskOnClose())
			fSavingState = kAskSave;
		else
			fSavingState = kDoSave;
	}
	else
		fSavingState = kDontSave;
}

//----------------------------------------------------------------------------------------
// TCloseDocCommand::AskToSave
//----------------------------------------------------------------------------------------

void TCloseDocCommand::AskToSave()
{
	if (fSavingState == kAskSave)
	{
		short poseResult = fDocument->PoseSaveDialog();
		switch (poseResult)
		{
			case kNoButton:
				fSavingState = kDontSave;
				break;

			case kYesButton:
				fSavingState = kDoSave;
				break;

			case cancel:
				fSavingState = kCanceled;
				::ThrowIfOSErr_AC(userCanceledErr);
				break;
		}
	}
}

//----------------------------------------------------------------------------------------
// TCloseDocCommand::DoIt:
//----------------------------------------------------------------------------------------

void TCloseDocCommand::DoIt()
{
	if (fDocument)
	{
		if (fSavingState == kAskSave)
			AskToSave();

		if (fSavingState != kCanceled)
		{
			if (fSavingState == kDoSave)
			{
				if (fDocument->GetCommitOnSave())
					fDocument->CommitLastCommand();

				fDocument->SaveDocument(fIdentifier);
			}

			// If there is actually some saving to do it should have already been done.
			fDocument->SetChangeCount(0);	// Force it to not save since it will have
											// already have been saved if desired by user.
			fDocument->Close();
			delete fDocument;
		}
		else
			::ThrowIfOSErr_AC(userCanceledErr);
	}
}

#if qAppleEventAware

//----------------------------------------------------------------------------------------
// TCloseDocCommand constructor
//----------------------------------------------------------------------------------------

TCloseDocCommand::TCloseDocCommand(TDocument* itsDocument, TAppleEvent* message, TAppleEvent* reply)
	:	TCommand(cClose, itsDocument,  kCantUndo, kDoesNotCauseChange, NULL),
		fDocument(itsDocument),
		fSavingState(kDoSave)
{
	#pragma unused (reply)

	// Does the AppleEvent specifically say not to save?
	bool hasSaveOptions = message->HasParameter(keyAESaveOptions);
	if (hasSaveOptions)
	{
		// Get the save options
		DescType theSaveOption = message->ReadEnum(keyAESaveOptions);
		if (theSaveOption == kAEAsk)
			fSavingState = kAskSave;
		else if (theSaveOption == kAENo)
			fSavingState = kDontSave;
	}
	else if (fDocument->GetAskOnClose())
		fSavingState = kAskSave;
}

//----------------------------------------------------------------------------------------
// TCloseDocCommand::MakeAppleEvent:
//----------------------------------------------------------------------------------------

TAppleEvent* TCloseDocCommand::MakeAppleEvent()
{
	TAppleEvent* returnVal = NULL;

	if (fSavingState == kAskSave)
		AskToSave();

	if (fSavingState != kCanceled)
	{
		CAutoPtr_AC<TAppleEvent> theEvent(TH_new TAppleEvent(kAECoreSuite, kAEClose, gServerAddress, kAEWaitReply));
		{
			CTempDesc_AC theDocDesc;
			fDocument->MakeObjectSpecifier(theDocDesc, fDocument->GetSpecifierForm());
			theEvent->WriteParameter(keyDirectObject, theDocDesc);
		}
		// What kind of saving is desired.
		DescType theSaveOption = kAEAsk;
		if (fSavingState == kDoSave)
			theSaveOption = kAEYes;
		else if (fSavingState == kDontSave)
			theSaveOption = kAENo;
		theEvent->WriteEnum(keyAESaveOptions, theSaveOption);

		returnVal = theEvent.release();
	}

	return returnVal;
}

#endif	// #if qAppleEventAware

//----------------------------------------------------------------------------------------
// End of UDocument.cpp

/*
	Historical Change Record:
		----- R13 -----
		07/09/97	Replaced AllocateObjectsFromPerm with TempAllocation.
		07/03/97	[1615435] Removed GetSpecifierForm since default behavior of returning
							formAbsolutePosition is appropriate.
		07/02/97	Don't user autoPtr for TCloseDocCommand in DoAEClose.
		06/25/97	Removed excessive blank lines.
		06/17/97	[1615680] TDocument::DoClose now calls MakeCloseCommand.  Added
							comments to MakeCloseCommand.  Added command number to interface
							to MakeCloseCommand.  Added a MakeCloseCommand which uses an AppleEvent
							for making the command.
		06/22/97	Minor changes for VC++.
		06/22/97	Minor change for VC++.
		06/09/97	Use dynamic_cast_AC where we expected dynamic_cast to always work.
		06/04/97	[1615892] Check result of dynamic_cast.
		05/28/97	[1357034] Removed TDocument::DoSetupMenus; cSave et al are now set up in TFileBasedDocument
		04/23/97	Remove Clone declarations from classes we don't clone.
		04/23/97	ReadFields methods don't free themselves on failure.
		04/14/97	Update for real xxx_cast operators.
		04/13/97	Update List and Dependency names for ACS.
		04/09/97	properly use dynamic casting for all down/side casts
		04/07/97	Renamed TSaveCommand, added TSaveAsCommand and TSaveCopyCommand.
							Modernized all of the commands by using temporary objects.
							Removed all qContainer stuff.  Renamed TRevertDocCommand to
							TRevertCommand.  Replaced all Inherited's.
		04/08/97	Update for TAdorner/TBehavior/TEventHandler/TCommandHandler/TCommand/
							TFileBasedDocument/TSection/TEditionDocument protected fields.
		04/04/97	Update for TView/TWindow/TDispatcher/TDocument protected fields.
		03/25/97	AC_ to _AC Name change.
		03/11/97	Update exception support to latest.
		03/07/97	Massive Changes: Use Exceptions_AC, new to TH_new, use Blah_AC,
							Update Copyright, Moved Obsolete APIs into Compatibility.h, etc..
		02/19/97	Use embedded objects instead of auto_ptr based object where possible.
		02/18/97	In TRevertDocCommand constructor throw a userCancelledError if the user cancels.
							This also eliminates a long standing compiler warning.
		08/15/96	Use constructors for all TCommand descendents
		08/14/96	Use constructors for all TDispatcher descendents
		08/13/96	Use constructors for all TDocument descendents
		08/13/96	Use constructors for all TBehavior descendents
		08/10/96	Fixed -noload compiles, made more datamembers auto_ptrs, FreeIfObject->delete
		08/07/96	Goodbye TObject!
		08/01/96	T[Sorted]List now takes a void* T[Sorted]VoidList now typedefed to T[Sorted]List
		07/26/96	[1372385] Changed MDependable_AC* changedBy parameters and member to
							void* changeData.
		07/18/96	Use CAutoPtr_AC based pointers for many instance variables.
		07/17/96	define template CAutoPtr_AC and use it in place of CTempObject
		07/16/96	Replacing Failxxx with Throwxx procs
		07/16/96	Goodbye Exception Macros (TRY, CATCH_ALL, ENDTRY)
		07/15/96	Boolean->bool
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	[1290384] Overhauled AddWindow/View and DeleteWindow/View.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		06/19/96	[1351356] TDocument::CloseWindow now checks fClosesDocument.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		06/17/96	[1222063] Changed OpenWindowCount to call CountAsOpen so developer
							can change the behavior.
		06/17/96	[114989] Record all quitting-related commands.  Default recording
							in command I method to true.
		06/17/96	[1358314] Fixed interface problem building with !qTemplateViews
		06/13/96	[1350002] Fixed the document bumping it's changed count when it's closing.
							Tried to leave it intact for developers who are using the closed method, by
							leaving an empty case statement, which they could modify.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/02/95	Made TDocument::CloseAndFree deprecated. It will eventually be removed,
							please call Close and then if necessary free the object
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/30/96	Removed include for UPrinting
		03/27/96	Switch last remaining Str255s to CStr255s_AC
		03/26/96	Cleanup references to gEmptyString
		03/22/96	[1331566] Fixed double-free in three of MakeAppleEvents.
		03/14/96	Replaced curly quotes with straight single quote.
		 3/07/96	[1313793] (Printing) fSharePrintInfo not respected
		 3/01/96	Re-arranged data members, natural alignment results in
		 					reduced storage size.
							Grouped some globals and global functions as static members.
		02/19/96	[1298518] Set the default of fReopenAlert to false,
							changed copyright to 1996.
		12/20/95	Add RevealUndoRedo.
		12/19/95	Don't need failure handler in DoIt just for SetValidationError.
		12/18/95	Remove linkedCommand argument to ICloseDocCommand.
		 12/8/95	Split up includes for modular MacApp.
							Bring back MAInteractWithUser.
		 5/23/95	Add IsChanged (CALib).
		----- 3.3 -----
		11/15/95	Added TDocument::RegainControl.
		11/03/95	Fix user interaction for TCloseDocCommands.
		11/03/95	Setting name property is not undoable.
		11/01/95	Check interaction level in IRevertDocCommand before posing
							revert dialog.  Also check in OpenAgain and don't pose alert
							just go ahead an bring window to front.
		10/31/95	Remove TDocument::DoAEPrint.
		10/31/95	Change TRevertDocCommand to kAEWaitReply.
		10/27/95	Override GetSpecifierForm and return formName.
		10/24/95	Replace calls to GetBestType with GetSpecifierForm.
		10/21/95	Use GetBestType() in calls to MakeObjectSpecifier.
		10/16/95	TDocument::CloseWindow doesn't close the document if
							the window being closed is a floater or is invisible.
							This fixes a bug introduced in the 7/13/94 fix that
							prevented floaters and invisible windows from being
							counted in OpenWindowCount.
		10/16/95	Reintroduce the bottlenecking of window closing through
							TDocument::CloseWindow().
		10/11/95	Include UMemory.h.
		10/11/95	[1263154] Cleaned up the AllocateObjectsFromPerm calling.
		 9/26/95	[1276050] Check for read-only items [pIsModified] in
		 					TDocument::SetObjectProperty.
		 9/22/95	[1287420] Removed the linkedCommand argument from the TDocument::
		 					DoClose interface and from its call to ICloseDocCommand.
		 9/22/95	Add fIsGhostDocument, GetIsGhostDocument, SetIsGhostDocument.
		----- 3.3b1 -----
		  9/7/95	It's that const problem.  Don't use it lightly.
		  9/6/95	(Maybe one of these days I'll get it right!)  Changed
		  					TCloseDocCommand back to derive from TCommand and made
							changes to the error handling.  Immediately process
							the close command in TDocument::DoAEClose.  Made the
							same changes to TSaveDocCommand.
		 8/30/95	Moved all user interaction for save/close doc commands
		 					back into the I-methods so that recording would work
							properly.  Caught userCanceledError in DoSave and DoClose.
		 8/23/95	TDocument::DoClose now returns void rather than bool and links with
							another command if required.  Added a failure handler to TCloseDocCommand::DoIt.
		 8/22/95	TSave/CloseDocCommand are now based on TServerCommand.
		 8/16/95	Removed modal loop in DoAEClose/Save since TCloseDocCommand was
		 					changed to derive from TServerCommand.
		 8/10/95	Repaired document saving command which would not perform
		 					a cSaveAs unless the document was dirty.
		  8/9/95	Execution of DoAEClose, DoAERevert and DoAESave were made modal
		  					so that errors could be reported to the client properly.
		  8/8/95	Changed context to the document in the ICloseDocCommand
		  					function.  Also increased its priority.  Fixed parameter
							bug in TSaveDocCommand::MakeAppleEvent.
		  8/7/95	Include UScriptableObject.h for access to error
		  					string.  Modify document closing to remove the
							MakeDocClose command functions.  Changed I-methods
							so they no longer need to be virtual.
		  8/4/95	Add more save states and PoseSaveDialog method
		  					to TCloseDocCommand.
		 7/31/95	Modified closing of documents which is now recordable.
		 					See TCloseDocCommand.
		 7/30/95	Need to include UPrinting to get TPrintInfo.
		07/26/95	Created a TPrinter object and a TPrintInfo object
		 7/27/95	Conditionalize attachability support.
		 6/28/95	Reorder scripting method params.
		 6/15/95	Document passes "this" to MScriptableObject constructor.
		 6/12/95	Moved PowerTalk support to TMailDocument.
		 6/12/95	Reorder params to DoScriptCommand
		 4/12/95	Base class constructors called from mem initializers don't
		 					rely on default arguments.
		 3/30/95	Remove unnecessary includes.
		 3/14/95	Add TLetter and TFileBaseLetter classes.
		 3/13/95	Change Free methods to destructors.
		 3/12/95	Change MMailable method names so as not to conflict with base
		 					classes. Don't need to call MMailable from TDocument constructor.
		 3/10/95	Move mail code to MMailable mixin class.
		 2/24/95	Remove PPCC warning message.
		 2/20/95	Move GetSaveLocation and DoSave out of qPowerTalk area.
		 2/19/95	Remove unused from local variables from DoMenuCommand.
		 2/17/95	Integration fixes.
		 2/14/95	Second batch of attachability changes.
							Add DoAESetData.
		  2/3/95	Fix DetachPrintHandler to not free NULL objects.
		 1/26/95	Add DoAEClose.
							Add fSaveAttachedScript and fAskOnClose.
							Change TDocument::Close to not call PoseSaveDialog
							when fAskOnClose is false.
							In DoMenuCommand case cUndo, change call to
							application's DoUndoRedo method. Remove case for
							cAEUndo and cAERedo that was calling the application's
							UndoRedoInContext method.
							Call DoSave instead of posting a TSaveDocCommand.
							Add desiredType to GetObjectProperty.
							Add DoAEClose.
							In TDocument::CountContainedObjects, call MScriptableObject::
							CountContainedObjects instead of TDocument:: CountContainedObjects.
							This looks like a bug fix to me.
							In DoSendOptions, add a * to dereference nativeFormats.
							Add GetSaveLocation. Add DoSave.
							In DoScriptCommand, add support for cAEUndo and cAERedo.
		 2/14/95	TDocument::GetObjectProperty returns a bool.
		----- 3.5d3 -----
		11/17/94	Change NULL to nil.
		11/14/94	Ken Ryall fixed a minor naming bug in DoSendOptions.
		11/13/94	Support qPowerTalk conditional compile
		10/28/94	Changed TDocument::CountContainedObjects to not
							call itself recursively. Thanks Jeroen!
		 9/23/94	Modified to support new TScriptEventDispatcher.
		 9/14/94	Added Ken Ryall's AOCE mailer support.
		 8/29/94	Added support for pIndex to GetObjectProperty. Now
							returns the index of the associated window.
		 7/26/94	Include UAppleEvents.
		 7/18/94	Change NULL to nil.
		 7/14/94	Merged with Ken Ryall's MAScript changes.
		 7/13/94	Don't include floaters in OpenWindowCount (as per
							Ed Anson).
*/