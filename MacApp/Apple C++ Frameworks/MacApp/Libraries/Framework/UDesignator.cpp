//----------------------------------------------------------------------------------------
// UDesignator.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		08/31/00	Use MStreamable_AC instead of MStreamable.  Cosmetic.
		08/10/99	Removed Inherited.
		03/24/99	Update copyright notice.
		03/23/99	Go back to native Toolbox region calls.
		10/29/98	[W] No longer necessary to include QTMLMapNames.h.  Use CopyRgn_AC,
					EqualRgn_AC and include ImagingUtils_AC.h.
*/

#ifndef __UDESIGNATOR__
#include "UDesignator.h"
#endif

// ACS

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

#ifndef __ImagingStreaming_AC__
#include "ImagingStreaming_AC.h"
#endif

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

// Toolbox

#if qAppleEventAware
	#ifndef __AEREGISTRY__
	#include <AERegistry.h>
	#endif
#endif

//========================================================================================
// CLASS TDesignator
//========================================================================================

MA_DEFINE_CLASS(TDesignator);

//----------------------------------------------------------------------------------------
// TDesignator::TDesignator
//----------------------------------------------------------------------------------------

TDesignator::TDesignator()
#if qAppleEventAware
	: MScriptableObject(cSelection)
#endif
{
}

//----------------------------------------------------------------------------------------
// TDesignator destructor
//----------------------------------------------------------------------------------------

TDesignator::~TDesignator()
{
}

//----------------------------------------------------------------------------------------
// TDesignator::GetSize: 
//----------------------------------------------------------------------------------------

Size TDesignator::GetSize() const
{
	// SubClassResponsibility();
	return 0;
}

//----------------------------------------------------------------------------------------
// TDesignator::IsContained: 
//----------------------------------------------------------------------------------------

ContainmentType TDesignator::IsContained(TDesignator* aDesignator)
{
	#pragma unused (aDesignator)
	return kNotContained;
}

//----------------------------------------------------------------------------------------
// TDesignator::IsEmpty: 
//----------------------------------------------------------------------------------------

bool TDesignator::IsEmpty() const
{
	return GetSize() <= 0;				// empty if nothing designated
}

//========================================================================================
// CLASS TLinearDesignator
//========================================================================================

MA_DEFINE_CLASS(TLinearDesignator);

//----------------------------------------------------------------------------------------
// TLinearDesignator::TLinearDesignator
//----------------------------------------------------------------------------------------

TLinearDesignator::TLinearDesignator(long startPos,
												 long endPos) :
	fStartPos(startPos),
	fEndPos(endPos)
{
}

//----------------------------------------------------------------------------------------
// TLinearDesignator destructor
//----------------------------------------------------------------------------------------

TLinearDesignator::~TLinearDesignator()
{
}

//----------------------------------------------------------------------------------------
// TLinearDesignator::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TLinearDesignator::GetStandardSignature() const
{
	return kLinearDesignator;
}

//----------------------------------------------------------------------------------------
// TLinearDesignator::GetSize: 
//----------------------------------------------------------------------------------------

Size TLinearDesignator::GetSize() const
{
	return (Size)(fEndPos - fStartPos);
}

//----------------------------------------------------------------------------------------
// TLinearDesignator::ReadFrom: 
//----------------------------------------------------------------------------------------

void TLinearDesignator::ReadFrom(CStream_AC* aStream)
{
	MStreamable_AC::ReadFrom(aStream);

	fStartPos = aStream->ReadLong();
	fEndPos = aStream->ReadLong();
}

//----------------------------------------------------------------------------------------
// TLinearDesignator::WriteTo: 
//----------------------------------------------------------------------------------------

void TLinearDesignator::WriteTo(CStream_AC* aStream) const
{
	MStreamable_AC::WriteTo(aStream);

	aStream->WriteLong(fStartPos);
	aStream->WriteLong(fEndPos);
}

//----------------------------------------------------------------------------------------
// TLinearDesignator::IsContained: 
//----------------------------------------------------------------------------------------

ContainmentType TLinearDesignator::IsContained(TDesignator* aDesignator)
{
	ContainmentType returnVal = kNotContained;

#if qDebug
	if (aDesignator && !dynamic_cast_AC(TLinearDesignator*,aDesignator))
		::ProgramBreak_AC("The containing designator for the TLinearDesignator is not of the same class");
#endif

	if (aDesignator)
	{
		TLinearDesignator* workDesignator = dynamic_cast_or_throw_AC(TLinearDesignator*,aDesignator);
	
		long itsStartPos = workDesignator->fStartPos;
		long itsEndPos = workDesignator->fEndPos;
		
		// Are we designating the data in the other direction?  If so switch for the test.
		if (itsStartPos > itsEndPos)
		{
			itsStartPos = itsEndPos;
			itsEndPos = workDesignator->fStartPos;
		}
		
		if ((fStartPos == itsStartPos) && (fEndPos == itsEndPos))
			returnVal = kExactlyContained;
		else if ((fStartPos <= itsStartPos) && (fEndPos >= itsEndPos))
			returnVal = kFullyContained;
		else if (((fStartPos <= itsStartPos) && (fEndPos >= itsStartPos)) || ((fStartPos <= itsEndPos) && (fEndPos >= itsEndPos)))
			returnVal = kPartiallyContained;
	}

	return returnVal;
}

//========================================================================================
// CLASS TViewRectDesignator
//========================================================================================

MA_DEFINE_CLASS(TViewRectDesignator);

//----------------------------------------------------------------------------------------
// TViewRectDesignator::TViewRectDesignator: 
//----------------------------------------------------------------------------------------

TViewRectDesignator::TViewRectDesignator(const CViewRect& itsDesignation) :
	fDesignation(itsDesignation)
{
}

//----------------------------------------------------------------------------------------
// TViewRectDesignator destructor
//----------------------------------------------------------------------------------------

TViewRectDesignator::~TViewRectDesignator()
{
}

//----------------------------------------------------------------------------------------
// TViewRectDesignator::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TViewRectDesignator::GetStandardSignature() const
{
	return kVRectDesignator;
}

//----------------------------------------------------------------------------------------
// TViewRectDesignator::GetSize: 
//----------------------------------------------------------------------------------------

Size TViewRectDesignator::GetSize() const
{
	return fDesignation.GetLength(vSel) * fDesignation.GetLength(hSel);
}

//----------------------------------------------------------------------------------------
// TViewRectDesignator::ReadFrom: 
//----------------------------------------------------------------------------------------

void TViewRectDesignator::ReadFrom(CStream_AC* aStream)
{
	TDesignator::ReadFrom(aStream);
	*aStream >> fDesignation;
}

//----------------------------------------------------------------------------------------
// TViewRectDesignator::WriteTo: 
//----------------------------------------------------------------------------------------

void TViewRectDesignator::WriteTo(CStream_AC* aStream) const
{
	TDesignator::WriteTo(aStream);
	*aStream << fDesignation;
}

//----------------------------------------------------------------------------------------
// TViewRectDesignator::IsContained: 
//----------------------------------------------------------------------------------------

ContainmentType TViewRectDesignator::IsContained(TDesignator* aDesignator)
{
	ContainmentType returnVal = kNotContained;

#if qDebug
	if (aDesignator && !dynamic_cast_AC(TViewRectDesignator*,aDesignator))
		::ProgramBreak_AC("The containing designator for the TViewRectDesignator is not of the same class");
#endif

	if (aDesignator)
	{
		CViewRect itsVRect(dynamic_cast_or_throw_AC(TViewRectDesignator*,aDesignator)->fDesignation);
		
		if (fDesignation == itsVRect)
			returnVal = kExactlyContained;
		else
		{
			CViewRect dstRect = fDesignation & itsVRect;
			if (!dstRect.Empty())
				if (dstRect == itsVRect)
					returnVal = kFullyContained;
				else
					returnVal = kPartiallyContained;
		}
	}

	return returnVal;
}

//========================================================================================
// CLASS TRegionDesignator
//========================================================================================

MA_DEFINE_CLASS(TRegionDesignator);

//----------------------------------------------------------------------------------------
// TRegionDesignator::TRegionDesignator: 
//----------------------------------------------------------------------------------------

TRegionDesignator::TRegionDesignator(RgnHandle itsDesignation,
										   bool freeRegionOnFree) :
	fFreeRegionOnFree(freeRegionOnFree),
	fDesignation(itsDesignation ? itsDesignation :MakeNewRgn())	// Either assign the designation, or create it.
{
}

//----------------------------------------------------------------------------------------
// TRegionDesignator::~TRegionDesignator: 
//----------------------------------------------------------------------------------------

TRegionDesignator::~TRegionDesignator()
{
	if (!fFreeRegionOnFree)
		fDesignation.release();
}

//----------------------------------------------------------------------------------------
// TRegionDesignator::ReadFrom: 
//----------------------------------------------------------------------------------------

void TRegionDesignator::ReadFrom(CStream_AC* aStream)
{
	TDesignator::ReadFrom(aStream);

	if (!fDesignation)
		fDesignation.reset((RgnHandle)aStream->ReadHandle());
	else
	{
		// read the size of the handle in from the stream
		Size itsSize = aStream->ReadLong();

		// increase the handle appropriately
		SetPermHandleSize((Handle) fDesignation.get(), itsSize);

		// lock the handle and read into it from the stream
		CTempHandleLock_AC tempHandleLock((Handle) fDesignation.get());
		::ThrowIfMemError_AC();
		aStream->ReadBytes(*((Handle) fDesignation.get()), itsSize);
	}
}


//----------------------------------------------------------------------------------------
// TRegionDesignator::WriteTo: 
//----------------------------------------------------------------------------------------

void TRegionDesignator::WriteTo(CStream_AC* aStream) const
{
	TDesignator::WriteTo(aStream);

	aStream->WriteHandle((Handle) fDesignation.get());
}

//----------------------------------------------------------------------------------------
// TRegionDesignator copy constructor
//----------------------------------------------------------------------------------------

TRegionDesignator::TRegionDesignator(const TRegionDesignator& inRegionDesignator) :
	TDesignator(inRegionDesignator),

	fFreeRegionOnFree(inRegionDesignator.fFreeRegionOnFree),
	fDesignation(MakeNewRgn())
{
	::MacCopyRgn(inRegionDesignator.fDesignation, fDesignation);
}

//----------------------------------------------------------------------------------------
// TRegionDesignator::GetSize: 
//----------------------------------------------------------------------------------------

Size TRegionDesignator::GetSize() const
{
	Size returnVal = 0;

	if (fDesignation && !EmptyRgn(fDesignation))
	{
		CRect_AC rgnBBox(GetBounds());
		returnVal = (rgnBBox.GetLength(vSel) * rgnBBox.GetLength(hSel));
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TRegionDesignator::IsContained: 
//----------------------------------------------------------------------------------------

ContainmentType TRegionDesignator::IsContained(TDesignator* aDesignator)
{
	ContainmentType returnVal = kNotContained;
#if qDebug
	if (aDesignator && !dynamic_cast_AC(TRegionDesignator*,aDesignator))
		::ProgramBreak_AC("The containing designator for the TRegionDesignator is not of the same class");
#endif

	if (aDesignator)
	{
		TRegionDesignator* designator = dynamic_cast_or_throw_AC(TRegionDesignator*,aDesignator);
	
		RgnHandle itsDesignation = designator->fDesignation;
		
		if (::MacEqualRgn(fDesignation, itsDesignation))
			returnVal = kExactlyContained;
		else
		{
			CTempRegion_AC rRgn;
			SectRgn(fDesignation, itsDesignation, rRgn);
			if (!EmptyRgn(rRgn))
				if (::MacEqualRgn(itsDesignation, rRgn))
					returnVal = kFullyContained;
				else
					returnVal = kPartiallyContained;
		}
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TRegionDesignator::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TRegionDesignator::GetStandardSignature() const
{
	return kRegionDesignator;
}

//----------------------------------------------------------------------------------------
// TRegionDesignator::SetDesignationRect: 
//----------------------------------------------------------------------------------------

void TRegionDesignator::SetDesignationRect(const CRect_AC& theDesignation)
{
	RectRgn(fDesignation, theDesignation);
}

//----------------------------------------------------------------------------------------
// End of UDesignator.cpp


/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/09/96	Removed UStreamable to a separate file from UObject
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/29/96	Create and use functions that return their data as results for:
							TStream::ReadCharacter/ViewPoint/Rect/CViewRect/RGBColor/String. Create compatible inlines
							so users don't have to change their code.
		04/26/96	Made C/ViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/ViewPoint/Rects.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		----- R10 -----
		12/08/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		----- 3.3b1 -----
		06/16/95	Support MI in designator classdesc.
		04/14/95	save/lock and restore handle state instead of lock and unlock
		03/17/95	MAVolatile. 
		03/13/95	Change Free methods to destructors. 
		07/26/94	Include AERegistry. 
		07/14/94	Merged with Ken Ryall's MAScript changes. 
*/