//----------------------------------------------------------------------------------------
// UDragTracker.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		03/24/99	Update copyright notice.
		01/15/99	CAEDesc_AC is now in ACS. 
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.
*/

#ifndef __UDRAGTRACKER__
#include "UDragTracker.h"
#endif

// MacApp

#if qDrag
	#ifndef __UDRAGDROP__
	#include "UDragDrop.h"
	#endif
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

// Toolbox

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

// ANSI

#ifndef __STDLIB__
#include <stdlib.h>
#endif

//========================================================================================
// CLASS TDragTracker
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// TDragTracker constructor
//----------------------------------------------------------------------------------------

TDragTracker::TDragTracker(CommandNumber itsCommandNumber,
						   TView* itsView,
						   const CViewPoint& itsMouse,
						   const TToolboxEvent* event) :
	TTracker(itsCommandNumber, itsView, kCantUndo, kDoesNotCauseChange, NULL, itsView, 
			 itsView->GetScroller(kImmediateSuperView), itsMouse),
	fStarted(false)
{
	if (event)
		fEventRecord = event->GetEventRecord();
	else
		fEventRecord.what = nullEvent;
}

//----------------------------------------------------------------------------------------
// TDragTracker destructor
//----------------------------------------------------------------------------------------

TDragTracker::~TDragTracker()
{
}

//----------------------------------------------------------------------------------------
// TDragTracker::TrackConstrain:
//----------------------------------------------------------------------------------------

void TDragTracker::TrackConstrain(TrackPhase /*aTrackPhase*/,
								  const CViewPoint& /*anchorPoint*/,
								  const CViewPoint& /*previousPoint*/,
								  CViewPoint& /*nextPoint*/,
								  bool /*mouseDidMove*/)
{
}

//----------------------------------------------------------------------------------------
// TDragTracker::TrackFeedback:
//----------------------------------------------------------------------------------------

void TDragTracker::TrackFeedback(TrackPhase /*aTrackPhase*/,
								 const CViewPoint& /*anchorPoint*/,
								 const CViewPoint& /*previousPoint*/,
								 const CViewPoint& /*nextPoint*/,
								 bool /*mouseDidMove*/,
								 bool /*turnItOn*/)
{
//	if (fView)
//		fView->TrackFeedback(aTrackPhase, anchorPoint, previousPoint, nextPoint, mouseDidMove, turnItOn);
}

//----------------------------------------------------------------------------------------
// TDragTracker::TrackMouse:
//----------------------------------------------------------------------------------------

TTracker* TDragTracker::TrackMouse(TrackPhase aTrackPhase,
								   CViewPoint& /*anchorPoint*/,
								   CViewPoint& /*previousPoint*/,
								   CViewPoint& /*nextPoint*/,
								   bool /*mouseDidMove*/)
{
	TTracker* nextTracker = this;

#if qDrag
	if (HasDragManager_AC())
	{
		if (aTrackPhase == trackBegin)
		{
			StartDrag();
			
			// The drag has completed, so we're done. 
			nextTracker = NULL;
		}
	}
#endif
//	if (fView)
//		fView->TrackMouse(aTrackPhase, anchorPoint, previousPoint, nextPoint, mouseDidMove);
//
//	if (aTrackPhase == trackEnd && (!fView || !fView->ContainsMouse(nextPoint)))
//		nextTracker = NULL;

	return nextTracker;
}

#if qDrag

//----------------------------------------------------------------------------------------
// TDragTracker::StartDrag
//----------------------------------------------------------------------------------------

void TDragTracker::StartDrag()
{
	if (!fStarted)
	{
		fStarted = true;

		TDragDropSession::fgDragDropSession->ClearDrag();
		DoAddDragContent();

		fDragRegion = DoMakeDragOutlineRegion();
		TDragDropSession::fgDragDropSession->StartDrag(fView, fEventRecord, fDragRegion, this);
	}
}

//----------------------------------------------------------------------------------------
// TDragTracker::DoAddDragContent:
//----------------------------------------------------------------------------------------

void TDragTracker::DoAddDragContent()
{
	fView->DoAddDragContent();
}

//----------------------------------------------------------------------------------------
// TDragTracker::DoMakeDragOutlineRegion
//----------------------------------------------------------------------------------------

RgnHandle TDragTracker::DoMakeDragOutlineRegion()
{
	return fView->DoMakeDragOutlineRegion();
}

//----------------------------------------------------------------------------------------
// TDragTracker::DoDragEnter
//----------------------------------------------------------------------------------------

void TDragTracker::DoDragEnter()
{
#if qDragObsolete
	if (fView)
		fView->DoDragEnter();
#else
	// set up private data used to track drag
#endif
}
	
//----------------------------------------------------------------------------------------
// TDragTracker::DoDragWithin
//----------------------------------------------------------------------------------------

void TDragTracker::DoDragWithin(const CViewPoint& localMouse)
{
#if qDragObsolete
	if (fView)
		fView->DoDragWithin(localMouse);
#else
#pragma unused (localMouse)
	// update tracking data and visuals
#endif
}
								
//----------------------------------------------------------------------------------------
// TDragTracker::DoDragLeave
//----------------------------------------------------------------------------------------

void TDragTracker::DoDragLeave()
{
#if qDragObsolete
	if (fView)
		fView->DoDragLeave();
#else
	// clean up after the drag has left
#endif
}

//----------------------------------------------------------------------------------------
// TDragTracker::MakeDropLocationDescriptor
//----------------------------------------------------------------------------------------

bool TDragTracker::MakeDropLocationDescriptor(CAEDesc_AC& dropLocationDesc)
{
	return fView ? fView->DoMakeDropLocationDescriptor(dropLocationDesc) : false;
}

//----------------------------------------------------------------------------------------
// TDragTracker::WillDragMove
//----------------------------------------------------------------------------------------

bool TDragTracker::WillDragMove(TView* destinationView)
{
#if qDragObsolete
	return fView ? fView->WillDragMove(destinationView) : false;
#else
	// test the family id's first
	bool isMove = (fView->GetDragMoveFamily() == destinationView->GetDragMoveFamily());

	if (isMove)
	{
		switch (fView->GetDragMoveDeterminer())
		{
			case kNeverMove:
				isMove = false;
				break;

			case kMoveWithinView:
				isMove = (fView == destinationView);
				break;

			case kMoveWithinWindow:
				isMove = (GetWindow() == destinationView->GetWindow());
				break;

			case kMoveWithinContext:
				isMove = (fView->GetContext(cDragMove) == destinationView->GetContext(cDragMove));
				break;

			case kMoveWithinApplication:		// already true.
				break;

			default:
				isMove = false;					// unknown context value
				break;
		}
	}

	return isMove;
#endif
}

//----------------------------------------------------------------------------------------
// TDragTracker::DoMakeDragDropCommand
//----------------------------------------------------------------------------------------

TCommand* TDragTracker::DoMakeDragDropCommand(CommandNumber itsCommandNumber,
											  CDragItemIterator& dragItemIterator,
											  TDragTracker* targetTracker)
{
#if qDragObsolete
	return fView
			? fView->DoMakeDragDropCommand(itsCommandNumber, dragItemIterator, targetTracker)
			: NULL;
#else
#pragma unused (itsCommandNumber, dragItemIterator)
	return NULL;								// subview responsibility
#endif
}

//----------------------------------------------------------------------------------------
// TDragTracker::DoFulfillPromise
//----------------------------------------------------------------------------------------

void TDragTracker::DoFulfillPromise(TDragItem* promisedItem)
{
#if qDragObsolete
	if (fView)
		fView->DoFulfillPromise(promisedItem);
#else
#pragma unused (promisedItem)
	// subview responsibility
#endif
}

#endif // qDrag

//----------------------------------------------------------------------------------------
// End of UDragTracker.cpp
