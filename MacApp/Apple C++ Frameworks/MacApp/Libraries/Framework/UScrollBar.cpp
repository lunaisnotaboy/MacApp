//----------------------------------------------------------------------------------------
// UScrollBar.cpp
// Copyright © 1987-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/10/01	Added redraw parameter to UpdateScrollAmounts.  Hide and shown
					the pen if this parameter is false.  Pass false to
					UpdateScrollAmounts in AttachScroller. 
		03/01/01	Don't include Windows_AC. 
		01/24/01	[W] Handle kControlIndicatorPart case in TrackScrollBar.  Added
					SB_THUMBTRACK handling in HandleWindowsEvent.  Added SetWindowsWindow.
		01/02/01	Update copyright.
		11/27/00	TScrollerScrollBar most commonly is used with one scroller,
					so give fScrollers an allocation increment of 1. 
		11/14/00	[W] Simply refer DoMouseCommand since it is automatically
					handled.
		11/10/00	Cosmetic.
		11/03/00	[C] Don’t include Balloons.h.
		11/01/00	[PB] Include MacErrors instead of Errors.
		10/02/00	Replace CCharStr with standard strings.
		09/18/00	Save and restore the port and the clip region in the control
					action callback.
		09/07/00	Work around Carbon controls not redrawing during tracking.
					Compute proportional scroll bar sizes a little better.
		09/06/00	Added embedded documentation - TScrollerScrollBar::AttachScroller.
		08/01/00	[W] Set scrollbar style in ctor.  Added DoPostCreate.  Reworked
					UpdateScrollAmounts.  Removed Inherited.  Cosmetic.
					Added GetMaximum, GetMinimum, GetValue, SetMaximum,
					SetMinimum, SetValue, SetValues, GetWindowsClassName and
					HandleWindowsEvent.
		03/31/00	TrackScrollBar had some incorrect scoping of variables within
					case and removed unused newLongValue variable.
		12/27/99	Stripped out unused code.
		12/08/99	Added safeguard in DoMouseCommand.  Make sure we have a nun-NULL
					control before drawing in Draw.
		03/24/99	Update copyright notice.
		03/23/99	Replace ...Rect_AC calls with standard Toolbox rect calls.
		11/13/98	[2279273] Changed iter-> for MrC.
		11/05/98	[2279096] Set fHandlesFirstClicks true if in floating window.
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					FrameRect_AC.  Include ImagingUtils_AC.h.
*/

#ifndef __UScrollBar__
#include "UScrollBar.h"
#endif

// MacApp

#ifndef __UADORNERS__
#include "UAdorners.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDRAWINGENVIRONMENT__
#include "UDrawingEnvironment.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

// for DelayFuture_AC
#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CIterator__
#include "CIterator_AC.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

#ifndef __ImagingStreaming_AC__
#include "ImagingStreaming_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

// Toolbox

#if !qCarbon
	#ifndef __BALLOONS__
	#include <Balloons.h>
	#endif
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MACWINDOWS__
#include <MacWindows.h>
#endif

// ANSI

#ifndef __LIMITS__
#include <limits.h>
#endif

#ifndef __STDLIB__
#include <stdlib.h>
#endif

#ifndef __APPEARANCE__
#include <Appearance.h>
#endif

//========================================================================================
// CLASS TScrollBar
//========================================================================================

MA_DEFINE_CLASS(TScrollBar);

//----------------------------------------------------------------------------------------
// TScrollBar constructor
//----------------------------------------------------------------------------------------

TScrollBar::TScrollBar(const CViewPoint&	itsLocation,
					   const CViewPoint&	itsSize,
					   SizeDeterminer		itsHSizeDet,
					   SizeDeterminer		itsVSizeDet,
					   VHSelect				itsDirection,
					   long					itsVal,
					   long					itsMin,
					   long					itsMax)
	:	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, gEmptyString),
		fDirection(itsDirection),
		fInitialVal(itsVal),
		fInitialMin(itsMin),
		fInitialMax(itsMax)
{
	fEventNumber = itsDirection == hSel ? mHScrollBarHit : mVScrollBarHit;
	fHandlesFirstClicks = false;
	SetOpacity(true);

#if qMSWindows
	SetWindowsWindowStyle(WS_CHILD | (fDirection == hSel ? SBS_HORZ : SBS_VERT));
#endif
}

//----------------------------------------------------------------------------------------
// TScrollBar copy constructor
//----------------------------------------------------------------------------------------

TScrollBar::TScrollBar(const TScrollBar& inScrollBar)
	:	TCtlMgr(inScrollBar),
		fDirection(inScrollBar.fDirection),
		fInitialVal(inScrollBar.GetValue()),
		fInitialMin(const_cast<TScrollBar&> (inScrollBar).GetMinimum()),
		fInitialMax(const_cast<TScrollBar&> (inScrollBar).GetMaximum())
{
	fEventNumber = fDirection == hSel ? mHScrollBarHit : mVScrollBarHit;
	fHandlesFirstClicks = false;
	SetOpacity(true);
}

//----------------------------------------------------------------------------------------
// TScrollBar destructor
//----------------------------------------------------------------------------------------

TScrollBar::~TScrollBar()
{
}

//----------------------------------------------------------------------------------------
// TScrollBar::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TScrollBar::GetStandardSignature() const
{
	return kStdScrollBar;
}

//----------------------------------------------------------------------------------------
// TScrollBar::ReadFields:
//----------------------------------------------------------------------------------------

void TScrollBar::ReadFields(CStream_AC* aStream)
{
	TCtlMgr::ReadFields(aStream);

	fDirection = (VHSelect) aStream->ReadByte();

	fInitialVal = aStream->ReadLong();
	fInitialMin = aStream->ReadLong();
	fInitialMax = aStream->ReadLong();

//	CreateCMgrControl(gEmptyString);
}

//----------------------------------------------------------------------------------------
// TScrollBar::WriteFields:
//----------------------------------------------------------------------------------------

void TScrollBar::WriteFields(CStream_AC* aStream) const
{
	TCtlMgr::WriteFields(aStream);

	aStream->WriteByte(fDirection);

	aStream->WriteLong(GetValue());
	aStream->WriteLong((const_cast<TScrollBar*> (this))->GetMinimum());
	aStream->WriteLong((const_cast<TScrollBar*> (this))->GetMaximum());
}

//----------------------------------------------------------------------------------------
// TScrollBar::DoPostCreate:
//----------------------------------------------------------------------------------------

void TScrollBar::DoPostCreate(TDocument* itsDocument)
// DoPostCreate is used to set the Windows-related control style.
//
// itsDocument:		A TDocument* which points to the document into which this control
//					is being installed.
//
// Override:		As needed.
// Call:			Only as the inherited DoPostCreate when implementing a custom
//					class deriving from TScrollBar and which has its own DoPostCreate.
{
	TCtlMgr::DoPostCreate(itsDocument);

#if qMSWindows
	SetWindowsWindowStyle(WS_CHILD | (fDirection == hSel ? SBS_HORZ : SBS_VERT));
#endif
}

//----------------------------------------------------------------------------------------
// TScrollBar::ActionProc:
//----------------------------------------------------------------------------------------

void TScrollBar::DoControlAction(ControlPartCode partCode)
{
	if (partCode)
	{
		CTempGrafPort_AC savePort;
		CSaveClipRegion_AC saveClip;

		TrackScrollBar(partCode);

		HandleEvent(fEventNumber, this, NULL);

#if 0
		Update();							// Make sure that we're in synch before
											// returning
#endif
		Focus();							// make sure i am looking at myself… e.e. cummings

#if qDebugMsg
		static bool pDebugPortChanges;
		if (pDebugPortChanges)
		{
			if (savePort != GetGrafPtr_AC())
				ProgramReport_AC("port changed: was %08x, now %08x", savePort, GetGrafPtr_AC());

			if (saveClip != GetPortClipTempRegion_AC(savePort))
				ProgramReport_AC("clip changed: was %s, now %s",
								 GetRegionBounds_AC(saveClip).AsText().c_str(),
								 GetClipRegionBounds_AC(savePort).AsText().c_str());
		}
#endif
	}
}

//----------------------------------------------------------------------------------------
// TScrollBar::DeltaValue:
//----------------------------------------------------------------------------------------

void TScrollBar::DeltaValue(ViewCoordinate delta)
{
	if (delta)				// Ensure that delta does not cause an overflow (or underflow)
		SetValue(GetValue() + MinMax_AC(GetMinimum() - GetValue(),
				 delta,
				 GetMaximum() - GetValue()),
				 IsShown());
}

//----------------------------------------------------------------------------------------
// TScrollBar::DoMouseCommand:
//----------------------------------------------------------------------------------------

void TScrollBar::DoMouseCommand(CViewPoint& theMouse,
								TToolboxEvent* event,
								CPoint_AC hysteresis)
{
	TCtlMgr::DoMouseCommand(theMouse, event, hysteresis);
}

//----------------------------------------------------------------------------------------
// TScrollBar::TrackScrollBar:
//----------------------------------------------------------------------------------------

void TScrollBar::TrackScrollBar(short partCode)
{
	switch (partCode)
	{
		case kControlPageUpPart:
		case kControlUpButtonPart:
			if (GetValue() > GetMinimum())
				DeltaValue(-1);
			break;
		case kControlPageDownPart:
		case kControlDownButtonPart:
			if (GetValue() < GetMaximum())
				DeltaValue(1);
			break;
#if qMSWindows
		case kControlIndicatorPart:
			{
				SCROLLINFO scrollInfo;
				memset(&scrollInfo, 0, sizeof(SCROLLINFO));
				scrollInfo.cbSize = sizeof(SCROLLINFO);
				scrollInfo.fMask = SIF_TRACKPOS;
				::GetScrollInfo(GetWindowsWindow(), SB_CTL, &scrollInfo);

				if (Focus())
					SetValue(scrollInfo.nTrackPos, kRedraw);
			}
			break;
#endif
	}	
}

//----------------------------------------------------------------------------------------
// TScrollBar::DoMakeControl:
//----------------------------------------------------------------------------------------

CControl_AC* TScrollBar::DoMakeControl(WindowRef			theWindow,
									   const CRect_AC&		boundsRect,
									   bool					isVisible,
									   bool					isEnabled,
									   const CStr255_AC&	itsTitle)
{
	#pragma unused (itsTitle)
	return CreateScrollBar_AC(theWindow, boundsRect, isVisible, isEnabled,
				fInitialVal, fInitialMin, fInitialMax,
				0 /* view/page size */,
				true /* prefer live scrolling */, this);
}

#if qMSWindows

//----------------------------------------------------------------------------------------
// TScrollBar::GetMaximum:
//----------------------------------------------------------------------------------------

ViewCoordinate TScrollBar::GetMaximum()
{
	ViewCoordinate result = 0;
	HWND windowsWindow = GetWindowsWindow();
	if (windowsWindow != NULL)
	{
		int itsMin = 0;
		int itsMax = 0;
		::GetScrollRange(windowsWindow, SB_CTL, &itsMin, &itsMax);
		result = itsMax;
	}
	return result;
}

//----------------------------------------------------------------------------------------
// TScrollBar::GetMinimum:
//----------------------------------------------------------------------------------------

ViewCoordinate TScrollBar::GetMinimum()
{
	ViewCoordinate result = 0;
	HWND windowsWindow = GetWindowsWindow();
	if (windowsWindow != NULL)
	{
		int itsMin = 0;
		int itsMax = 0;
		::GetScrollRange(windowsWindow, SB_CTL, &itsMin, &itsMax);
		result = itsMin;
	}
	return result;
}

//----------------------------------------------------------------------------------------
// TScrollBar::GetValue:
//----------------------------------------------------------------------------------------

ViewCoordinate TScrollBar::GetValue() const
{
	ViewCoordinate result = 0;
	HWND windowsWindow = GetWindowsWindow();
	if (windowsWindow != NULL)
		result = ::GetScrollPos(windowsWindow, SB_CTL);
	return result;
}

//----------------------------------------------------------------------------------------
// TScrollBar::SetMaximum:
//----------------------------------------------------------------------------------------

void TScrollBar::SetMaximum(ViewCoordinate itsMax, bool redraw)
{
	HWND windowsWindow = GetWindowsWindow();
	if (windowsWindow != NULL)
	{
		ViewCoordinate itsMin = GetMinimum();
		SCROLLINFO scrollInfo;
		memset(&scrollInfo, 0, sizeof(SCROLLINFO));
		scrollInfo.cbSize = sizeof(SCROLLINFO);
		scrollInfo.fMask = SIF_RANGE;
		scrollInfo.nMin = itsMin;
		scrollInfo.nMax = itsMax;
		::SetScrollInfo(windowsWindow, SB_CTL, &scrollInfo, redraw);
	}
}

//----------------------------------------------------------------------------------------
// TScrollBar::SetMinimum:
//----------------------------------------------------------------------------------------

void TScrollBar::SetMinimum(ViewCoordinate itsMin, bool redraw)
{
	HWND windowsWindow = GetWindowsWindow();
	if (windowsWindow != NULL)
	{
		ViewCoordinate itsMax = GetMaximum();
		SCROLLINFO scrollInfo;
		memset(&scrollInfo, 0, sizeof(SCROLLINFO));
		scrollInfo.cbSize = sizeof(SCROLLINFO);
		scrollInfo.fMask = SIF_RANGE;
		scrollInfo.nMin = itsMin;
		scrollInfo.nMax = itsMax;
		::SetScrollInfo(windowsWindow, SB_CTL, &scrollInfo, redraw);
	}
}

//----------------------------------------------------------------------------------------
// TScrollBar::SetValue:
//----------------------------------------------------------------------------------------

void TScrollBar::SetValue(ViewCoordinate itsVal, bool redraw)
{
	HWND windowsWindow = GetWindowsWindow();
	if (windowsWindow != NULL)
	{
		SCROLLINFO scrollInfo;
		memset(&scrollInfo, 0, sizeof(SCROLLINFO));
		scrollInfo.cbSize = sizeof(SCROLLINFO);
		scrollInfo.fMask = SIF_POS;
		scrollInfo.nPos = itsVal;
		::SetScrollInfo(windowsWindow, SB_CTL, &scrollInfo, redraw);
	}
}

//----------------------------------------------------------------------------------------
// TScrollBar::SetValues:
//----------------------------------------------------------------------------------------

void TScrollBar::SetValues(ViewCoordinate	itsVal,
						   ViewCoordinate	itsMin,
						   ViewCoordinate	itsMax,
						   bool				redraw)
{
	HWND windowsWindow = GetWindowsWindow();
	if (windowsWindow != NULL)
	{
		SCROLLINFO scrollInfo;
		memset(&scrollInfo, 0, sizeof(SCROLLINFO));
		scrollInfo.cbSize = sizeof(SCROLLINFO);
		scrollInfo.fMask = SIF_POS | SIF_RANGE;
		scrollInfo.nPos = itsVal;
		scrollInfo.nMin = itsMin;
		scrollInfo.nMax = itsMax;
		::SetScrollInfo(windowsWindow, SB_CTL, &scrollInfo, redraw);
	}
}

//----------------------------------------------------------------------------------------
// TScrollBar::HandleWindowsEvent:
//----------------------------------------------------------------------------------------

long TScrollBar::HandleWindowsEvent(HWND hwnd, UINT message, WPARAM wParam, LPARAM lParam)
{
	long result = 0;
	switch (message)
	{
    	// let the controls handle drawing and scrolling themselves
		case WM_LBUTTONDOWN:
			result = DefaultWindowProcedure(hwnd, message, wParam, lParam);
			break;

		case WM_HSCROLL:
		case WM_VSCROLL:
			{
	  			int request = LOWORD(wParam);
				if ((request == SB_LINEDOWN) || (request == SB_LINEUP) || (request == SB_PAGEDOWN) || (request == SB_PAGEUP))
				{
					ControlPartCode partCode = 0;
					switch (request)
					{
						case SB_LINELEFT:
							partCode = kControlUpButtonPart;
							break;
						case SB_LINERIGHT:
							partCode = kControlDownButtonPart;
							break;
						case SB_PAGELEFT:
							partCode = kControlPageUpPart;
							break;
						case SB_PAGERIGHT:
							partCode = kControlPageDownPart;
							break;
					}
					DoControlAction(partCode);
				}
				else if (request == SB_THUMBTRACK)
				{
					DoControlAction(kControlIndicatorPart);
				}
			}
			break;

		default:
			result = TCtlMgr::HandleWindowsEvent(hwnd, message, wParam, lParam);
			break;
	}
	return result;
}

//----------------------------------------------------------------------------------------
// TScrollBar::SetWindowsWindow
//----------------------------------------------------------------------------------------

void TScrollBar::SetWindowsWindow(HWND windowsWindow)
{
	TCtlMgr::SetWindowsWindow(windowsWindow);
	SetValues(fInitialVal, fInitialMin, fInitialMax, true);
}
#endif


//========================================================================================
// CLASS TScrollerScrollBar
//========================================================================================

MA_DEFINE_CLASS(TScrollerScrollBar);

//----------------------------------------------------------------------------------------
// TScrollerScrollBar constructor
//----------------------------------------------------------------------------------------

TScrollerScrollBar::TScrollerScrollBar(const CViewPoint&	itsLocation,
									   const CViewPoint&	itsSize,
									   SizeDeterminer		itsHSizeDet,
									   SizeDeterminer		itsVSizeDet,
									   VHSelect				itsDirection,
									   long					itsMax,
									   TScroller*			itsScroller)
	:	TScrollBar(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsDirection, 0, 0, itsMax)
{
	fScrollers.SetAllocationIncrement(1);

	SetCMgrVisibility(IsActive());// •••  (virtual call)

	AttachScroller(itsScroller);// •••  (virtual call)
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar copy constructor
//----------------------------------------------------------------------------------------

TScrollerScrollBar::TScrollerScrollBar(const TScrollerScrollBar& inScrollerScrollBar)
	:	TScrollBar(inScrollerScrollBar),
		fScrollers(inScrollerScrollBar.fScrollers)
{
#if qDebug
	if (inScrollerScrollBar.fScrollers.GetSize() != 1)
		::ProgramBreak_AC("###TScrollerScrollBar copy constructor: Unexpected number of scrollers!");
#endif
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar destructor
//----------------------------------------------------------------------------------------

TScrollerScrollBar::~TScrollerScrollBar()
{
	for (TemplateIterator_AC<TScroller*> iter(&fScrollers); iter; ++iter)
		if ((*iter).fScrollBars[fDirection] == this)
			(*iter).HaveScrollBar(NULL, fDirection);
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TScrollerScrollBar::GetStandardSignature() const
{
	return kStdScrollerScrollBar;
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::ReadFields:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::ReadFields(CStream_AC* aStream)
{
	TScrollBar::ReadFields(aStream);

	// ??? This does nothing, since scrollbars aren't created yet.
	//SetCMgrVisibility(IsActive());
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::WriteFields:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::WriteFields(CStream_AC* aStream) const
{
	TScrollBar::WriteFields(aStream);

}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::Activate:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::Activate(bool entering)
{
	// Don't call CWhileFocused because it restores the old visibility
	//CWhileFocused itsWhileFocused(this, kDontRedraw);

	if (SetCMgrVisibility(entering) != entering)
	{
//		if (!HasPendingUpdate())
//			DrawContents();
//		else
			ForceRedraw(); // DrawContents();
	}
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::AttachScroller:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::AttachScroller(TScroller* itsScroller)
// AttachScroller associates a scroller with a scroll bar. AttachScroller
// adds the scroller to the TScrollerScrollBar object’s list of scrollers and
// then calls the HaveScrollBar method of the scroller specified by itsScroller.
// For example, MacApp calls AttachScroller when creating new TScrollerScrollBar
// objects.
//
// itsScroller:	Specifies the TScroller object that this method associates
// 				with the TScrollerScrollBar object.
//
// Call?		As needed.
// Override?	Seldom.
{
	if (itsScroller)
	{
		// create a fake fIdentifier for TScrollerScrollBar, if needed
		if (fIdentifier == kNoIdentifier)
		{
			IDType tempID = itsScroller->GetIdentifier();
			Ptr hiBytePtr = (Ptr) &tempID;

			if (fDirection == vSel)
				*hiBytePtr = 'v';
			else
				*hiBytePtr = 'h';

			fIdentifier = tempID;
		}

		fScrollers.Insert(itsScroller);
		itsScroller->HaveScrollBar(this, fDirection);

		UpdateScrollAmounts(false);

		// Insure that the scrollbar is always active if in a floater.
		TWindow* myWindow = GetWindow();
		if (myWindow && myWindow->GetFloats())
			fHandlesFirstClicks = true;
	}
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::SetFrame
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::SetFrame(const CViewRect& newFrame, bool invalidate)
{
	TScrollBar::SetFrame(newFrame, invalidate);

	UpdateScrollAmounts();
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::BeInPort:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::BeInPort(GrafPtr itsPort)
{
	TScrollBar::BeInPort(itsPort);

	SetCMgrVisibility(IsActive());
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::UpdateScrollAmounts
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::UpdateScrollAmounts(bool redraw)
{
	// Synchronize the control to reflect the scroller view size.

#if !qMSWindows
	if ((GetControl()) && (fScrollers.GetSize() > 0))
	{
		TScroller*	firstScroller = static_cast<TScroller*>(fScrollers.At(1));
		if (firstScroller != NULL)
		{
			ViewCoordinate	maxTranslation = firstScroller->fMaxTranslation[fDirection];
			ViewCoordinate	viewSize = firstScroller->GetSize()[fDirection];

			CWhileFocused itsWhileFocused(this, kRedraw);

			try
			{
				if (!redraw)
					HidePen();

				GetControl()->SetMinimum(0);
				GetControl()->SetMaximum(maxTranslation);
				GetControl()->SetViewSize(viewSize);
			}
			catch (...)
			{
				if (!redraw)
					ShowPen();
				throw;
			}
			if (!redraw)
				ShowPen();
		}
	}
#else
	#pragma unused (redraw)

	HWND windowsWindow = GetWindowsWindow();
	if ((windowsWindow != NULL) && (fScrollers.GetSize() > 0))
	{
		TScroller*	firstScroller = static_cast<TScroller*>(fScrollers.At(1));
		if (firstScroller != NULL)
		{
			ViewCoordinate	maxTranslation = firstScroller->fMaxTranslation[fDirection];
			ViewCoordinate	viewSize = firstScroller->GetSize()[fDirection];
			ViewCoordinate	singleStepSize = firstScroller->fScrollUnit[fDirection];
			ViewCoordinate	pageSize = maxTranslation * (((float) (Max_AC(0, viewSize - singleStepSize))) / ((float) (viewSize + maxTranslation)));

			SCROLLINFO scrollInfo;
			memset(&scrollInfo, 0, sizeof(SCROLLINFO));
			scrollInfo.cbSize = sizeof(SCROLLINFO);
			scrollInfo.fMask = SIF_PAGE | SIF_RANGE;
			scrollInfo.nMin = 0;
			scrollInfo.nMax = pageSize+maxTranslation;
			scrollInfo.nPage = pageSize+1;
			::SetScrollInfo(windowsWindow, SB_CTL, &scrollInfo, true);
		}
	}
#endif
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::DoMouseCommand:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::DoMouseCommand(CViewPoint&		theMouse,
										TToolboxEvent*	event,
										CPoint_AC		hysteresis)
{
#if !qMSWindows
#if qDebug
	AssumeFocused();
#endif

	CPoint_AC theQDMouse = ViewToQD(theMouse);

	CWhileFocused itsWhileFocused(this, kRedraw);

	Assertion_AC(GetControl(), "TScrollerScrollBar::DoMouseCommand: Could not get control");

	if (GetControl()->TestMouse(theQDMouse) == kControlIndicatorPart) //•••if (TestControl(fCMgrControl, theQDMouse) == kControlIndicatorPart) // Thumb
	{
		if (GetControl()->TrackMouse(theQDMouse, event->GetModifiers()) == kControlIndicatorPart) //•••if (TrackControl(fCMgrControl, theQDMouse, NULL) == kControlIndicatorPart)
		{
			// If thumb is dragged to bottom of scroll bar then ensure that
			// the new long value is set to the maximum long value.

			// ••• we no longer have to worry about this.
			//fLongVal = GetVal() == GetMax() ? fLongMax : GetVal() << fBitsToShift;

			long sBarDelta = 0;
			for (TemplateIterator_AC<TScroller*> iter(&fScrollers); iter; ++iter)
				sBarDelta += (*iter).ScrollRelative(fDirection, GetValue());

			if (Focus() && sBarDelta)
				SetValue(GetValue() + sBarDelta, kRedraw);
		}
	}
	else
#endif
		TScrollBar::DoMouseCommand(theMouse, event, hysteresis);
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::Draw:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::Draw(const CViewRect& area)
{
#if qDebug
	AssumeFocused();
#endif

	if (GetControl() && !IsCMgrVisible())
	{

		//CRGBColor_AC savedBkColor(GetIfBkColor());
		// SetIfBkColor(gRGBWhite);// •••  use Finder colors, which seem to be r1 and r10.

		CWhileFocused itsWhileFocused(this, kRedraw);
		CRect_AC itsRect(GetControl()->GetBounds()); //•••CRect_AC itsRect((*fCMgrControl)->contrlRect);

		// •••  04/04/98 One Step Further: use current fore/background color
		// so we get the right color for the right theme.
		//PenNormal();
		//CTempForeColor_AC foreColor(kRGBColorRamp[r10]);
		//CTempBackColor_AC backColor(kRGBColorRamp[r1]);

		::EraseRect(itsRect);
		::MacFrameRect(itsRect);
		//SetIfBkColor(savedBkColor);
	}

	TScrollBar::Draw(area);
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::TrackScrollBar:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::TrackScrollBar(short partCode)
{
	switch (partCode)
	{
		case kControlPageUpPart:
		case kControlUpButtonPart:
		case kControlPageDownPart:
		case kControlDownButtonPart:
			{
				long sBarDelta = 0;

				for (TemplateIterator_AC<TScroller*> iter(&fScrollers); iter; ++iter)
					sBarDelta += (*iter).ScrollStep(fDirection, partCode);

				if (Focus())
					DeltaValue(sBarDelta);
			}
			break;

		case kControlIndicatorPart:
			{
				for (TemplateIterator_AC<TScroller*> iter(&fScrollers); iter; ++iter)
				{
					(*iter).ScrollRelative(fDirection, GetValue());
#if 0
					(*iter).Update();
#endif
				}
			}
			break;
	}
}

#if qMSWindows

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::HandleWindowsEvent:
//----------------------------------------------------------------------------------------

long TScrollerScrollBar::HandleWindowsEvent(HWND hwnd, UINT message, WPARAM wParam, LPARAM lParam)
{
	long result = 0;
	switch (message)
	{
		case WM_HSCROLL:
		case WM_VSCROLL:
			if (LOWORD(wParam) == SB_THUMBTRACK)
			{
				SCROLLINFO scrollInfo;
				memset(&scrollInfo, 0, sizeof(SCROLLINFO));
				scrollInfo.cbSize = sizeof(SCROLLINFO);
				scrollInfo.fMask = SIF_TRACKPOS;
				::GetScrollInfo(hwnd, SB_CTL, &scrollInfo);

				//inThumb
				long sBarDelta = 0;
				for (TemplateIterator_AC<TScroller*> iter(&fScrollers); iter; ++iter)
					sBarDelta += (*iter).ScrollRelative(fDirection, scrollInfo.nTrackPos);

				if (Focus() && sBarDelta)
					SetValue(scrollInfo.nTrackPos + sBarDelta, kRedraw);
			}
			else
				TScrollBar::HandleWindowsEvent(hwnd, message, wParam, lParam);
			break;

		default:
			result = TScrollBar::HandleWindowsEvent(hwnd, message, wParam, lParam);
			break;
	}
	return result;
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBar::CreateWindowsWindow:
//----------------------------------------------------------------------------------------

void TScrollerScrollBar::CreateWindowsWindow()
{
	TScrollBar::CreateWindowsWindow();
	UpdateScrollAmounts();
}

#endif

//----------------------------------------------------------------------------------------
// End of UControl.cpp