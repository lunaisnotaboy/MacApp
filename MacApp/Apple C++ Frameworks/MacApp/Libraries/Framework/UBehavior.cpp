//----------------------------------------------------------------------------------------
// UBehavior.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/11/00	Fixed inconsistency in how NextIdle and HandleIdle treated
					fLastIdle, which gave a sleep time of 0 for large values of 
					fIdleFreq. Now SetIdleFreq sets fLastIdle to now, and NextIdle
					always returns fLastIdle + fIdleFreq. 
		11/10/00	Cosmetic.
		11/09/00	[PB] Change initialization order to match declaration. 
					Fix comparison between signed and unsigned. 
		09/06/00	Added embedded documentation.
		08/31/00	Use MStreamable_AC instead of MStreamable.  Removed
					Inherited and other cosmetic.
		03/24/99	Update copyright notice.
*/

#ifndef __UBEHAVIOR__
#include "UBehavior.h"
#endif

// MacApp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UEVENTHANDLER__
#include "UEventHandler.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

//========================================================================================
// CLASS TBehavior
//========================================================================================

MA_DEFINE_CLASS(TBehavior);

//----------------------------------------------------------------------------------------
// TBehavior constructor
//----------------------------------------------------------------------------------------

TBehavior::TBehavior(IDType itsIdentifier)
	:	fPreviousBehavior(NULL),
		fOwner(NULL),
		fIdentifier(itsIdentifier),
		fIdleFreq(kMaxIdleTime),	// Assume it never wants idle time 
		fLastIdle(0),
		fEnabled(true),
		fIsOwnerSelected(false)
{
}

//----------------------------------------------------------------------------------------
// TBehavior copy constructor
//----------------------------------------------------------------------------------------

TBehavior::TBehavior(const TBehavior& inBehavior)
	:	MStreamable_AC(inBehavior),
		fPreviousBehavior(NULL),
		fOwner(NULL),
		fIdentifier(inBehavior.fIdentifier),
		fIdleFreq(inBehavior.fIdleFreq),
		fLastIdle(inBehavior.fLastIdle),
		fEnabled(inBehavior.fEnabled),
		fIsOwnerSelected(inBehavior.fIsOwnerSelected)
{
}

//----------------------------------------------------------------------------------------
// TBehavior::Free:
//----------------------------------------------------------------------------------------

TBehavior::~TBehavior()
{
}

//----------------------------------------------------------------------------------------
// TBehavior::ReadFrom:
//----------------------------------------------------------------------------------------

void TBehavior::ReadFrom(CStream_AC* aStream)
{
	MStreamable_AC::ReadFrom(aStream);

	fIdentifier = aStream->ReadIDType();
	fEnabled = aStream->ReadBoolean();
	fIdleFreq = aStream->ReadLong();
}

//----------------------------------------------------------------------------------------
// TBehavior::WriteTo:
//----------------------------------------------------------------------------------------

void TBehavior::WriteTo(CStream_AC* aStream) const
{
	MStreamable_AC::WriteTo(aStream);

	aStream->WriteIDType(fIdentifier);
	aStream->WriteBoolean(fEnabled);
	aStream->WriteLong(fIdleFreq);
}

//----------------------------------------------------------------------------------------
// TBehavior::AppendBehavior:
//----------------------------------------------------------------------------------------

void TBehavior::AppendBehavior(TBehavior* aBehavior)
// AppendBehavior appends the specified behavior to the list of behaviors 
// that includes this one.
//
// aBehavior:	Specifies the behavior to be appended.
//
// Call?		Seldom. Call your event handlerÕs AddBehavior instead.
// Override?	NEVER. It is not virtual.
{
	if (aBehavior)
	{
		if (fNextBehavior)
			fNextBehavior->AppendBehavior(aBehavior);
		else
		{
			SetNextBehavior(aBehavior);
			aBehavior->SetPreviousBehavior(this);
		}
	}
}

//----------------------------------------------------------------------------------------
// TBehavior::SetOwner:
//----------------------------------------------------------------------------------------

void TBehavior::SetOwner(TEventHandler* itsOwner)
{
	fOwner = itsOwner;
}

//----------------------------------------------------------------------------------------
// TBehavior::SelectOwner:
//----------------------------------------------------------------------------------------

void TBehavior::SelectOwner(bool select)
{
	fIsOwnerSelected = select;
}

//----------------------------------------------------------------------------------------
// TBehavior::SetEnabled:
//----------------------------------------------------------------------------------------

void TBehavior::SetEnabled(bool enabled)
{
	fEnabled = enabled;
}

//----------------------------------------------------------------------------------------
// TBehavior::GetNextEnabledBehavior:
//----------------------------------------------------------------------------------------

TBehavior* TBehavior::GetNextEnabledBehavior() const
{
	TBehavior* returnVal = NULL;

	for (TBehavior* test = GetNextBehavior(); test; test = test->GetNextBehavior())
		if (test->IsEnabled())
		{
			returnVal = test;
			break;
		}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TBehavior::InsertBefore:
//----------------------------------------------------------------------------------------

void TBehavior::InsertBefore(TBehavior* insertMe,
							 TBehavior* before)
{
	if (insertMe)
	{
		// We are one that insertion is going to be before
		if (this == before)
		{
			if (fPreviousBehavior)
				fPreviousBehavior->SetNextBehavior(insertMe);

			insertMe->SetPreviousBehavior(fPreviousBehavior);
			insertMe->SetNextBehavior(this);

			SetPreviousBehavior(insertMe);
		}
		else if (fNextBehavior)				// Pass message on down chain
			fNextBehavior->InsertBefore(insertMe, before);
	}
}

//----------------------------------------------------------------------------------------
// TBehavior::InsertAfter:
//----------------------------------------------------------------------------------------

void TBehavior::InsertAfter(TBehavior* insertMe,
							TBehavior* after)
{
	if (insertMe)
	{
		// We are one that insertion is going to be after
		if (this == after)
		{
			TBehavior * nextBehavior = GetNextBehavior();

			insertMe->SetPreviousBehavior(this);
			insertMe->SetNextBehavior(nextBehavior);

			if (nextBehavior)
				nextBehavior->SetPreviousBehavior(insertMe);

			SetNextBehavior(insertMe);
		}
		else if (fNextBehavior)				// Pass message on down chain
			fNextBehavior->InsertAfter(insertMe, after);
	}
}

//----------------------------------------------------------------------------------------
// TBehavior::RemoveBehavior:
//----------------------------------------------------------------------------------------

void TBehavior::RemoveBehavior(TBehavior* removeMe)
{
	// We are the one being removed
	if (this == removeMe)
	{
		TBehavior * itsNextBehavior = GetNextBehavior();

		if (fPreviousBehavior)
			fPreviousBehavior->SetNextBehavior(itsNextBehavior);

		if (itsNextBehavior)
			itsNextBehavior->SetPreviousBehavior(fPreviousBehavior);

		// remove it from the linked list
		SetNextBehavior(NULL);
		SetPreviousBehavior(NULL);
		SetOwner(NULL);
	}
	else if (fNextBehavior) 					// Pass message on down chain as we aren't one to be removed
			fNextBehavior->RemoveBehavior(removeMe);
}

//----------------------------------------------------------------------------------------
// TBehavior::DoCommandKeyEvent:
//----------------------------------------------------------------------------------------

void TBehavior::DoCommandKeyEvent(TToolboxEvent* event)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	if (nextBehavior)
		nextBehavior->DoCommandKeyEvent(event);
	else if (fOwner)
		fOwner->DoCommandKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TBehavior::DoEvent:
//----------------------------------------------------------------------------------------

void TBehavior::DoEvent(EventNumber eventNumber,
						TEventHandler* source,
						TEvent* event)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	if (nextBehavior)
		nextBehavior->DoEvent(eventNumber, source, event);
	else if (fOwner)
		fOwner->DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TBehavior::DoKeyEvent:
//----------------------------------------------------------------------------------------

void TBehavior::DoKeyEvent(TToolboxEvent* event)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	if (nextBehavior)
		nextBehavior->DoKeyEvent(event);
	else if (fOwner)
		fOwner->DoKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TBehavior::DoKeyUp:
//----------------------------------------------------------------------------------------

void TBehavior::DoKeyUp(TToolboxEvent* event)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	if (nextBehavior)
		nextBehavior->DoKeyUp(event);
	else if (fOwner)
		fOwner->DoKeyUp(event);
}

//----------------------------------------------------------------------------------------
// TBehavior::DoMenuCommand:
//----------------------------------------------------------------------------------------

void TBehavior::DoMenuCommand(CommandNumber aCommandNumber)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	if (nextBehavior)
		nextBehavior->DoMenuCommand(aCommandNumber);
	else if (fOwner)
		fOwner->DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// TBehavior::DoScriptCommand:
//----------------------------------------------------------------------------------------

bool TBehavior::DoScriptCommand(CommandNumber	aCommandNumber,
								TAppleEvent*	message,
								TAppleEvent*	reply)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	return nextBehavior ? nextBehavior->DoScriptCommand(aCommandNumber, message, reply) : false;
}

//----------------------------------------------------------------------------------------
// TBehavior::DoSetupMenus:
//----------------------------------------------------------------------------------------

void TBehavior::DoSetupMenus()
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	if (nextBehavior)
		nextBehavior->DoSetupMenus();
	else if (fOwner)
		fOwner->DoSetupMenus();
}

//----------------------------------------------------------------------------------------
// TBehavior::NextIdle:
//----------------------------------------------------------------------------------------

unsigned long TBehavior::NextIdle()
// NextIdle computes the next time, in ticks, when the behavior would like to have
// its DoIdle method called. 
//
// return:		Next time to idle. kMaxIdleTime means never. 
//
// Call?		Unlikely. TEventHandler::NextIdle calls each of its behavior's
//				NextIdle method. 
{
	unsigned long returnVal = kMaxIdleTime;

	if (fIdleFreq != kMaxIdleTime && IsEnabled())	// Does it idle at all? 
		returnVal = fLastIdle + fIdleFreq;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TBehavior::HandleIdle:
//----------------------------------------------------------------------------------------

void TBehavior::HandleIdle(IdlePhase phase)
// HandleIdle passes control from one behavior to the next, and ensures that the DoIdle 
// methods are called only at the idle frequency or slower. 
//
// phase:		The IdlePhase. idleContinue means this is a true idle. idleBegin and
//				idleEnd are notifications that before and after idling. 
//
// Call?		Unlikely. The dispatcher and TEventHandler call HandleIdle for you. 
//				Use SetIdleFreq to control when idling happens. 
{
	// Do first, because 'this' may be freed by DoIdle
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	// Does it idle at all? 
	// idleBegin and idleEnd don't respect fIdleFreq because they are
	// notifications that the application is beginning/ending idle.
	// idleContinues, however, are parceled out at the fIdleFreq.

	if ((IsEnabled() && fIdleFreq != kMaxIdleTime) &&
		(phase != idleContinue || (static_cast<long>(TickCount() - fLastIdle) >= fIdleFreq)))
	{
		// ALSO: don't store the fLastIdle if I freed myself or
		// the idlePhase is not idleContinue
		if (!DoIdle(phase) && phase == idleContinue)
			fLastIdle = TickCount();
	}

	if (nextBehavior)
		nextBehavior->HandleIdle(phase);
}

//----------------------------------------------------------------------------------------
// TBehavior::DoIdle:
//----------------------------------------------------------------------------------------

bool TBehavior::DoIdle(IdlePhase phase)
// DoIdle is an empty method that you can override to do things at idle time. 
//
// phase:		The IdlePhase. idleContinue means this is a true idle. idleBegin and
//				idleEnd are notifications that before and after idling. Generally
//				your DoIdle method should do nothing if the phase is not idleContinue. 
// return:		A boolean value that used to indicate whether the behavior deleted
//				itself during idle processing. Your DoIdle method should always 
//				return false (and should never delete itself). 
//
// Call?		Unlikely. Call SetIdleFreq to control when idling happens. 
// Override?	As needed. 
{
#pragma unused (phase)
	return false;								// Did not free myself 
}

//----------------------------------------------------------------------------------------
// TBehavior::SetIdleFreq:
//----------------------------------------------------------------------------------------

void TBehavior::SetIdleFreq(long newIdleFreq)
// SetIdleFreq sets the idle frequency for the behavior. Technically, it sets the idle 
// duration, the time in ticks between idles, which is the inverse of the frequency. 
// It also updates the last idle time so the next idle will be at least newIdleFreq 
// ticks from now. 
//
// newIdleFreq:		The new idle frequency for the behavior. 
//
// Call?			Whenever you feel like it. 
// Override?		Seldom. 
{
#if qDebugMsg && 0
	// Enable this code to get warnings about objects that may be idling too fast. 
	// An idle frequency of 0 is okay if the object is going to idle only once, but
	// if it is going to idle repeatedly, the idle frequency should be at least 1. 
	if ((fIdleFreq != newIdleFreq) && (newIdleFreq == 0))
		ProgramReport_AC("SetIdleFreq(%d) for behavior '%.4s'", newIdleFreq, (char*)&fIdentifier);
#endif

	// Set the idle frequency. 
	fIdleFreq = newIdleFreq;
	
	// The next idle will occur fIdleFreq ticks from now. 
	fLastIdle = TickCount();
}

//----------------------------------------------------------------------------------------
// TBehavior::DoMouseCommand:
//----------------------------------------------------------------------------------------

bool TBehavior::DoMouseCommand(CViewPoint& theMouse, TToolboxEvent* event, CPoint_AC hysteresis)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	return nextBehavior ? nextBehavior->DoMouseCommand(theMouse, event, hysteresis) : false;
}

//----------------------------------------------------------------------------------------
// TBehavior::DoMouseUp:
//----------------------------------------------------------------------------------------

bool TBehavior::DoMouseUp(CViewPoint& theMouse, TToolboxEvent* event, CPoint_AC hysteresis)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	return nextBehavior ? nextBehavior->DoMouseUp(theMouse, event, hysteresis) : false;
}

//----------------------------------------------------------------------------------------
// TBehavior::Draw:
//----------------------------------------------------------------------------------------

void TBehavior::Draw(const CViewRect& area)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	if (nextBehavior)
		nextBehavior->Draw(area);
}

//----------------------------------------------------------------------------------------
// TBehavior::DoSetCursor:
//----------------------------------------------------------------------------------------

bool TBehavior::DoSetCursor(const CViewPoint& localPoint, RgnHandle cursorRegion)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	return nextBehavior ? nextBehavior->DoSetCursor(localPoint, cursorRegion) : false;
}

//----------------------------------------------------------------------------------------
// TBehavior::DoUnsetCursor:
//----------------------------------------------------------------------------------------

bool TBehavior::DoUnsetCursor()
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	return nextBehavior ? nextBehavior->DoUnsetCursor() : false;
}

//----------------------------------------------------------------------------------------
// TBehavior::DoToolboxEvent:
//----------------------------------------------------------------------------------------

bool TBehavior::DoToolboxEvent(TToolboxEvent* event)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	return nextBehavior ? nextBehavior->DoToolboxEvent(event) : false;
}

//----------------------------------------------------------------------------------------
// TBehavior::DoPostCreate:
//----------------------------------------------------------------------------------------

void TBehavior::DoPostCreate(TDocument* itsDocument)
{
	TBehavior * nextBehavior = GetNextEnabledBehavior();

	if (nextBehavior)
		nextBehavior->DoPostCreate(itsDocument);
}

//========================================================================================
// CLASS CBehaviorIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CBehaviorIterator::CBehaviorIterator.
//----------------------------------------------------------------------------------------

CBehaviorIterator::CBehaviorIterator(const TEventHandler* itsEventHandler)
	:	fCurrent(NULL),
		fFirstBehavior(NULL),
		fNextBehavior(NULL)
// CBehaviorIterator is a constructor that initializes an instance for iteration 
// over TBehavior objects.
//
// itsEventHandler:	specifies the TEventHandler object over whose behaviors 
// 					you want to iterate.
//
// Call?		As needed. You typically define an instance with 
//				these parameters when you want to specify the boundary for iteration over objects in the list. If you subclass CBehaviorIterator, you must invoke this constructor from the subclass constructor.
// Override?	NEVER. It is a constructor.
{
	if (itsEventHandler)
		fFirstBehavior = itsEventHandler->GetFirstBehavior();

	First();
}

//----------------------------------------------------------------------------------------
// CBehaviorIterator::First:
//----------------------------------------------------------------------------------------

TBehavior* CBehaviorIterator::First()
{
	fCurrent = fFirstBehavior;
	if (fFirstBehavior)
		fNextBehavior = fFirstBehavior->GetNextBehavior();
	
	return fCurrent;
}

//----------------------------------------------------------------------------------------
// CBehaviorIterator::Next:
//----------------------------------------------------------------------------------------

TBehavior* CBehaviorIterator::Next()
{
	if (fCurrent)
	{
		fCurrent = fNextBehavior;
		if (fCurrent)
			fNextBehavior = fCurrent->GetNextBehavior();
	}
	
	return fCurrent;
}

//----------------------------------------------------------------------------------------
// End of UBehavior.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/12/96	Removed "DoBehaviorUpdate" which was wrapped in pound-if 0.
		06/09/96	Removed UStreamable to a separate file from UObject
		04/24/96	Removed TBehavior::DoBehaviorUpdate.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Update iterators to be OD stylish
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		 3/31/96	Made some judicious inlining for CBehaviourIterator
		 3/25/96	Made TBehavior::IsEnabled/GetNextBehavior/GetNextEnabledBehavior non virtual.
		 3/07/96	Removed more gratuitous inlining.
		 3/01/96	Re-arranged data members, natural alignment results in 
		 					reduced storage size.
		 12/8/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		----- 3.3b1 -----
		 6/28/95	Reorder DoScriptCommand params.
		  6/2/95	Add TCommandHandler::HandleDoItAppleEvent, fgTransactionIDCount
							TCommandHandler::DoPerformCommand supports performing as apple event
							Command aevt's are assigned transaction IDs
							Remove MScriptableObject* param from Behavior::DoScriptCommand
		 3/13/95	Change Free methods to destructors. 
		 9/30/94	Add TBehavior::DoScriptCommand. TBehavior does not
							descend mix with MScriptableObject.  This new method
							is intended to allow behaviors to handle events targeted
							at MScriptableObjects. This method will be necessary
							to support AdLib 2.0's THandlerBehavior's appleevent
							handling.
		 9/14/94	Remove TBehavior::DoAppleCommand. AEOM support
							makes it obsolete.
		  9/9/94	Added TBehavior::DoPostCreate per Eric Hanig.
		 7/13/94	Fix InsertBefore and InsertAfter to update the backward
							links as well as the forward ones. 
*/