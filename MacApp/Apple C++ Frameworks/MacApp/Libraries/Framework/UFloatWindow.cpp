//----------------------------------------------------------------------------------------
// UFloatWindow.cpp
// Copyright © 1987-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		06/06/01	Eliminated Inherited.
		01/02/01	Update copyright.
		07/31/00	[W] Added DoPostCreate.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
		03/19/99	Include ClassRegistration_AC.h.
*/

#ifndef __UFLOATWINDOW__
#include "UFloatWindow.h"
#endif

// ACS

#ifndef __ClassRegistration_AC__
#include "ClassRegistration_AC.h"
#endif

#ifndef __CPoint_AC__
#include "CPoint_AC.h"
#endif

#ifndef __CRect_AC__
#include "CRect_AC.h"
#endif

// MacApp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

// Toolbox

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

//----------------------------------------------------------------------------------------

bool gUFloatWindowInitialized;		// declared in header

//----------------------------------------------------------------------------------------

//========================================================================================
// CLASS TFloatWindow
//========================================================================================

MA_DEFINE_CLASS(TFloatWindow);

//----------------------------------------------------------------------------------------
// TFloatWindow constructor
//----------------------------------------------------------------------------------------


TFloatWindow::TFloatWindow(WindowRef itsWMgrWindow,
						   bool canResize, bool canClose, bool inDispose)
	:	TWindow(itsWMgrWindow, canResize, canClose, inDispose)
{
	// Override default value for fResizeLimits
	fResizeLimits[topLeft].Set(1, 1);
	
	fHideOnSuspend = true;
	fDoFirstClick = true;
	fFloats = true;
	fGenerateActivates = false;
#if qAppleEventAware
	fOMClassID = cPalette;			// Establish AEOM class ID
#endif

	if (fWMgrWindow)
		SetWindowKind(fWMgrWindow, kFloatingWindowKind);	// Mark it as a floating window 
}

//----------------------------------------------------------------------------------------
// TFloatWindow destructor
//----------------------------------------------------------------------------------------

TFloatWindow::~TFloatWindow()
{
}

//----------------------------------------------------------------------------------------
// TFloatWindow::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TFloatWindow::GetStandardSignature() const
{
	return kStdFloatWindow;
}

//----------------------------------------------------------------------------------------
// TFloatWindow::ReadFields: 
//----------------------------------------------------------------------------------------

void TFloatWindow::ReadFields(CStream_AC* aStream)
{
	TWindow::ReadFields(aStream);

	SetWindowKind(fWMgrWindow, kFloatingWindowKind);// mark it as a floating window 
}

//----------------------------------------------------------------------------------------
// TFloatWindow::DoPostCreate:
//----------------------------------------------------------------------------------------

void TFloatWindow::DoPostCreate(TDocument* itsDocument)
// DoPostCreate is used to set the Windows-related window kind.
//
// itsDocument:		A TDocument* which points to the document into which this control
//					is being installed.
//
// Override:		As needed.
// Call:			Only as the inherited DoPostCreate when implementing a custom
//					class deriving from TFloatWindow and which has its own DoPostCreate.
{
	TWindow::DoPostCreate(itsDocument);

#if qMSWindows
	SetWindowKind(fWMgrWindow, kFloatingWindowKind);	// Mark it as a floating window 
#endif
}

//----------------------------------------------------------------------------------------
// TFloatWindow::GetBehindWindowPtr: 
//----------------------------------------------------------------------------------------

WindowRef TFloatWindow::GetBehindWindowPtr() const

{
	// bring the float window up in front of all other windows
	return (WindowRef) - 1;						
}

//----------------------------------------------------------------------------------------
// TFloatWindow::Close: 
//----------------------------------------------------------------------------------------

void TFloatWindow::Close()

{
	TWindow::Close();
	
	TEventHandler* activeTarget = NULL;
	
	TWindow* activeWindow = gDispatcher->GetActiveWindow(!kFloatersOK);
	
	// Non-floater is always targettable.
	if (activeWindow)
		activeTarget = activeWindow->GetWindowTarget();
	
	if (activeTarget)
	{
		SetTarget(activeTarget);
		activeTarget->SetTargetSelection(kRedraw);
	}
	else
		SetTarget(gDispatcher);
}

//----------------------------------------------------------------------------------------
// TFloatWindow::DoSetupMenus: 
//----------------------------------------------------------------------------------------

void TFloatWindow::DoSetupMenus()
{
		TWindow::DoSetupMenus();
		Enable(cClose, false);		// Floaters cannot be closed via cmd-W! 
}

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUFloatWindow:
//----------------------------------------------------------------------------------------

void InitUFloatWindow()
{
	if (!gUFloatWindowInitialized)
	{
#if qTemplateViews
		REGISTER_SIGNATURE_AC(TFloatWindow, kStdFloatWindow);
#endif

		gUFloatWindowInitialized = true;
	}
}

//----------------------------------------------------------------------------------------
// End of UFloatWindow.cp



/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		05/25/96	[1353199] Potential memory leak when disposing windows.
		 4/26/96	Made C/CCoordPoint_AC/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CCoordPoint_AC/Rects.
		----- R10 -----
		02/22/96	Correct the assignment of the target when a floater is closed.
							This fixes 1326033 and 1326034.
		 12/8/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		----- 3.3b1 -----
		 6/18/95	Remove gStandardWindowMoveBounds, gStandardWindowSizeRect and
		 					gStandardWindowScreenRect. Change usage of fMoveBounds and fResizeLimits
							to be used only if non-zero. Otherwise, values are dynamically calculated
							in the new functions: GetDynamicMoveBounds and GetDynamicResizeLimits.
							This is because monitor location, resolution and size is now dynamic since
							System 7.5.
		 5/17/95	More WindowRef. 
		 5/16/95	WindowRef
		  4/5/95	Constructor sets fOMClassID to cPalette.
		 3/13/95	Change Free methods to destructors. 
		 2/28/95	Use MA_REGISTER_SIGNATURE instead of macroDontDeadStrip
							and RegisterStdType. 
		02/13/95	Remove unnecessary initialization of static variables. See ARM ¤8.4 
		 7/20/94	Change TFloatWindow::Close to make the active document
							window the target, rather than the next active window,
							which could be a floater that doesn't want to be the
							target. (Suggested by Oddur Sigurdsson). 
*/