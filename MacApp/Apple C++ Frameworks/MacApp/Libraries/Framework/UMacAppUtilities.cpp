//----------------------------------------------------------------------------------------
// UMacAppUtilities.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		05/02/01	In GetFontNum, don't need to convert string constants to
					objects just to compare them. 
		03/01/01	Don't include Windows_AC, Memory_AC. 
		01/02/01	Update copyright.
		11/13/00	[PB] sizeof is unsigned. 
		11/10/00	Cosmetic.  gBoolString[1] had a bad ÔpÕ.
		11/09/00	Remove unused functions CheckAdornment and CheckStyleItem. 
					Separate the call to EventAvail in ShowGlobalRegion from the
					rest of the code, to eliminate an unused variable warning. 
		11/03/00	[C] DonÕt include Packages.h or Traps.h.
		11/01/00	[PB] Include MacErrors instead of Errors.
		10/16/00	[W] Alter style setting in MAGetTextStyle.
		09/20/00	Changed initialization of gBoolString.
		09/07/00	Added embedded documentation.
		09/01/00	Changed pragma warning to pragma message.  Don't include string.h.
					Add pragma unused's.  Removed StdNoRect -- no implementation!
					Removed CenterRectOnScreen unused code.  Simplified
					MACharacterByteType and MACharacterByte.  Use reinterpret_cast.
		07/31/00	Changed screen size calculation in CenterRectOnScreen.
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Include CMultiLocal.h.
					Use CMultiLocale_AC::SetKeyScriptCode instead of KeyScript.
		05/23/00	[2279264] Remove false from ProgramReport_AC.
		03/31/00	Include CHandle_AC.h. Test against qCoreDebug, not qDebug, in
					DisposeIfPicHandle and DisposeIfSectionHandle.
		01/13/00	Conditionalize eventRecord declaration in ShowGlobalRegion.
					Conditionalize declaration of theEvent in PullApplicationToFront.
		12/08/99	Remove extraneous line in change history.  Changed
					method of initializing gBoolString.
		11/04/99	CStringListRsrc_AC::GetString: CopyFrom needs a length.
		07/23/99	[C] Cannot acces qd directly in CenterRectOnScreen.  Do not
					set script in MACharacterByteType and MACharacterType.
		03/24/99	Update copyright notice.
		03/23/99	Go back to native Toolbox region calls.  Do not directly access
					desktoptop region.
		01/19/98	[W] Don't define DisposeIfSectionHandle.
		11/05/98	Carbon - use GetQDGlobalsScreenBits() instead of qd.screenBits;
					Fixed merge error in ShowGlobalRegion w/CopyRgn_AC
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					UnionRgn_AC, CopyRgn_AC, PaintRgn_AC, SetPort_AC,CopyRgn_AC.
					Include ImagingUtils_AC.h.
		10/26/98	Carbonize
*/

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

// MacApp

#ifndef __MACAPPVERSION__
#include "MacAppVersion.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UNIVERSALSTARTUP__
#include "UniversalStartup.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// Toolbox

#if qPowerPC || qModelCFM
	#ifndef __CODEFRAGMENTS__
	#include <CodeFragments.h>
	#endif
#endif

#ifndef __DEVICES__
#include <Devices.h>
#endif

#ifndef __DIALOGS__
#include <Dialogs.h>
#endif

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif

#ifndef __MACWINDOWS__
#include <MacWindows.h>
#endif

#ifndef __MENUS__
#include <Menus.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __SCRAP__
#include <Scrap.h>
#endif

#ifndef __SCRIPT__
#include <Script.h>
#endif

#ifndef __TEXTUTILS__
#include <TextUtils.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

#if !qCarbon
	#ifndef __PACKAGES__
	#include <Packages.h>
	#endif

	#ifndef __TRAPS__
	#include <Traps.h>
	#endif
#endif

enum
{
	kCapsLockKey = 57,
	kCommandKey = 55,
	kCtlKey = 0x3B,
	kOptionKey = 58,
	kShiftKey = 56
};

//----------------------------------------------------------------------------------------
// extern definitions:

extern WindowRef gWorkPort;

// constants

#if qOldConfigurationFlags
Configuration gConfiguration;
#endif

#if qDebugMsg
// Non-POD array cannot be initialized this way.
// const CStr15_AC gBoolString[2] = { "false", "true"};
const unsigned char* gBoolString[2] = { (const unsigned char*)"\005false",
										(const unsigned char*)"\004true" };
#endif

bool gUGridViewInitialized;

const VHSelect gOrthogonal[2] = { hSel, vSel};

const CPoint_AC kBestSystemLocation(-1, -1);

//========================================================================================
// CLASS CStringListRsrc_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CStringListRsrc_AC::GetString:
//----------------------------------------------------------------------------------------

void CStringListRsrc_AC::GetString(short index, CStr255_AC& theString) const
{
	theString.CopyFrom(fStrListID, index, CStr255_AC::kMaxLength);
}

//----------------------------------------------------------------------------------------
// CStringListRsrc_AC::FindString:
//----------------------------------------------------------------------------------------

short CStringListRsrc_AC::FindString(const CStr255_AC& theString, bool addString)
{
	short returnVal = kNoResource;

	short numStrings = CountStrings();

	for (short i = 1; i <= numStrings; ++i)
	{
		CStr255_AC testString;
		GetString(i, testString);

		if (testString == theString)
		{
			returnVal = i;							// found it! return the index
			break;
		}
	}

	// CPascalStr_AC is not found, should we add it?
	if (returnVal == kNoResource && addString == kAddString)
		returnVal = AppendString(theString);	// added it! return the index

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CStringListRsrc_AC::AppendString:
//----------------------------------------------------------------------------------------

short CStringListRsrc_AC::AppendString(const CStr255_AC& theString)
// AppendString appends the specified string to the current 'STR#' resource
// and returns the index to the string.
//
// theString:	Specifies the string to be appended to the 'STR#' resource.
//
// Call?		As needed.
// Override?	Seldom.
{
	short returnVal = kNoResource;

	short totalStringLength = theString.Length() + kLengthByte;
	Handle aHandle = CMultiLocale_AC::GetResource('STR#', fStrListID);
	if (aHandle)
	{
		Size itsSize = GetHandleSize(aHandle);
		if (itsSize > 0)
		{
			short numStrings = CountStrings();
			SetPermHandleSize(aHandle, itsSize + totalStringLength);
			(**((IntegerHandle)aHandle)) =++numStrings;// increment the count of strings in the STR# resource

			// needs a failure handler
			long result = Munger(aHandle, itsSize, NULL, totalStringLength, &theString, totalStringLength);
			if (result > 0)
			{
				// mark it as changed
				ChangedResource(aHandle);

				returnVal = numStrings;
			}
		}
	}
	else
	{
		// must create the resource...
		aHandle = NewPermHandle(sizeof(short) + totalStringLength);
		(**((IntegerHandle)aHandle)) = 1;		// set the count of strings in the STR# resource
		long result = Munger(aHandle, sizeof(short), NULL, totalStringLength, &theString, totalStringLength);
		if (result > 0)
		{
			CMultiLocale_AC::AddResource(aHandle, 'STR#', fStrListID, fStrListRsrcName);
			::ThrowIfResError_AC();						// if fails, it's most likely because the file is read-only

			SetResAttrs(aHandle, resPurgeable);

			// Need the following ChangedResource call because the SetResAttrs call on the previous
			// line cleared the "resChanged" attribute of the resource.
			ChangedResource(aHandle);

			returnVal = 1;
		}
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CStringListRsrc_AC::ClearAll:
//----------------------------------------------------------------------------------------

void CStringListRsrc_AC::ClearAll()
// ClearAll removes all strings from the 'STR#' resource.
//
// Call?		As needed.
// Override?	Seldom.
{
	Handle aHandle = CMultiLocale_AC::GetResource('STR#', fStrListID);
	if (aHandle)
	{
		SetPermHandleSize(aHandle, sizeof(short));
		(**((IntegerHandle)aHandle)) = 0;		// set the count of strings in the STR# resource

		// mark it as changed
		ChangedResource(aHandle);
	}
}

//----------------------------------------------------------------------------------------
// CStringListRsrc_AC::CountStrings:
//----------------------------------------------------------------------------------------

short CStringListRsrc_AC::CountStrings() const
{
	// return the leading integer in the STR# resource:
	//
	// type 'STR#' {
	//      integer = $$Countof(StringArray);
	//      array StringArray {
	//              pstring;
	//      };
	// };

	Handle aHandle = CMultiLocale_AC::GetResource('STR#', fStrListID);

	return aHandle ? **((IntegerHandle)aHandle) : kNoResource;
}

//----------------------------------------------------------------------------------------
// CStringListRsrc_AC::GetListName:
//----------------------------------------------------------------------------------------

void CStringListRsrc_AC::GetListName(CStr255_AC& theString)
{
	// Do we have the name in our field?
	if (fStrListRsrcName.Length() > 0)
		theString = fStrListRsrcName;
	else										//	We don't have the name so try and get it from the resource
		{
			// Get the resource's handle
			Handle aHandle = CMultiLocale_AC::GetResource('STR#', fStrListID);
			if (aHandle)
			{
				short itsRsrcID;
				CStr255_AC itsName;
				ResType itsType;

				// Extract the resource info from the handle
				::GetResInfo(aHandle, &itsRsrcID, &itsType, itsName);
				if (itsName.Length() > 0)
				{
					theString = itsName;

					// Store the name in our field
					fStrListRsrcName = theString;
				}

				ReleaseResource(aHandle);
			}
			else								// Sorry we don't have anything so return an empty CPascalStr_AC
				theString.Empty();
		}
}

//----------------------------------------------------------------------------------------
// CStringListRsrc_AC::RemoveAt:
//----------------------------------------------------------------------------------------

void CStringListRsrc_AC::RemoveAt(short index)
{
	if ((index > 0) && (index <= CountStrings()))
	{
		Handle aHandle = CMultiLocale_AC::GetResource('STR#', fStrListID);
		if (aHandle)
		{
			Size originalSize = GetHandleSize(aHandle);

			// determine the accumulated size
			Size accumulatedSize = sizeof(short);// the accumulated size is the size of the count
			for (short i = 1; i < index; ++i)
				accumulatedSize += (*((Str255*)(*aHandle + accumulatedSize)))[0] + kLengthByte;

			// determine the actual CPascalStr_AC size
			Size stringSize = (*((Str255*)(*aHandle + accumulatedSize)))[0] + kLengthByte;

			// move the the data in the handle
			BlockMove_AC(*aHandle + accumulatedSize + stringSize, *aHandle + accumulatedSize, originalSize - accumulatedSize - stringSize);

			// trim the handle down to its new size
			SetPermHandleSize(aHandle, originalSize - stringSize);

			// decrement count of strings in STR# resource
			--(**((IntegerHandle)aHandle));

			// mark it as changed
			ChangedResource(aHandle);
		}
#if qDebugMsg
		else
			ProgramReport_AC("CStringListRsrc_AC::RemoveAt can't find STR# = %d.\n", CMultiLocale_AC::GetExistingResourceID('STR#', fStrListID));
#endif

	}
#if qDebugMsg
	else
		ProgramReport_AC("CStringListRsrc_AC::RemoveAt there's no CPascalStr_AC at %d to remove!\n", index);
#endif
}

//----------------------------------------------------------------------------------------
// CStringListRsrc_AC::ReplaceAt:
//----------------------------------------------------------------------------------------

void CStringListRsrc_AC::ReplaceAt(const CStr255_AC& theString, short index)
{
	if ((index > 0) && (index <= CountStrings()))
	{
		Handle aHandle = CMultiLocale_AC::GetResource('STR#', fStrListID);
		if (aHandle)
		{
			Size newStringSize = theString.Length() + kLengthByte;// the actual CPascalStr_AC size
			Size originalSize = GetHandleSize(aHandle);

			// determine the accumulated size of the valid portion of the resource
			Size accumulatedSize = sizeof(short);// the accumulated size is the size of the count
			for (short i = 1; i < index; ++i)
				accumulatedSize += (*((Str255*)(*aHandle + accumulatedSize)))[0] + kLengthByte;

			// determine the actual CPascalStr_AC size
			Size oldStringSize = (*((Str255*)(*aHandle + accumulatedSize)))[0] + kLengthByte;

			// determine the new handle size
			Size newHandleSize = originalSize + (newStringSize - oldStringSize);

			// determine whether to grow or shrink the handle?
			if (newStringSize > oldStringSize)
			{
				// grow the handle
				SetPermHandleSize(aHandle, newHandleSize);

				// move the bytes
				BlockMove_AC(*aHandle + accumulatedSize + oldStringSize, *aHandle + accumulatedSize + newStringSize, originalSize - accumulatedSize - oldStringSize);
			}
			else if (oldStringSize > newStringSize)
			{
				// move the bytes
				BlockMove_AC(*aHandle + accumulatedSize + oldStringSize, *aHandle + accumulatedSize + newStringSize, originalSize - accumulatedSize - oldStringSize);

				// shrink the handle
				SetPermHandleSize(aHandle, newHandleSize);
			}

			// assign the CPascalStr_AC
			theString.CopyTo(*((Str255 *)(*aHandle + accumulatedSize)));;

			// mark it as changed
			ChangedResource(aHandle);
		}
#if qDebugMsg
		else
			ProgramReport_AC("CStringListRsrc_AC::ReplaceAt can't find STR# = %d.\n", CMultiLocale_AC::GetExistingResourceID('STR#', fStrListID));
#endif

	}
#if qDebugMsg
	else
		ProgramReport_AC("CStringListRsrc_AC::ReplaceAt there's no CPascalStr_AC at %d to replace!\n", index);
#endif
}

//========================================================================================
// CLASS CWMgrIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CWMgrIterator::CWMgrIterator:
//----------------------------------------------------------------------------------------

CWMgrIterator::CWMgrIterator(bool itsForward)
	:	fIterateForward(itsForward)
// CWMgrIterator initializes this iterator according to the specified parameters.
//
// itsForward:	Specifies the direction in which iteration is to proceed; true
// 				indicates forward iteration.
//
// Call?		As needed.
// Override?	Seldom.
{
	First();
}

//----------------------------------------------------------------------------------------
// CWMgrIterator::First:
//----------------------------------------------------------------------------------------

WindowRef CWMgrIterator::First()
{
	return fCurrent = fIterateForward ? FirstWindow() : LastWindow();
}

//----------------------------------------------------------------------------------------
// CWMgrIterator::Next:
//----------------------------------------------------------------------------------------

WindowRef CWMgrIterator::Next()
{
	if (fCurrent)
		fCurrent = fIterateForward ? NextWindow(fCurrent) : PreviousWindow(fCurrent);

	return Current();
}

//----------------------------------------------------------------------------------------
// CWMgrIterator::FirstWindow:
//----------------------------------------------------------------------------------------

WindowRef CWMgrIterator::FirstWindow()
{
#if !qCarbon
	WindowRef currentWindow = (WindowRef)LMGetWindowList();
#else
	WindowRef currentWindow = (WindowRef)GetWindowList();
#endif
	if (currentWindow && (currentWindow == gWorkPort))
		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CWMgrIterator::NextWindow:
//----------------------------------------------------------------------------------------

WindowRef CWMgrIterator::NextWindow(WindowRef aWindow)
{
	WindowRef currentWindow = GetNextWindow_AC(aWindow);

	while (currentWindow && (currentWindow == gWorkPort))
		// ignore the work window
		currentWindow = GetNextWindow_AC(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CWMgrIterator::PreviousWindow:
//----------------------------------------------------------------------------------------

WindowRef CWMgrIterator::PreviousWindow(WindowRef aWindow)
{
	WindowRef currentWindow = FirstWindow();
	while (currentWindow && (NextWindow(currentWindow) != aWindow))
		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CWMgrIterator::LastWindow:
//----------------------------------------------------------------------------------------

WindowRef CWMgrIterator::LastWindow()
{
	WindowRef currentWindow = FirstWindow();
	while (currentWindow && NextWindow(currentWindow))
		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// CenterRectOnScreen:
//----------------------------------------------------------------------------------------
// This must always be in a resident segment as aRect may be within a handle

void CenterRectOnScreen(CRect_AC&	aRect,
						bool		horizontally,
						bool		vertically,
						bool		forDialog)
{
	short		newSize = 0;
	CPoint_AC	rectSize(aRect.GetSize());
	CPoint_AC	screenSize = ScreenBounds_AC().GetSize();

	screenSize.v -= GetMBarHeight();

	// Calculate screen size minus menu bar
	if (horizontally)
		aRect.left = (screenSize.h - rectSize.h) / 2;
	if (vertically)
		if (forDialog)
		{
			newSize = (screenSize.v - rectSize.v) / 5;
			aRect.top = Max_AC(newSize, static_cast<short>(10)) + GetMBarHeight();
		}
		else
			aRect.top = (screenSize.v - rectSize.v) / 2;

	aRect[botRight] = aRect[topLeft] + rectSize;
}

//----------------------------------------------------------------------------------------
// ConcatNumber:
//----------------------------------------------------------------------------------------

void ConcatNumber(const CStr255_AC&	aString,
				  long				aNumber,
				  CStr255_AC&		theResult)
{
	CStr255_AC	theNumber;
	NumToString(aNumber, theNumber);
	theResult = aString;
	theResult += theNumber;
}

//----------------------------------------------------------------------------------------
// PullApplicationToFront:
//----------------------------------------------------------------------------------------

void PullApplicationToFront()
{
	// The "Programmer's guide to MultiFinder says make an event call several times. I
	// guess 3 calls counts as several. Also, it says call GetNextEvent but we don't want
	// to lose events on the floor so we use EventAvail since it seems to work OK

#if qCarbon
	//#pragma message ("UMacAppUtilities.cpp:PullApplicationToFront: EventAvail not available in OS X.")
#else
	EventRecord theEvent;

	for (short i = 1; i <= 3; ++i)
		::EventAvail(everyEvent, &theEvent);
#endif
}

//----------------------------------------------------------------------------------------
// MAInteractWithUser:
//----------------------------------------------------------------------------------------

OSErr MAInteractWithUser(long timeOutInTicks, NMRecPtr nmReqPtr, AEIdleUPP idleProc)
{
	return gDispatcher
		? gDispatcher->InteractWithUser(timeOutInTicks, nmReqPtr, idleProc)
		:
#if !qMSWindows
			AEInteractWithUser(kNoTimeOut, nmReqPtr, idleProc);
#else
			true;
#endif
}

//----------------------------------------------------------------------------------------
// MAInteractWithUser:
//----------------------------------------------------------------------------------------

OSErr MAInteractWithUser()
{
	return MAInteractWithUser(kMacAppTimeout,
							  gNotificationPtr,
#if qAppleEventAware
							  TAppleEvent::fgIdleProc
#else
							  NULL
#endif
								  );
}

//----------------------------------------------------------------------------------------
// MAInteractWithUserNoIdleProc:
//----------------------------------------------------------------------------------------

OSErr MAInteractWithUserNoIdleProc()
{
	return MAInteractWithUser(kMacAppTimeout, gNotificationPtr);
}

//----------------------------------------------------------------------------------------
// MACharacterByteType:
//----------------------------------------------------------------------------------------

short MACharacterByteType(Ptr textBuf, short textOffset, ScriptCode script)
{
	short byteType = CharacterByteType(textBuf, textOffset, script);// textOffset is zero-based

#if qDebug
	::Assertion_AC(byteType != smMiddleByte, "MACharacterByteType: byteType != smMiddleByte. We should never receive smMiddleByte.");
#endif

	return byteType;
}

//----------------------------------------------------------------------------------------
// MACharacterByte:
//----------------------------------------------------------------------------------------

short MACharacterType(Ptr textBuf, short textOffset, ScriptCode script)
{
	// CharacterType only avail in sys 7.1+ and carbon
	short byteType = CharacterType(textBuf, textOffset, script);	// textOffset is zero-based

#if qDebug
	::Assertion_AC(byteType != smMiddleByte, "MACharacterType: byteType != smMiddleByte. We should never receive smMiddleByte.");
#endif

	return byteType;
}

//----------------------------------------------------------------------------------------
// CompareMultiByteChars:
//----------------------------------------------------------------------------------------

bool CompareMultiByteChars(const CStr31_AC& first, const CStr31_AC&	second, bool caseSens)
{
	bool areEqual = false;

	if (caseSens)
		areEqual = first == second;
	else
	{
		int textOffset = 0;
		bool done = false;

		do
		{
			++textOffset;
			char c = first[textOffset];

			short byteType = MACharacterByteType((Ptr) & c, 0, smCurrentScript);

			areEqual = first[textOffset] == second[textOffset];
			switch (byteType)
			{
					// special case single byte characters to allow lower case characters to map to
					// upper case characters
				case smSingleByte:
					areEqual = (LowerChar(first[1]) == LowerChar(second[1]));
					done = true;
					break;

				case smFirstByte:
					done = !areEqual;			// we're done if they don't match
					break;

				case smLastByte:
					done = true;
					break;
			}
		} while (!done);
	}

	return areEqual;
}

//----------------------------------------------------------------------------------------
// DefaultSize:
//----------------------------------------------------------------------------------------

void DefaultSize(short& theSize)
{
	if (theSize == ::GetDefFontSize_AC())
		theSize = 0;
}

//----------------------------------------------------------------------------------------
// DisposeIfPicHandle:
//----------------------------------------------------------------------------------------

PicHandle DisposeIfPicHandle(PicHandle aPicHandle)
{
	if (aPicHandle)
	{
#if !qCoreDebug
		KillPicture(aPicHandle);
#else
		if (IsAResource_AC((Handle)aPicHandle))		// Test resourceliness
		{
			::ProgramBreak_AC("Trying to dispose a resource-based PicHandle)\nBad PicHandle: %p\n", aPicHandle);
		}
		else if (VerboseIsHandle((Handle)aPicHandle))
		{
			// Set the handle contents to a real nice value for any dangling pointerciples
			BlockSet_AC(*((Handle)aPicHandle), GetHandleSize((Handle)aPicHandle), kDisposedInitVal_AC);
			KillPicture(aPicHandle);
		}
		else
		{
			// VerboseIsHandle will have already printed a detailed diagnosis.
			::ProgramBreak_AC("Trying to dispose an invalid PicHandle)\nBad PicHandle: %p\n", aPicHandle);
		}
#endif
	}
	return NULL;
}

#if !qCarbon && !qMSWindows

//----------------------------------------------------------------------------------------
// DisposeIfSectionHandle:
//----------------------------------------------------------------------------------------

SectionHandle DisposeIfSectionHandle(SectionHandle aSectionHandle)
{
	if (aSectionHandle)
	{
#if !qCoreDebug
		::DisposeIfHandle_AC((Handle)(*aSectionHandle)->alias);// dispose of the alias
		::DisposeIfHandle_AC((Handle)aSectionHandle);// dispose of the SectionHandle
#else
		// Test handlehood
		if (IsHandle_AC((Handle)aSectionHandle))
		{
			::DisposeIfHandle_AC((Handle)(*aSectionHandle)->alias);// dispose of the alias

			// Set the handle contents to a real nice value for any dangling pointerciples
			BlockSet_AC(*((Handle)aSectionHandle), GetHandleSize((Handle)aSectionHandle), kDisposedInitVal_AC);
			::DisposeIfHandle_AC((Handle)aSectionHandle);// dispose of the SectionHandle
		}
		else
		{
			VerboseIsHandle((Handle)aSectionHandle);// Get the diagnosis printed
			::ProgramBreak_AC("Trying to dispose an invalid SectionHandle.\nBad SectionHandle: %p\n", aSectionHandle);
		}
#endif

	}

	return NULL;
}

#endif	// non-Carbon code

//----------------------------------------------------------------------------------------
// FindWindowBefore: returns the window just before a given window. Returns NULL if the
// given window is frontmost or not found.
//----------------------------------------------------------------------------------------

WindowRef FindWindowBefore(WindowRef theWindow)
{
	WindowRef returnVal = NULL;

	for (CWMgrIterator iter; iter; ++iter)
		if (GetNextWindow_AC(iter) == theWindow)
		{
			returnVal = iter;
			break;
		}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// GetDeskTopRegion:
//----------------------------------------------------------------------------------------

void GetDeskTopRegion(RgnHandle deskTopRgn)
{
	::RectRgn(deskTopRgn, &((*GetMainDevice())->gdRect));
	::MacUnionRgn(GetGrayRgn(), deskTopRgn, deskTopRgn);// deskTopRgn = grayRgn + deskTopRgn
}

//----------------------------------------------------------------------------------------
// ShowGlobalRegion:
//----------------------------------------------------------------------------------------

void ShowGlobalRegion(RgnHandle globalRegion)
{
	if (globalRegion)
	{
		GrafPtr savedPort;
#if !qCarbon
		CGrafPort desktopPort;
#else
		CGrafPtr desktopPortPtr = ::CreateNewPort();
#endif

		// Cursor region is in global coords. Need to create desktop port
		GetPort(&savedPort);
#if !qCarbon
		::OpenCPort(&desktopPort);

		//CopyRgn(GetGrayRgn(), TWindow::GetVisRegion((GrafPtr) & desktopPort));
		//desktopPort.portRect = (*TWindow::GetVisRegion((GrafPtr) & desktopPort))->rgnBBox;
		::MacCopyRgn(GetGrayRgn(), desktopPort.visRgn);
		desktopPort.portRect = (*(desktopPort.visRgn))->rgnBBox;
#else
		CTempRegion_AC visRegion;
		::GetPortVisibleRegion(desktopPortPtr, visRegion);
		::MacCopyRgn(GetGrayRgn(), visRegion);
		Rect visRect;
		::SetPortBounds(desktopPortPtr, ::GetRegionBounds(visRegion, &visRect));
#endif

		::PenNormal();
		::PenMode(patXor);

		::MacPaintRgn(globalRegion);
		unsigned long endCount = TickCount() + 30;
		CPoint_AC globalMouse;

		GetMouse(&globalMouse);
		LocalToGlobal(&globalMouse);
		// delay up to thirty ticks

		while ((TickCount() < endCount) && CRegion_AC(globalRegion).Contains(globalMouse))
		{
#if qCarbon
			//#pragma message ("UMacAppUtilities.cpp:ShowGlobalRegion: EventAvail not available in OS X.")
#else
			{
				EventRecord eventRecord;
				if (::EventAvail(mouseDown | keyDown, &eventRecord))
					break;
			}
#endif
			GetMouse(&globalMouse);
			LocalToGlobal(&globalMouse);
		}

		::MacPaintRgn(globalRegion);

#if !qCarbon
		::CloseCPort(&desktopPort);
#else
		::DisposePort(desktopPortPtr);
#endif
		::SetPort_AC(savedPort);
	}
}

//----------------------------------------------------------------------------------------
// ShowViewRegion:
//----------------------------------------------------------------------------------------

void ShowViewRegion(TView* theView, RgnHandle viewRegion)
{
	if (viewRegion && theView)
	{
		CTempRegion_AC tempRegion;

		::MacCopyRgn(viewRegion, tempRegion);
		theView->LocalToGlobal(tempRegion);
		ShowGlobalRegion(tempRegion);
	}
}

//----------------------------------------------------------------------------------------
// GetFontNum:
//----------------------------------------------------------------------------------------

short GetFontNum(const CStr255_AC& fontName)
{
	short fontNum;
	CStr255_AC localFontName(fontName);

	UprStr255(localFontName);
	if (localFontName == kSysFontName)
		fontNum = systemFont;
	else if (localFontName == kApplFontName)
	{
		static short appFontNum = -1;
		if (appFontNum == -1)
			appFontNum = ::GetAppFont_AC();
		fontNum = appFontNum;
	}
	else
		GetFNum(fontName, &fontNum);

	return fontNum;
}

//----------------------------------------------------------------------------------------
// MAGetFontInfo:
//----------------------------------------------------------------------------------------

short MAGetFontInfo(FontInfo& theFontInfo)
// MAGetFontInfo may be used in place of GetFontInfo since it also returns the font height.
{
	GetFontInfo(&theFontInfo);					// get the current port's font info

	return theFontInfo.ascent + theFontInfo.descent + theFontInfo.leading;// returns the font height
}

//----------------------------------------------------------------------------------------
// GetPortFontInfo:
//----------------------------------------------------------------------------------------

void GetPortFontInfo(short fontNum, CStr255_AC& fontName, short& fontSize)
{
	if ((fontNum == systemFont) || (fontNum == ::GetSysFont_AC()))
	{
		fontName = kSysFontName;
		DefaultSize(fontSize);
	}
	else if ((fontNum == applFont) || (fontNum == ::GetAppFont_AC()))
	{
		fontName = kApplFontName;
		DefaultSize(fontSize);
	}
	else
		GetFontName(fontNum, fontName);
}

//----------------------------------------------------------------------------------------
// GetRandom:
//----------------------------------------------------------------------------------------

long GetRandom(long rangeStart, long rangeEnd)
{
	unsigned short rndNum = Random();

	return rangeStart < rangeEnd ? rangeStart + rndNum % (rangeEnd - rangeStart + 1) : rangeStart;
}

//----------------------------------------------------------------------------------------
// IsThisKeyDown:
//----------------------------------------------------------------------------------------

bool IsThisKeyDown(const short theKey)
{
	KeyMap map;
	GetKeys(map);

	return (reinterpret_cast<Byte*>(&map))[theKey >> 3] & (1 << (theKey & 0x07)) ? true : false;
}

//----------------------------------------------------------------------------------------
// IsCapsLockKeyDown:
//----------------------------------------------------------------------------------------

bool IsCapsLockKeyDown()
{
	return IsThisKeyDown(kCapsLockKey);
}

//----------------------------------------------------------------------------------------
// IsCommandKeyDown:
//----------------------------------------------------------------------------------------

bool IsCommandKeyDown()
{
	return IsThisKeyDown(kCommandKey);
}

//----------------------------------------------------------------------------------------
// IsControlKeyDown:
//----------------------------------------------------------------------------------------

bool IsControlKeyDown()
{
	return IsThisKeyDown(kCtlKey);
}

//----------------------------------------------------------------------------------------
// IsOptionKeyDown:
//----------------------------------------------------------------------------------------

bool IsOptionKeyDown()
{
	return IsThisKeyDown(kOptionKey);
}

//----------------------------------------------------------------------------------------
// IsShiftKeyDown:
//----------------------------------------------------------------------------------------

bool IsShiftKeyDown()
{
	return IsThisKeyDown(kShiftKey);
}

//----------------------------------------------------------------------------------------
// LongerSide:
//----------------------------------------------------------------------------------------

VHSelect LongerSide(const CRect_AC& r)
{
	return r.GetLength(vSel) >= r.GetLength(hSel) ? vSel : hSel;
}

//----------------------------------------------------------------------------------------
// LongerVSide:
//----------------------------------------------------------------------------------------

VHSelect LongerSide(const CViewRect& r)
{
	return r.GetLength(vSel) >= r.GetLength(hSel) ? vSel : hSel;
}

//----------------------------------------------------------------------------------------
// LIntToHex:
//----------------------------------------------------------------------------------------

void LIntToHex(long decNumber, CStr31_AC& hexNumber, short noOfDigits)
{
	short localNoOfDigits = Min_AC(noOfDigits, static_cast<short>(8));
	long localDecNumber = decNumber;
	hexNumber.Length() = static_cast<unsigned char>(localNoOfDigits);
	for (int i = localNoOfDigits; i >= 1; --i, localDecNumber = localDecNumber >> 4)
		hexNumber[i] = kHexDigits[(localDecNumber & 15)];
}

//----------------------------------------------------------------------------------------
// NumberToHex:
//----------------------------------------------------------------------------------------

void NumberToHex(long theNumber, CStr255_AC& hexString, short hexDigits)
{
	CStr31_AC tempString;

	LIntToHex(theNumber, tempString, hexDigits);
	hexString = "$";
	hexString += tempString;
}

//----------------------------------------------------------------------------------------
// PointerToHex:
//----------------------------------------------------------------------------------------

void PointerToHex(long theNumber, CStr31_AC& hexString, short hexDigits)
{
	CStr31_AC tempString;

	if (!theNumber)
		hexString = "nil";
	else
	{
		LIntToHex(theNumber, tempString, hexDigits);
		hexString = "$";
		hexString += tempString;
	}
}

//----------------------------------------------------------------------------------------
// NumBlocks:
//----------------------------------------------------------------------------------------

long NumBlocks(long numBytes, long blkSize)
{
	return (numBytes + blkSize - 1) / blkSize;
}

//----------------------------------------------------------------------------------------
// MADrawString:
//----------------------------------------------------------------------------------------

void MADrawString(const CStr255_AC& s,
				  const CRect_AC&	box,
				  short				justification,
				  bool				preferOutline)
{
	CWhileOutlinePreferred_AC setOP(preferOutline);

	short widthOfString = ::StringWidth(s);
	CRect_AC localBox(box);
	short boxWidth = localBox.GetLength(hSel);

	if (widthOfString < boxWidth)
		switch (GetActualJustification(justification))
		{
			case teCenter:
				localBox.left += (boxWidth - widthOfString) / 2;
				break;

			case teFlushRight:
				localBox.left += boxWidth - widthOfString;
				break;
		}

	FontInfo theFontInfo;
	::GetFontInfo(&theFontInfo);
	::MoveTo(localBox.left, localBox.top + theFontInfo.ascent);

	// If the string is too long for the box then it will need to be
	// clipped.
	if (widthOfString > boxWidth)
	{
		CTempRegion_AC tempRgn;
		::GetClip(tempRgn);

		CTempRegion_AC theClipRgn(box);
		::SectRgn(tempRgn, theClipRgn, theClipRgn);
		::SetClip(theClipRgn);

		::DrawString(s);

		::SetClip(tempRgn);
	}
	else
		::DrawString(s);
}

//----------------------------------------------------------------------------------------
// PinOnRect:
//----------------------------------------------------------------------------------------

long PinOnRect(const CRect_AC& theRect, CPoint_AC thePt)
{
	CPoint_AC localPt = thePt;
	if (localPt.h < theRect.left)
		localPt.h = theRect.left;
	if (localPt.h > theRect.right)
		localPt.h = theRect.right;
	if (localPt.v < theRect.top)
		localPt.v = theRect.top;
	if (localPt.v > theRect.bottom)
		localPt.v = theRect.bottom;

	return *reinterpret_cast<long*>(&localPt);
}

//----------------------------------------------------------------------------------------
// PinOnVRect:
//----------------------------------------------------------------------------------------

void PinOnVRect(const CViewRect& theRect, const CViewPoint& thePt, CViewPoint& thePin)
{
	long hCoord = MinMax_AC(theRect.left, thePt.h, theRect.right);
	long vCoord = MinMax_AC(theRect.top, thePt.v, theRect.bottom);
	thePin.Set(hCoord, vCoord);
}

//----------------------------------------------------------------------------------------
// RoundUp:
//----------------------------------------------------------------------------------------

long RoundUp(long aNumber,  short aModulus)
{
	return ((aNumber + aModulus - 1) / aModulus) * aModulus;
}

//----------------------------------------------------------------------------------------
// MAGetTextStyle:
//----------------------------------------------------------------------------------------

CTextStyle_AC MAGetTextStyle(ResNumber rsrcID)
{
	TemplateTempHandleLock<MATextStyleHandle> theTextStyleHdl(reinterpret_cast<MATextStyleHandle>(CMultiLocale_AC::GetResource('TxSt', rsrcID)));
	::ThrowIfNULLResource_AC(theTextStyleHdl);

	MATextStyle & resourceStyle = **theTextStyleHdl;

#if !qMSWindows
	return CTextStyle_AC(GetFontNum(resourceStyle.tsFont), resourceStyle.tsFace, resourceStyle.tsSize, resourceStyle.tsColor);
#else
	return CTextStyle_AC(GetFontNum(resourceStyle.tsFont), resourceStyle.tsFace, EndianS16_BtoN(resourceStyle.tsSize), resourceStyle.tsColor);
#endif
}

//----------------------------------------------------------------------------------------
// UseSelectionColor:
//----------------------------------------------------------------------------------------

void UseSelectionColor()
{
#if !qMSWindows
	unsigned char hiliteModeValue = ::LMGetHiliteMode();
	BitClr((Ptr) & hiliteModeValue, pHiliteBit);
	::LMSetHiliteMode(hiliteModeValue);
#endif
}

//----------------------------------------------------------------------------------------
// RotatePat:
//----------------------------------------------------------------------------------------

void RotatePat(Pattern& aPattern)
{
	unsigned char temp = aPattern.pat[0];
	for (unsigned short index = 0; index < (sizeof(Pattern) - 1); ++index)
		aPattern.pat[index] = aPattern.pat[index + 1];
	aPattern.pat[sizeof(Pattern) - 1] = temp;
}

//----------------------------------------------------------------------------------------
// XorPat:
//----------------------------------------------------------------------------------------

void XorPat(const Pattern&	patA,
			const Pattern&	patB,
			Pattern&		toPat)
{
	for (unsigned short index = 0; index < sizeof(Pattern); ++index)
		toPat.pat[index] = patA.pat[index] ^ patB.pat[index];// xor
}

//----------------------------------------------------------------------------------------
// StreamToHandle:
//----------------------------------------------------------------------------------------

Handle StreamToHandle(CRandomAccessStream_AC* theStream)
{
	Size dataSize = theStream->GetSize() - theStream->GetPosition();

	CTempHandle_AC dataHandle(NewPermHandle(dataSize));	// fails if error
	CTempHandleLock_AC tempHandleLock(dataHandle);

	theStream->ReadBytes(*dataHandle, dataSize);

	return dataHandle.release();
}

//----------------------------------------------------------------------------------------
// End of UMacAppUtilities.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/27/96	DisposeRoutineDescriptor is a macro - can't global scope.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		 6/04/96	Added constructors for gZero[V]Pt/Rect so they don't get dead stripped.
		 5/21/96	[1336161] (Errors) MacAppAlert and TopLevelHandler. Made MAInteractWithUser work if there
		 					is no gDispatcher yet. Made all MAInteractWithUser calls bottleneck thru a single MAInteractWithUser.
		 5/10/96	Removed HasTrueType test from CWhileOutlinePreferred since we require System 7
		 5/08/96	Cleanup CRGBColor_AC and add new class CTextStyle_AC
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/25/96	Made CRect_AC/CViewRect parameters to LongerSize const references. Made LongerSide
							overloaded for parameter type.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Update iterators to be OD stylish.
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use more "while" style iteration
		04/16/96	Use "while" style iteration
		----- R10 -----
		  4/3/96	OSEvents.h merged into Events.h.
							"FragLoad.h" has been renamed to "CodeFragments.h"
		03/31/96	Revert S/GetIf[Bk]Color. OK, now they are more clever. Since we
							require system 7 we can use the RGBColor calls even on b&w grafports
							and can dump the old compatibility code.
		03/30/96	Revert S/GetIf[Bk]Color inlines. They can be more clever about
							needlessly pestering QD.
		03/27/96	MapRGBToOldDumbCMYB missing return value.
		03/27/96	Change bgColor to bkColor of the GrafPort in GetIfBkColor.
		03/26/96	Cleanup Iterator::More/Reset to use selection operators
		03/26/96	Cleanup references to gEmptyString
		03/26/96	Add back constructor for gEmptyString to keep it from getting dead-stripped
		03/25/96	On qNeedsColorQD S/GetIf[Bk]Color can inline
		03/25/96	Reduce gBoolString to CStr15_AC from CStr255_AC, reduced gEmptyString
							to CStr2_AC. Saved total of 733 bytes of global space!
		03/25/96	Wrap MACharacterByteType and MACharacterType in #ifndef
							qNeedsSystem7_5 to avoid conflict with inline code.
		03/23/96	Make GetFontNum use UprStr255
		03/22/96	Added MACharacterByteType, MACharacterType to UMacAppUtilities
		03/20/96	Remove MrC warning in IsThisKeyDown.
		03/14/96	Use CPascalStr_AC::Empty.
		 3/05/96	Derive CRGBColor_AC from RGBColor so it is really compatible. We don't
		 					use CFront anymore so the only reason not to is gone now.
		 1/02/96	Fix bug reported by Dave Goldman, CharacterByteType only avail in sys 7.1+
		12/18/95	Include UDispatcher.
		12/13/95	Move upper/lower string utilities to UCoreUtilities.
		 12/8/95	Made MAInteractWithUser non-inline again. Remove UDispatcher.h.
							Add overloaded MAInteractWithUser with all parameters defaulted
							and MAInteractWithUserNoIdleProc.
							Move a lot of stuff to UCoreUtilities.
							Split up includes for modular MacApp.
		  5/7/95	Implement HasOpenDoc.
		----- 3.3 -----
		10/31/95	Add CurResFile_AC, Fix UseResFile_AC to avoid unnecessary UseResFile calls.
		10/19/95	1293874 Removed HasASLM due to ASLM removal vs. deinstall problems.
		10/03/95	1154871 Add IsCapsLockKeyDown
		----- 3.3b1 -----
		  8/2/95	Include UWindow.
		07/31/95	Use GetClipRegion
							Use a temp ref to the gMATextBoxTE when possible to avoid extra dereferences.
		07/30/95	Corrected presence test for QDGX and GX Printing. Use MAHasGestalt
		  8/2/95	Add ShowGlobalRegion, ShowViewRegion. Include UWindow.
		 7/28/95	Add configuration functions to use instead of gConfiguration.
		 6/28/95	Don't need to include ULoMem.
		 6/13/95	Change DisposeIfRoutineDescriptor to a macro so it will
		 					work with all types of UPPs.
		 5/23/95	Make several functions inline, rewrite several functions a single expression
		 5/18/95	Move gCodeRefNum here from UMemory
		 5/18/95	Added MASetResLoad
		 5/31/95	CharacterByteType needs cast to Ptr for compatibility
		 					with different versions of Types.h (see previous bugs).
		 5/17/95	More WindowRef changes. Use CharacterByteType instead of
		 					CharByte.
		 5/16/95	WindowRef
		 5/15/95	Remove support for pre-system 7.
		05/04/95	Move all the MAFoo Resource calls to UMacAppUtilities.
		04/14/95	skip locking handles that are locked already.
		 4/20/95	Change back CompareMultiByteChars to deal with reverted
		 					definition of Ptr in Types.h v2.0.1.
		 4/12/95	Use #if instead of if qDebug.
		 3/20/95	Move all Universal code required to Vet the hardware together
		 					And reduce the "universal" code to a bare minimum
		 3/17/95	Further optimizations to BlockSet_AC.
		03/14/95	1153499	(SPEED) StripLong() can be inline/macro
		03/14/95	1161152	(SPEED) BlockSet_AC() can be 35% faster on PowerPC
		 3/16/95	Use macros from MacAppVersion.h.
		 3/15/95	StreamToHandle reads from the stream position to the end
		 					of the stream.
		 3/10/95	StreamToHandle never throws exceptions.
		  3/3/95	Add StreamToHandle and include UStream.h
		  3/3/95	Include UMacAppGlobals.h for kNoResource definition.
		 2/25/95	Provide initializers for const global static variables, so
		 					SCpp will define them.
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		02/22/95	1222784 set various const usage globals to const attribute
		02/22/95	1185932 add kBestSystemLocation for -1,-1 window locations
		02/13/95	make "p" (private) globals static
		02/13/95	Remove unnecessary initialization of static variables. See ARM ¤8.4
		02/07/95	Create missing prototypes for static functions used internally.
		 2/17/95	Add MAAddResource.
		11/14/94	Update version to 3.5d3.
		10/27/94	Compile with ETO 15 prerelease headers.
		 10/4/94	Update version to 3.5d2.
		 7/18/94	Move GetRandom here from UScriptableObject (as per
							Ken Ryall).
							Update version to 3.5d1.
		 7/13/94	Update version to 3.1.1.
*/