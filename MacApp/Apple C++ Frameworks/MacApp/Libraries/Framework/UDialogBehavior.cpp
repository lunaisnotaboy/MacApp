//----------------------------------------------------------------------------------------
// UDialogBehavior.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/18/01	Correct validate test in Dismiss.
		05/10/01	[C] Carbon Event support. 
		01/02/01	Update copyright.
		11/09/00	[PB] Change initialization order to match declaration. 
		07/31/00	[W] Conditionalize implementation in PoseModally.
		03/24/99	Update copyright notice.
		10/08/98	Undo context. 
*/

#ifndef __UDIALOGBEHAVIOR__
#include "UDialogBehavior.h"
#endif

// MacApp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UUNDO__
#include "UUndo.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

// Toolbox

#if qCarbonEvents
#ifndef __CARBONEVENTS__
#include <CarbonEvents.h>
#endif
#endif

//========================================================================================
// CLASS TDialogBehavior
//========================================================================================
#undef Inherited
#define Inherited TBehavior


MA_DEFINE_CLASS(TDialogBehavior);

//----------------------------------------------------------------------------------------
// TDialogBehavior constructor
//----------------------------------------------------------------------------------------


TDialogBehavior::TDialogBehavior(bool isModal,
								 IDType itsDefaultItem,
								 IDType itsCancelItem)
	:	TBehavior(kDialogBehavior),
		fDefaultItem(itsDefaultItem),
		fCancelItem(itsCancelItem),
		fDismisser(kNoIdentifier),
		fModal(isModal),
		fDismissed(true)
{
}

//----------------------------------------------------------------------------------------
// TDialogBehavior destructor
//----------------------------------------------------------------------------------------


TDialogBehavior::~TDialogBehavior()
{
}

//----------------------------------------------------------------------------------------
// TDialogBehavior::ReadFrom: 
//----------------------------------------------------------------------------------------


void TDialogBehavior::ReadFrom(CStream_AC* aStream)
{
	Inherited::ReadFrom(aStream);

	fModal = aStream->ReadBoolean();
 	fDefaultItem = aStream->ReadIDType();
	fCancelItem = aStream->ReadIDType();
}

//----------------------------------------------------------------------------------------
// TDialogBehavior::WriteTo: 
//----------------------------------------------------------------------------------------


void TDialogBehavior::WriteTo(CStream_AC* aStream) const
{
	Inherited::WriteTo(aStream);

	aStream->WriteBoolean(fModal);
	aStream->WriteIDType(fDefaultItem);
	aStream->WriteIDType(fCancelItem);
}

//----------------------------------------------------------------------------------------
// TDialogBehavior::Dismiss: 
//----------------------------------------------------------------------------------------


void TDialogBehavior::Dismiss(IDType dismisser, bool validate)
{
	TView* owner = dynamic_cast_AC(TView*,fOwner);
	if (owner)
	{
		if (!validate || owner->IsHierarchyValid())
		{
			fDismisser = dismisser;
			fDismissed = true;

#if qCarbonEvents
			if (gDispatcher->UseCarbonEvents() && (&QuitAppModalLoopForWindow != 0))
			{
				// Stop the modal loop so we can return to PoseModally
				WindowRef windowRef = fOwner->GetWindow()->GetWindowRef();
				OSStatus err = QuitAppModalLoopForWindow(windowRef);
			}
#endif
		}
	}
}

//----------------------------------------------------------------------------------------
// TDialogBehavior::DoEvent: 
//----------------------------------------------------------------------------------------


void TDialogBehavior::DoEvent(EventNumber eventNumber,
								 TEventHandler* source,
								 TEvent* event)
{
	if (eventNumber == mDismiss /*dismiss*/)
		Dismiss(source->GetIdentifier(), source->GetIdentifier() != fCancelItem);
	else
		Inherited::DoEvent(eventNumber, source, event);
	
}

//----------------------------------------------------------------------------------------
// TDialogBehavior::DoKeyEvent: 
//----------------------------------------------------------------------------------------


void TDialogBehavior::DoKeyEvent(TToolboxEvent* event)
{
	// Maps the Enter and Return keys to the default item (view)
	// Maps the Escape key to the cancel item (view)
	
	TView* owner = dynamic_cast_AC(TView*, fOwner);
	bool wasHandled = false;

	if (owner && owner->IsEnabled())
	{
		if (event->GetText() == chEscape && event->GetKeyCode() != kClearVirtualCode) // esc double for two different keys! 
		{
			if (fCancelItem != kNoIdentifier)
			{
				wasHandled = true;
				TView * cancelView = owner->FindSubView(fCancelItem);
				if (cancelView)
				{
					if (cancelView->IsEnabled())
						cancelView->HandleEvent(cancelView->GetEventNumber(), owner, NULL);
				}
				else
					owner->HandleEvent(mCancelKey, owner, NULL);
			}
		}
		else if(event->GetText() == chEnter || event->GetText() == chReturn)
		{
			if (fDefaultItem != kNoIdentifier)
			{
				wasHandled = true;
				::AssertNotNULL_AC(owner);
				
				TView * defaultView = owner->FindSubView(fDefaultItem);
				if (defaultView)
				{
					if (defaultView->IsEnabled())
						defaultView->HandleEvent(defaultView->GetEventNumber(), owner, NULL);
				}
				else
					owner->HandleEvent(mDefaultKey, owner, NULL);
			}
		}
	}

	if (!wasHandled)
		Inherited::DoKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TDialogBehavior::DoCommandKeyEvent: 
//----------------------------------------------------------------------------------------


void TDialogBehavior::DoCommandKeyEvent(TToolboxEvent* event)

{
	// Maps Command-Period to the cancel item (view)
	TView* owner = dynamic_cast_AC(TView*, fOwner);

	if (owner && owner->IsEnabled() && event->GetText() == '.' && fCancelItem != kNoIdentifier)
	{
		TView* cancelView = owner->FindSubView(fCancelItem);
		if (cancelView)
		{
			if (cancelView->IsEnabled())
				cancelView->HandleEvent(cancelView->GetEventNumber(), owner, NULL);
		}
		else
			owner->HandleEvent(mCancelKey, owner, NULL);
	}
	else
		Inherited::DoCommandKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TDialogBehavior::PoseModally: 
//----------------------------------------------------------------------------------------


void TDialogBehavior::PoseModally()
{
	//TUndoHandler::fgUndoHandler.MarkActionHistory();
	fDismissed = false;
	fDismisser = kNoIdentifier;
	
#if !qMSWindows
	short oldEventMask = gDispatcher->GetMainEventMask();
	gDispatcher->SetMainEventMask(oldEventMask & ~highLevelEventMask);

	try
	{
#if qCarbonEvents
		if (gDispatcher->UseCarbonEvents() && (&RunAppModalLoopForWindow != 0))
		{
			// If we're running on CarbonLib 1.3 or later, 
			// use a modal event loop. 
			WindowRef windowRef = fOwner->GetWindow()->GetWindowRef();
			while (!fDismissed)
				ThrowIfOSErr_AC(RunAppModalLoopForWindow(windowRef));
		}
		else
#endif
		{
			while (!fDismissed)
				gDispatcher->PollEvent(kAllowApplicationToSleep);
		}

		gDispatcher->SetMainEventMask(oldEventMask);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		gDispatcher->SetMainEventMask(oldEventMask);
		//TUndoHandler::fgUndoHandler.ClearActionHistory(kRespectMarks);
		throw;
	}
		
	//TUndoHandler::fgUndoHandler.ClearActionHistory(kRespectMarks);
#else
	TWindow* owner = dynamic_cast_or_throw_AC(TWindow*, fOwner);
	while (!fDismissed)
	{
		MSG msg;
		if (PeekMessage(&msg, NULL, 0, 0, PM_REMOVE) && !IsDialogMessage(owner->GetWindowsWindow(), &msg))
		{
			TranslateMessage(&msg);
			DispatchMessage(&msg);
		}
	}
#endif
}

//----------------------------------------------------------------------------------------
// TDialogBehavior::GetStandardSignature:
//----------------------------------------------------------------------------------------


IDType TDialogBehavior::GetStandardSignature() const
{
	return kStdDialogBehavior;
}

//----------------------------------------------------------------------------------------
// End of UDialogBehavior.cpp



/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/24/96	[1345531] Added #include "UUndo.h" for noload buids
		06/11/96	Fix a problem with undo/redo menu items when posing modally.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		----- R10 -----
		03/25/96	TToolboxEvent::fCharacter is obsolete
		03/22/96	Account for TToolBoxEvent::fCharacter being a CStr2_AC
		12/08/95	Split up includes for modular MacApp. 
		05/24/95	Add modal focus (CALib). 
		----- 3.3 -----
		10/17/95	[1292285] Filter out high level events in PoseModally.
		10/11/95	TDialogBehavior::GetStandardSignature.
		----- 3.3b1 -----
		03/13/95	Change Free methods to destructors. 
*/