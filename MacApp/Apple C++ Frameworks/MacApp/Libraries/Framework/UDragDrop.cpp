//----------------------------------------------------------------------------------------
// UDragDrop.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/20/01	Removed extra reset of fDragReference in ClearDrag.  Cosmetic.
					Added fDragReference to TDragItem and used throughout class.
					Added fDropReference and initialized in ctors and SendDataProc.
					Use fDropReference in GetDropLocationDescriptor.  Removed AOCE
					accomodations.  Do not dispose of fDragReference in ClearDrag.
					Global scoping added.
		01/02/01	Update copyright.
		11/13/00	[PB] Change initialization order to match declaration. 
		11/01/00	[PB] Include MacErrors instead of Errors. 
		10/20/00	Use UPP versions of NewDragTrackingHandlerProc, NewDragReceiveHandlerPoc
					and NewDragSendDataUPP.
		10/06/00	FlavorFlags needs to be defined for non-qDebug in DragTrackingHandler.
		10/05/00	Do not save and restore the drag reference in DragTrackingHandler.
					Added some debug code to FlavorExists.
		08/29/00	[C] Save and restore the drag reference in DragTrackingHandler.
					Cosmetic and pragma unused.
		08/15/00	Add a convenience macro for generating temp UPP classes. 
		08/08/00	[2510179] Reverse parms to TDragFlavorStream ctor and the ones passed
					to the TDragFlavorStreamRep ctor.  [2511273] Make sure a sourceCommand
					was created before using it in DragReceiveHandler.
		03/31/00	Get pointee from fDragTrackingHandlerUPP, fDragReceiveHandlerUPP and
					fDragSendDataUPP for testing in TDragDropSession ctor.
		12/08/99	Explicitly instantiate ~CRefCountingPtr_AC for SCpp.
		10/07/99	Use TemplateTempUPP_AC instead of TmplTmpRtnDescrptr.
		09/23/99	Carbon: Change TmplTmpRtnDescrptr to TmplTmpOpaqueRtnDescrptr.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		01/15/99	CAEDesc_AC is now in ACS. 
		10/08/98	Drag transaction command number. 
*/

// These includes needed for uses outside of qDrag.
#ifndef __UDRAGDROP__
#include "UDragDrop.h"
#endif

#ifndef __UCLASSDESC__
#include "UClassDesc.h"
#endif

#ifndef __UDRAGDROPBEHAVIOR__
#include "UDragDropBehavior.h"
#endif

#ifndef __UDRAGTRACKER__
#include "UDragTracker.h"
#endif

#if qDrag

// ACS

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __CStreamContext_AC__
#include "CStreamContext_AC.h"
#endif

#ifndef __TemplateUPP_AC__
#include "TemplateUPP_AC.h"
#endif

// •••  shouldn't have to include these!
#include "CBuffer_AC.h"
#include "CLinkedList_AC.h"

// MacApp

#if qAppleEventAware
	#ifndef __UAPPLEEVENTS__
	#include "UAppleEvents.h"
	#endif
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

#ifndef __UUNDO__
#include "UUndo.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// Toolbox

#if qPowerPC || qModelCFM
#ifndef __CODEFRAGMENTS__
#include <CodeFragments.h>
#endif

#endif

#ifndef __FOLDERS__
#include <Folders.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// Compatibility Hacks

#if UNIVERSAL_INTERFACES_VERSION < 0x0300

enum
{
	kDragHasLeftSenderWindow	= dragHasLeftSenderWindow
};

enum
{
	kDragTrackingEnterHandler	= dragTrackingEnterHandler,
	kDragTrackingEnterWindow	= dragTrackingEnterWindow,
	kDragTrackingInWindow		= dragTrackingInWindow,
	kDragTrackingLeaveWindow	= dragTrackingLeaveWindow,
	kDragTrackingLeaveHandler	= dragTrackingLeaveHandler
};

#endif // UNIVERSAL_INTERFACES_VERSION < 0x0300

#if defined(__SC__) && !FIXED_MPW_BUG
// SCPP forgets to make this dtor for its exception handling.
template CRefCountingPtr_AC<CStreamRep_AC>::~CRefCountingPtr_AC();
#endif

//========================================================================================
// CLASS TDragFlavorStreamRep
//========================================================================================

class TDragFlavorStreamRep : public CRandomAccessStreamRep_AC
{
public:
	TDragFlavorStreamRep(FlavorType theFlavor, ItemReference theReference);

	virtual ~TDragFlavorStreamRep();

	//------------------------------------------------------------------------------------
	// Access:
	//------------------------------------------------------------------------------------

	virtual long GetPosition() const;

	virtual void SetPosition(long newPosition);

	virtual long GetSize() const;

	virtual void ReadBytes(void* p, long count);

	virtual void WriteBytes(const void* p, long count);

protected:
	ItemReference	fItemReference;
	FlavorType		fFlavorType;
	long 			fPosition;	// offset into stream

};

//========================================================================================
// Globals
//========================================================================================

// public globals
CAutoPtr_AC<TDragDropSession> TDragDropSession::fgDragDropSession;

// private globals
CTempDragTrackingHandlerUPP 	TDragDropSession::fDragTrackingHandlerUPP;
CTempDragReceiveHandlerUPP	 	TDragDropSession::fDragReceiveHandlerUPP;
CTempDragSendDataUPP			TDragDropSession::fDragSendDataUPP;

#if qDebug
short TDragFlavorStream::fInstanceCount;		// initialize static refcount of TDragFlavorStreams
#endif // qDebug

#endif // qDrag

//----------------------------------------------------------------------------------------
// InitUDragManager
//----------------------------------------------------------------------------------------

void InitUDragManager()
{
#if qDrag
	if (HasDragManager_AC())						// balk if drag manager isn't present
	{
		TDragDropSession::fgDragDropSession = TH_new TDragDropSession;
	}
#endif
	REGISTER_SIGNATURE_AC(TDragDropBehavior, kDragDropBehavior);
}

#if qDrag

//========================================================================================
// CLASS TDragDropSession
//========================================================================================
//----------------------------------------------------------------------------------------
// TDragDropSession::TDragDropSession
//----------------------------------------------------------------------------------------

TDragDropSession::TDragDropSession()
	:	fTargetTracker(NULL),
		fDropTarget(NULL),
		fSourceTracker(NULL),
		fDragSource(NULL),
		fScroller(NULL),
		fSourceWindow(NULL),
		fTargetWindow(NULL),
		fDragReference(0L),
		fDropReference(0L),
		fDragTransaction(cNoCommand),
		fDragLeftSourceView(false),
		fTargetIsHilited(false),
		fUserRequestedCopy(false)
{
	// create universal proc pointers for the callbacks
	fDragTrackingHandlerUPP = NewDragTrackingHandlerUPP(TDragDropSession::DragTrackingHandlerGlue);
	::ThrowIfNULL_AC(fDragTrackingHandlerUPP.get());

	fDragReceiveHandlerUPP = NewDragReceiveHandlerUPP(TDragDropSession::DragReceiveHandlerGlue);
	::ThrowIfNULL_AC(fDragReceiveHandlerUPP.get());

	fDragSendDataUPP = NewDragSendDataUPP(TDragDropSession::DragSendDataProcGlue);
	::ThrowIfNULL_AC(fDragSendDataUPP.get());
}

//----------------------------------------------------------------------------------------
// TDragDropSession::~DragDropSession
//----------------------------------------------------------------------------------------

TDragDropSession::~TDragDropSession()
{
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragTrackingHandlerGlue
//----------------------------------------------------------------------------------------

pascal OSErr TDragDropSession::DragTrackingHandlerGlue(DragTrackingMessage message,
													   WindowRef theWindowMgrWindow,
													   void* handlerRefCon,
													   DragReference theDragRef)
{
	OSErr err = noErr;

	// scoped for destruction of Metrowerks destruction chain before restoring A5
	{

		// it is necessary for a failure handler to exist at this level to prevent
		// blowing away the failure handler stack while in drag manager callbacks
		try
		{
			fgDragDropSession->DragTrackingHandler(message, theWindowMgrWindow, handlerRefCon, theDragRef);
		}
		catch(CException_AC& theException)
		{
			DoCatchMessage_AC(theException);
			err = theException.GetError();					// don't resignal - we're in a callback
		}

	}

	return err;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragReceiveHandlerGlue
//----------------------------------------------------------------------------------------

pascal OSErr TDragDropSession::DragReceiveHandlerGlue(WindowRef theWindowMgrWindow,
													  void* handlerRefCon,
													  DragReference theDragRef)
{
	OSErr err = noErr;

	// scoped for destruction of Metrowerks destruction chain before restoring A5
	{
		// it is necessary for a failure handler to exist at this level to prevent
		// blowing away the failure handler stack while in drag manager callbacks
		try
		{
			err = fgDragDropSession->DragReceiveHandler(theWindowMgrWindow, handlerRefCon, theDragRef);
		}
		catch(CException_AC& theException)
		{
			DoCatchMessage_AC(theException);
			err = theException.GetError();					// don't resignal - we're in a callback
		}

#if qDebug
		TDragFlavorStream::CheckInstanceCount();// test the TDragFlavorStream instance count
#endif

	}

	return err;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragSendDataProcGlue
//----------------------------------------------------------------------------------------

pascal OSErr TDragDropSession::DragSendDataProcGlue(FlavorType theType,
													void* dragSendDataRefCon,
													ItemReference theItemRef,
													DragReference theDragRef)
{
	OSErr err = noErr;

	// scoped for destruction of Metrowerks destruction chain before restoring A5
	{

		// it is necessary for a failure handler to exist at this level to prevent
		// blowing away the failure handler stack while in drag manager callbacks
		try
		{
			fgDragDropSession->DragSendDataProc(theType, dragSendDataRefCon, theItemRef, theDragRef);
		}
		catch(CException_AC& theException)
		{
			DoCatchMessage_AC(theException);
			err = theException.GetError();					// don't resignal
		}
	}

	return err;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragTrackingHandler
//----------------------------------------------------------------------------------------

void TDragDropSession::DragTrackingHandler(DragTrackingMessage	message,
										   WindowRef			theWindowMgrWindow,
										   void*				handlerRefCon,
										   DragReference		theDragRef)
{
	#pragma unused (theWindowMgrWindow)
	// •••  Hmmm.  We receiving a drag reference here.  Do we need to check to see
	// if we already had one and if so should we dispose of it?
	fDragReference = theDragRef;

	// Account for the case that the drag manager has changed the port behind our back.
	static GrafPtr	lastTrackingPort;
	GrafPtr			thePort;

	GetPort(&thePort);

	if (thePort != lastTrackingPort)
		gDispatcher->InvalidateFocus();

	switch (message)
	{
		case kDragTrackingEnterHandler:
			HandleEnterHandler();
			break;

		case kDragTrackingLeaveHandler:
			HandleLeaveHandler();
			break;

		case kDragTrackingEnterWindow:
			HandleEnterWindow(static_cast<TWindow*>(handlerRefCon));
			break;

		case kDragTrackingLeaveWindow:
			HandleLeaveWindow();
			break;

		case kDragTrackingInWindow:
			HandleTrackInWindow();
			break;

		default:
			break;
	}

	GetPort(&lastTrackingPort);			// Save to test against for next entry to handler.
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragReceiveHandler
//----------------------------------------------------------------------------------------

OSErr TDragDropSession::DragReceiveHandler(WindowRef		theWindowMgrWindow,
										   void*			handlerRefCon,
										   DragReference	theDragRef)
{
	#pragma unused (theWindowMgrWindow, handlerRefCon)
	OSErr returnValue = noErr;

	if (fDropTarget)
	{
		CTempDesc_AC dropLocationDesc;
		TCommand* sourceCommand = NULL;
		TCommand* targetCommand = NULL;

		if (MakeDropLocationDescriptor(dropLocationDesc))
			SetDropLocation(theDragRef, dropLocationDesc);

		CDragItemIterator dragItemIterator(&fDragItemList);

		if (fDragSource && !UserRequestedCopy() && WillDragMove(fDropTarget))
		{
			if (fDragSource->DoGetDragProxy() == fDropTarget->DoGetDragProxy())
				targetCommand = MakeMoveCommand(dragItemIterator);
			else
			{
				sourceCommand = MakeDragCommand(dragItemIterator);
				if (sourceCommand)
					sourceCommand->SetIdentifier(cDragMoveOut);

				dragItemIterator.First();			// reset the iterator
				targetCommand = MakeDropCommand(dragItemIterator);
			}
		}
		else
			targetCommand = MakeDropCommand(dragItemIterator);

		if (targetCommand)							// should always have a target command
		{
			if (sourceCommand)
				sourceCommand->GetContext()->PostCommand(sourceCommand);// source command is primary

			targetCommand->GetContext()->PostCommand(targetCommand);// target command is primary

			if (sourceCommand && (sourceCommand->GetUndoHandler() == targetCommand->GetUndoHandler()))
				fDragTransaction = cDragMove;

			// if this process is in the background, it is possible for
			// it to be sitting in WaitNextEvent with an infinite sleep value.
			// waking the process will cause the command(s) that were just posted
			// to be processed immediately.
			if (!gDispatcher->IsFrontProcess())
				gDispatcher->WakeProcess();

			if (!fDragSource)
				gDispatcher->PostCommand(TH_new TInvalCursorCommand);
		}
		else
		{
			returnValue = dragNotAcceptedErr;
#if qDebug
			// its an error if a source command was provided without a target
			if (sourceCommand)
			{
				::ProgramBreak_AC("###Drag source provided a target, drop target did not.");
				delete sourceCommand;
			}
#endif
		}

		SetDropTarget(NULL);					// allow the view to clean up
		fUserRequestedCopy = false;				// reset user request for copy
	}
	else
		returnValue = dragNotAcceptedErr;

	return returnValue;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragSendDataProc
//----------------------------------------------------------------------------------------

void TDragDropSession::DragSendDataProc(FlavorType		theType,
										void*			dragSendDataRefCon,
										ItemReference	theItemRef,
										DragReference	theDragRef)
{
	#pragma unused (dragSendDataRefCon)

	// Note: Under Mac OS X, the drag reference is no longer reliable from
	// creation to destruction.
	fDropReference = theDragRef;
	GetDropLocationDescriptor(fDropLocation);	// Remember drop location in case it is the Trash.

	TDragItem promisedItem(theDragRef, theItemRef);
	promisedItem.FocusOnFlavor(theType);

	fSourceTracker->DoFulfillPromise(&promisedItem);
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HandleEnterHandler
//----------------------------------------------------------------------------------------

void TDragDropSession::HandleEnterHandler()
{
	// initialize the flavor list
	fDragItemList.BuildListFromDrag();

	fDropTarget = NULL;
	fTargetWindow = NULL;
	fTargetIsHilited = false;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HandleLeaveHandler
//----------------------------------------------------------------------------------------

void TDragDropSession::HandleLeaveHandler()
{
	for (TemplateIterator_AC<TDragItem*> iter(&fDragItemList); iter; ++iter)
		delete iter.Current();
	fDragItemList.DeleteAll();
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HandleEnterWindow
//----------------------------------------------------------------------------------------

void TDragDropSession::HandleEnterWindow(TWindow* targetWindow)
{
	if (!(gDispatcher->InModalState() && (gDispatcher->GetFrontWindow() != targetWindow)))
	{
		CDragItemIterator dragItemIterator(&fDragItemList);
		targetWindow->DragEnteredWindow(dragItemIterator);

		fTargetWindow = targetWindow;
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HandleLeaveWindow
//----------------------------------------------------------------------------------------

void TDragDropSession::HandleLeaveWindow()
{
	SetDropTarget(NULL);					// clear the current drop target

	if (fTargetWindow)
	{
		fTargetWindow->DragLeftWindow();		// notify the window
		fTargetWindow = NULL;					// reset data
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HandleTrackInWindow
//----------------------------------------------------------------------------------------

void TDragDropSession::HandleTrackInWindow()
{
	if (fTargetWindow && !HandleAutoScroll())
	{
		CPoint_AC theMouse;
		CPoint_AC pinnedMouse;

		GetDragMouse(fDragReference, theMouse, pinnedMouse);

		CDragItemIterator dragItemIterator(&fDragItemList);
		CViewPoint localPoint;
		TView* newTarget = fTargetWindow->MouseToDropTarget(dragItemIterator, pinnedMouse, localPoint);

		SetDropTarget(newTarget);

		DragWithin(localPoint);
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HandleAutoScroll
//----------------------------------------------------------------------------------------

bool TDragDropSession::HandleAutoScroll()
{
	bool didScroll = false;

	if (fScroller /* not for target autoscroll && fTargetWindow == fSourceWindow && fSourceWindow->IsActive() */
		&& fScroller->Focus())
	{
		CPoint_AC pinnedMouse;
		CPoint_AC theMouse;

		GetDragMouse(fDragReference, theMouse, pinnedMouse);

		CViewPoint delta(fScroller->GetDragScrollDelta(fTargetWindow->SuperViewToLocal(pinnedMouse)));
		if (delta != gZeroPt)
		{
			TScroller* aScroller = fScroller; // will be cleared
			SetDropTarget(NULL);			// clear the drop target

			aScroller->ScrollBy(delta, kRedraw);// scroll and inval
			aScroller->Update();				// redraw content
			didScroll = true;
		}
	}

	return didScroll;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HandleDragToTrash
//----------------------------------------------------------------------------------------

bool TDragDropSession::HandleDragToTrash()
{
	bool draggedToTrash = false;

	if (!UserRequestedCopy()
		&& IsDropLocationFinderTrash()
		&& fDragSource
		&& fDragSource->GetDragMoveDeterminer() != kNeverMove)
	{
		CDragItemIterator dragItemIterator(&fDragItemList);
		TCommand* dragCommand = MakeDragCommand(dragItemIterator);
		if (dragCommand)
		{
			dragCommand->GetContext()->PostCommand(dragCommand);
			fDragTransaction = cClear;
		}

		if (!gDispatcher->IsFrontProcess())
			gDispatcher->WakeProcess();			// time to wake up...

		draggedToTrash = true;
	}

	return draggedToTrash;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::GetGlobalDragMouse
//----------------------------------------------------------------------------------------

void TDragDropSession::GetGlobalDragMouse(CPoint_AC& mouse,
										  CPoint_AC& pinnedMouse)
{
	::ThrowIfOSErr_AC(GetDragMouse(fDragReference, mouse, pinnedMouse));
}

//----------------------------------------------------------------------------------------
// TDragDropSession::SetGlobalPinnedDragMouse
//----------------------------------------------------------------------------------------

void TDragDropSession::SetGlobalPinnedDragMouse(CPoint_AC& pinnedMouse)
{
	::ThrowIfOSErr_AC(SetDragMouse(fDragReference, pinnedMouse));
}

//----------------------------------------------------------------------------------------
// TDragDropSession::SetDropTarget
//----------------------------------------------------------------------------------------

void TDragDropSession::SetDropTarget(TView* newDropTarget)
{
	// track whether drag has left the source view
	if (!fDragLeftSourceView && (newDropTarget != fDragSource))
		fDragLeftSourceView = true;

	if (fDropTarget != newDropTarget)
	{
		DragLeave();

		DeleteTargetTracker();

		fDropTarget = newDropTarget;
		if (!fDropTarget)
			fScroller = NULL; // Added so that we don't crash due to a stale scroller

		MakeTargetTracker();

		DragEnter();
	}
	else
	{
		// Reset the scroller if the drop failed: scroller reference may
		// become stale otherwise.
		fScroller = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::RegisterDroppableWindow
//----------------------------------------------------------------------------------------

void TDragDropSession::RegisterDroppableWindow(TWindow* theWindow,
											   WindowRef theWindowMgrWindow)
{
	// register a window with the Drag Manager.

#if qDebug
	if (!HasDragManager_AC())
	{
		::ProgramBreak_AC("Window tried to register w/DragSession when drag isn't available.");
		return;
	}
#endif

	try
	{
		::ThrowIfOSErr_AC(InstallTrackingHandler(fDragTrackingHandlerUPP, theWindowMgrWindow, theWindow));

		::ThrowIfOSErr_AC(InstallReceiveHandler(fDragReceiveHandlerUPP, theWindowMgrWindow, theWindow));
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);

		RemoveTrackingHandler(fDragTrackingHandlerUPP, theWindowMgrWindow);
		RemoveReceiveHandler(fDragReceiveHandlerUPP, theWindowMgrWindow);
	}

}

//----------------------------------------------------------------------------------------
// TDragDropSession::UnregisterDroppableWindow
//----------------------------------------------------------------------------------------

void TDragDropSession::UnregisterDroppableWindow(WindowRef theWindowMgrWindow)
{
#if qDebug
	if (!HasDragManager_AC())
	{
		::ProgramBreak_AC("Window tried to unregister w/DragSession when drag isn't available.");
		return;
	}
#endif

		::RemoveTrackingHandler(fDragTrackingHandlerUPP, theWindowMgrWindow);
		::RemoveReceiveHandler(fDragReceiveHandlerUPP, theWindowMgrWindow);
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HasDragLeftSenderWindow
//----------------------------------------------------------------------------------------

bool TDragDropSession::HasDragLeftSenderWindow() const
{
	DragAttributes attributes;
	::GetDragAttributes(fDragReference, &attributes);

	return (attributes & kDragHasLeftSenderWindow) == kDragHasLeftSenderWindow;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::ShowDropTargetHilite
//----------------------------------------------------------------------------------------

void TDragDropSession::ShowDropTargetHilite()
{
	if (fDragLeftSourceView && fDropTarget)
	{
		CTempRegion_AC hiliteRegion(fDropTarget->DoMakeDropHiliteRegion());

		::ShowDragHilite(fDragReference, hiliteRegion, true);

		fTargetWindow->Focus();
		fTargetIsHilited = true;
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::HideDropTargetHilite
//----------------------------------------------------------------------------------------

void TDragDropSession::HideDropTargetHilite()
{
	if (fTargetIsHilited)
	{
		fDropTarget->Focus();
		HideDragHilite(fDragReference);

		fTargetWindow->Focus();
		fTargetIsHilited = false;
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::GetItemCount
//----------------------------------------------------------------------------------------

unsigned short TDragDropSession::GetItemCount()
{
	return fDragItemList.GetSize();
}

//----------------------------------------------------------------------------------------
// TDragDropSession::UserIsDragging
//----------------------------------------------------------------------------------------

bool TDragDropSession::UserIsDragging(CPoint_AC& mousePoint)
{

	return WaitMouseMoved(mousePoint);
}

//----------------------------------------------------------------------------------------
// TDragDropSession::UserRequestedCopy
//----------------------------------------------------------------------------------------

bool TDragDropSession::UserRequestedCopy()
{
	if (!fUserRequestedCopy && IsOptionKeyDown())
		fUserRequestedCopy = true;

	return fUserRequestedCopy;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::ClearDrag
//----------------------------------------------------------------------------------------

void TDragDropSession::ClearDrag()
{
#if !qProjectBuilder
	// •••  I haven't figured out why it is necessary to _not_ DisposeDrag
	// when building with Project Builder yet.
	if (fDragReference)
		::DisposeDrag(fDragReference);
#endif
	DeleteTargetTracker();
	fDropTarget = NULL;
	fSourceTracker = NULL;	// Don't delete the source tracker; it belongs to the command queue
	fDragSource = NULL;
	fDragReference = 0L;
	fScroller = NULL;
	fSourceWindow = NULL;
	fTargetWindow = NULL;

	for (TemplateIterator_AC<TDragItem*> iter(&fDragItemList); iter; ++iter)
		delete iter.Current();
	fDragItemList.DeleteAll();

	fDragLeftSourceView = false;
	fTargetIsHilited = false;
	fUserRequestedCopy = false;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::StartDrag
//----------------------------------------------------------------------------------------

void TDragDropSession::StartDrag(TView*			sourceView,
								 TToolboxEvent*	event,
								 RgnHandle		dragRegion)
{
	StartDrag(sourceView, event->GetEventRecord(0), dragRegion);
}

//----------------------------------------------------------------------------------------
// TDragDropSession::StartDrag
//----------------------------------------------------------------------------------------

void TDragDropSession::StartDrag(TView*				sourceView,
								 const EventRecord&	event,
								 RgnHandle			dragRegion,
								 TDragTracker*		tracker)
{
	OSErr dragErr;

	fSourceTracker = tracker;
	fDragSource = sourceView;

	UserRequestedCopy();					// test for copy override
	fScroller = fDragSource->GetScroller(false);
	fSourceWindow = sourceView->GetWindow();

	bool oldBusyCursorState = gDispatcher->ActivateBusyCursor(false);

	fDragTransaction = cNoCommand;
	TUndoHandler* undoHandler = sourceView->GetUndoHandler();
	if (undoHandler)
		undoHandler->BeginAction();

	dragErr = ::TrackDrag(fDragReference, &event, dragRegion);

	// Must refocus on the source. Otherwise the port and the source
	// will get out of synch
	sourceView->Focus();

	if (dragErr == noErr)
		HandleDragToTrash();

	if (undoHandler)
		undoHandler->EndAction(fDragTransaction);

	gDispatcher->PostCommand(TH_new TInvalCursorCommand);

	gDispatcher->ActivateBusyCursor(oldBusyCursorState);

	ClearDrag();
}

//----------------------------------------------------------------------------------------
// TDragDropSession::AddDragItem
//----------------------------------------------------------------------------------------

TDragItem* TDragDropSession::AddDragItem(ItemReference theItemRef)
{
	if (fDragItemList.IsEmpty())				// create a new drag manager drag
	{
		::ThrowIfOSErr_AC(::NewDrag(&fDragReference));
		::ThrowIfOSErr_AC(::SetDragSendProc(fDragReference, fDragSendDataUPP, NULL));
	}

	TDragItem* newItem = TH_new TDragItem(fDragReference, theItemRef);
	fDragItemList.InsertElementInOrder(&newItem);

	return newItem;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::GetDragItemByIndex
//----------------------------------------------------------------------------------------

TDragItem* TDragDropSession::GetDragItemByIndex(unsigned short index)
{
	TDragItem* indexedItem = static_cast<TDragItem*>(fDragItemList.At(index));
	indexedItem->SetPosition(0);

	return indexedItem;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::GetDragItemByReference
//----------------------------------------------------------------------------------------

TDragItem* TDragDropSession::GetDragItemByReference(ItemReference itemReference)
{
	TDragItem* returnVal = NULL;
	for (CDragItemIterator iter(&fDragItemList); iter.Current(); ++iter)
		if ((*iter).GetItemReference() == itemReference)
		{
			(*iter).SetPosition(0);	
			returnVal = iter;
			break;
		}

	if (!returnVal)
		::ThrowException_AC(minErr, 0);

	return returnVal;
}

#if qAppleEventAware

//----------------------------------------------------------------------------------------
// TDragDropSession::GetDropLocationDescriptor
//----------------------------------------------------------------------------------------

void TDragDropSession::GetDropLocationDescriptor(CAEDesc_AC& dropLocationDesc) const
// GetDropLocationDescriptor constructs an AEDesc for the drop location.
//
// dropLocationDesc:	A reference to a CAEDesc_AC in which the location's AEDesc
//						is placed.
//
// Call?	As needed.  MacApp calls this to determine if the drop location is the
//			Trash.
{
	::ThrowIfOSErr_AC(::GetDropLocation(fDropReference, dropLocationDesc));
}

#endif	// #if qAppleEventAware

//----------------------------------------------------------------------------------------
// TDragDropSession::IsDropLocationFinderTrash
//----------------------------------------------------------------------------------------

bool TDragDropSession::IsDropLocationFinderTrash() const
{
	bool result = false;

#if qAppleEventAware

	CTempDesc_AC dropLocation;

	if (!fDropTarget)
	{
		try
		{
			CInfoPBRec cpb;

			if (!fDropLocation.CanCoerceDesc(typeFSS))
				result = false;
			else
			{
				CFSSpec_AC dropLocationSpec(fDropLocation.GetFSSpec());

				cpb.dirInfo.ioNamePtr = dropLocationSpec.name;// get destination's info
				cpb.dirInfo.ioVRefNum = dropLocationSpec.vRefNum;
				cpb.dirInfo.ioFDirIndex = 0;
				cpb.dirInfo.ioDrDirID = dropLocationSpec.parID;

				::ThrowIfOSErr_AC(PBGetCatInfoSync(&cpb));

				if ((cpb.dirInfo.ioFlAttrib & (1 << 4)) == (1 << 4))// it's a directory
				{
					short trashVRefNum;
					long trashDirID;

					::ThrowIfOSErr_AC(FindFolder(cpb.dirInfo.ioVRefNum, kTrashFolderType, kDontCreateFolder, &trashVRefNum, &trashDirID));

					if (cpb.dirInfo.ioDrDirID == trashDirID)
						result = true;
				}
			}
		}
		catch(CException_AC& theException)
		{
			DoCatchMessage_AC(theException);
			result = false;
		}

	}

#endif	// #if qAppleEventAware

	return result;
}

//----------------------------------------------------------------------------------------
// TDragDropSession::MakeTargetTracker
//----------------------------------------------------------------------------------------

void TDragDropSession::MakeTargetTracker()
{
	if (fDropTarget)
	{
		fTargetTracker = (fDropTarget == fDragSource) ? fSourceTracker : NULL;
		if (!fTargetTracker)
			fTargetTracker = fDropTarget->DoMakeDragTracker(cDrop);
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DeleteTargetTracker
//----------------------------------------------------------------------------------------

void TDragDropSession::DeleteTargetTracker()
{
	if (fTargetTracker)
	{
		if (fTargetTracker != fSourceTracker)
			delete fTargetTracker;

		fTargetTracker = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragEnter
//----------------------------------------------------------------------------------------

void TDragDropSession::DragEnter()
{
	if (fDropTarget)
	{
		fScroller = fDropTarget->GetScroller(false); // added so that we can autoscroll the target

		fDropTarget->Focus();
		fTargetTracker->DoDragEnter();			// target the new target

		ShowDropTargetHilite();
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragWithin
//----------------------------------------------------------------------------------------

void TDragDropSession::DragWithin(const CViewPoint& localMouse)
{
	if (fDropTarget)
	{
		fDropTarget->Focus();
		fTargetTracker->DoDragWithin(localMouse);
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::DragLeave
//----------------------------------------------------------------------------------------

void TDragDropSession::DragLeave()
{
	if (fDropTarget)
	{
		fDropTarget->Focus();
		fTargetTracker->DoDragLeave();			// resign the current target

		HideDropTargetHilite();		// unhilite the current target
	}
}

//----------------------------------------------------------------------------------------
// TDragDropSession::MakeDropLocationDescriptor
//----------------------------------------------------------------------------------------

bool TDragDropSession::MakeDropLocationDescriptor(CAEDesc_AC& dropLocationDesc)
{
	return fTargetTracker->MakeDropLocationDescriptor(dropLocationDesc);
}

//----------------------------------------------------------------------------------------
// TDragDropSession::WillDragMove
//----------------------------------------------------------------------------------------

bool TDragDropSession::WillDragMove(TView* destinationView)
{
	return fSourceTracker->WillDragMove(destinationView);
}

//----------------------------------------------------------------------------------------
// TDragDropSession::MakeMoveCommand
//----------------------------------------------------------------------------------------

TCommand* TDragDropSession::MakeMoveCommand(CDragItemIterator& dragItemIterator)
{
	return fSourceTracker->DoMakeDragDropCommand(cDragMove, dragItemIterator, fTargetTracker);
}

//----------------------------------------------------------------------------------------
// TDragDropSession::MakeDragCommand
//----------------------------------------------------------------------------------------

TCommand* TDragDropSession::MakeDragCommand(CDragItemIterator& dragItemIterator)
{
	return fSourceTracker->DoMakeDragDropCommand(cDrag, dragItemIterator);
}

//----------------------------------------------------------------------------------------
// TDragDropSession::MakeDropCommand
//----------------------------------------------------------------------------------------

TCommand* TDragDropSession::MakeDropCommand(CDragItemIterator& dragItemIterator)
{
	return fTargetTracker->DoMakeDragDropCommand(cDrop, dragItemIterator);
}


//========================================================================================
// CLASS TDragItemList
//========================================================================================

MA_DEFINE_CLONE(TDragItemList);

//----------------------------------------------------------------------------------------
// TDragItemList::~TDragItemList
//----------------------------------------------------------------------------------------

TDragItemList::~TDragItemList()
{
}

//----------------------------------------------------------------------------------------
// TDragItemList::BuildListFromDrag
//----------------------------------------------------------------------------------------

void TDragItemList::BuildListFromDrag()
{
	DragReference dragReference = TDragDropSession::fgDragDropSession->GetDragReference();

	for (TemplateIterator_AC<TDragItem*> iter(this); iter; ++iter)
		delete iter.Current();
	DeleteAll();

	unsigned short itemCount;
	::ThrowIfOSErr_AC(::CountDragItems(dragReference, &itemCount));

	for (unsigned short itemIndex = 1; itemIndex <= itemCount; ++itemIndex)
	{
		ItemReference itemReference;
		::ThrowIfOSErr_AC(::GetDragItemReferenceNumber(dragReference, itemIndex, &itemReference));

		TDragItem* dragItem = TH_new TDragItem(dragReference, itemReference);
		InsertLast(dragItem);
	}
}

//========================================================================================
// CLASS TDragItem
//========================================================================================

//----------------------------------------------------------------------------------------
// TDragItem::TDragItem
//----------------------------------------------------------------------------------------

TDragItem::TDragItem(DragReference dragReference, ItemReference itemReference)
	:	fDragReference(dragReference),
		fItemReference(itemReference),
		fFlavorType(kAllQuestionsType_AC),
		fFlavorOffset(0)
{
}

//----------------------------------------------------------------------------------------
// TDragItem::~TDragItem
//----------------------------------------------------------------------------------------

TDragItem::~TDragItem()
{
}

//----------------------------------------------------------------------------------------
// TDragItem::AddFlavor
//----------------------------------------------------------------------------------------

void TDragItem::AddFlavor(FlavorType newFlavor,
						  CFlavorFlags& flavorFlags,
						  void* buffer,
						  long count)
{
	::ThrowIfOSErr_AC(::AddDragItemFlavor(fDragReference, fItemReference, newFlavor, buffer, count, flavorFlags));
	FocusOnFlavor(newFlavor);
	fFlavorOffset = count;
}

//----------------------------------------------------------------------------------------
// TDragItem::PromiseFlavor
//----------------------------------------------------------------------------------------

void TDragItem::PromiseFlavor(FlavorType newFlavor,
							  CFlavorFlags& flavorFlags)
{
	::ThrowIfOSErr_AC(::AddDragItemFlavor(fDragReference, fItemReference, newFlavor, NULL, 0L, flavorFlags));
	FocusOnFlavor(newFlavor);
}

//----------------------------------------------------------------------------------------
// TDragItem::CountFlavors
//----------------------------------------------------------------------------------------

unsigned short TDragItem::CountFlavors()
{
	unsigned short flavorCount;

	::ThrowIfOSErr_AC(::CountDragItemFlavors(fDragReference, fItemReference, &flavorCount));

	return flavorCount;
}

//----------------------------------------------------------------------------------------
// TDragItem::FlavorExists
//----------------------------------------------------------------------------------------

bool TDragItem::FlavorExists(FlavorType requestedFlavor)
{
	FlavorFlags			flags;

#if qDebug
	// The following has been added to aid in debugging drag problems.  You can inspect
	// the items and flavors of the current drag references.  Set a breakpoint here and
	// follow through the two loops to see what you have.

	unsigned short		itemCount;
	OSStatus 			anErr;
	
	anErr = ::CountDragItems(fDragReference, &itemCount);
	for (unsigned short i = 1; anErr == noErr && i <= itemCount; i++)
	{
		ItemReference		itemRef;
		unsigned short		flavorCount;

		anErr = ::GetDragItemReferenceNumber(fDragReference, i, &itemRef);
		if (anErr == noErr)
		{
			anErr = ::CountDragItemFlavors(fDragReference, itemRef, &flavorCount);
			for (unsigned short j = 1; anErr == noErr && j <= flavorCount; j++)
			{
				FlavorType			flavorType;

				anErr = ::GetFlavorType(fDragReference, itemRef, j, &flavorType);
			}
		}
	}
#endif

	return (::GetFlavorFlags(fDragReference, fItemReference, requestedFlavor, &flags) == noErr) ? true : false;
}

//----------------------------------------------------------------------------------------
// TDragItem::FocusOnFlavor
//----------------------------------------------------------------------------------------

void TDragItem::FocusOnFlavor(FlavorType focusFlavor)
{
	fFlavorOffset = 0;

	if (FlavorExists(focusFlavor))
		fFlavorType = focusFlavor;
	else
		::ThrowIfOSErr_AC(badDragFlavorErr);
}

//----------------------------------------------------------------------------------------
// TDragItem::GetPosition
//----------------------------------------------------------------------------------------

long TDragItem::GetPosition()
{
	return fFlavorOffset;
}

//----------------------------------------------------------------------------------------
// TDragItem::SetPosition
//----------------------------------------------------------------------------------------

void TDragItem::SetPosition(long newPosition)
{
	fFlavorOffset = newPosition;
}

//----------------------------------------------------------------------------------------
// TDragItem::GetBounds
//----------------------------------------------------------------------------------------

CRect_AC TDragItem::GetBounds()
{
	CRect_AC itemBounds;

	::ThrowIfOSErr_AC(::GetDragItemBounds(fDragReference, fItemReference, itemBounds));

	return itemBounds;
}

//----------------------------------------------------------------------------------------
// TDragItem::SetBounds
//----------------------------------------------------------------------------------------

void TDragItem::SetBounds(CRect_AC& itemBounds)
{
	if (!itemBounds.IsEmpty())
		::ThrowIfOSErr_AC(::SetDragItemBounds(fDragReference, fItemReference, itemBounds));
}

//----------------------------------------------------------------------------------------
// TDragItem::GetSize
//----------------------------------------------------------------------------------------

long TDragItem::GetSize() const
{
	long dataSize;

	::ThrowIfOSErr_AC(::GetFlavorDataSize(fDragReference, fItemReference, fFlavorType, &dataSize));

	return dataSize;
}

//----------------------------------------------------------------------------------------
// TDragItem::GetFlags
//----------------------------------------------------------------------------------------

CFlavorFlags TDragItem::GetFlags()
{
	CFlavorFlags flags;

	::ThrowIfOSErr_AC(::GetFlavorFlags(fDragReference, fItemReference, fFlavorType, flags));

	return flags;
}

//----------------------------------------------------------------------------------------
// TDragItem::GetFlavorType
//----------------------------------------------------------------------------------------

FlavorType TDragItem::GetFlavorType()
{
	return fFlavorType;
}

//----------------------------------------------------------------------------------------
// TDragItem::GetData
//----------------------------------------------------------------------------------------

void TDragItem::GetData(void* buffer,
						long& count)
{
	::ThrowIfOSErr_AC(::GetFlavorData(fDragReference, fItemReference, fFlavorType, buffer, &count, fFlavorOffset));
	fFlavorOffset += count;
}

//----------------------------------------------------------------------------------------
// TDragItem::GetDataAsHandle
//----------------------------------------------------------------------------------------

Handle TDragItem::GetDataAsHandle()
{
	TDragFlavorStream dragFlavorStream(fFlavorType, fItemReference);
	dragFlavorStream.SetPosition(fFlavorOffset);

	Handle dataHandle = StreamToHandle(&dragFlavorStream);

	fFlavorOffset = dragFlavorStream.GetPosition();

	return dataHandle;
}

//----------------------------------------------------------------------------------------
// TDragItem::SetData
//----------------------------------------------------------------------------------------

void TDragItem::SetData(void* buffer,
						long count)
{
	::ThrowIfOSErr_AC(::SetDragItemFlavorData(fDragReference, fItemReference, fFlavorType, buffer, count, fFlavorOffset));
	fFlavorOffset += count;
}

//----------------------------------------------------------------------------------------
// TDragItem::SetDataFromHandle
//----------------------------------------------------------------------------------------

void TDragItem::SetDataFromHandle(Handle dataHandle)
{
	if (!dataHandle)
		::ThrowException_AC(minErr, 0);

	CTempHandleLock_AC tempHandleLock(dataHandle);
	Size dataSize = GetHandleSize(dataHandle);
	::ThrowIfMemError_AC();

	SetData(*dataHandle, dataSize);
}

//----------------------------------------------------------------------------------------
// TDragItem::GetDataStream
//----------------------------------------------------------------------------------------

TDragFlavorStream* TDragItem::GetDataStream()
{
	return TH_new TDragFlavorStream(fFlavorType, fItemReference);
}

//========================================================================================
// CLASS ~TDragFlavorStreamRep
//========================================================================================

MA_DEFINE_CLONE(TDragFlavorStream);

//----------------------------------------------------------------------------------------
// TDragFlavorStream::TDragFlavorStream
//----------------------------------------------------------------------------------------

TDragFlavorStreamRep::TDragFlavorStreamRep(FlavorType theFlavor, ItemReference theReference)
	:	fItemReference(theReference),
		fFlavorType(theFlavor),
		fPosition(0)
{
}

//----------------------------------------------------------------------------------------
// TDragFlavorStreamRep::~TDragFlavorStreamRep
//----------------------------------------------------------------------------------------

TDragFlavorStreamRep::~TDragFlavorStreamRep()
{
}

//----------------------------------------------------------------------------------------
// TDragFlavorStream::GetPosition
//----------------------------------------------------------------------------------------

long TDragFlavorStreamRep::GetPosition() const
{
	return fPosition;
}

//----------------------------------------------------------------------------------------
// TDragFlavorStreamRep::SetPosition
//----------------------------------------------------------------------------------------

void TDragFlavorStreamRep::SetPosition(long newPosition)
{
	OSErr err = noErr;
	long dataSize;

	dataSize = GetSize();

	if (newPosition < 0)						// Same error returned by File Manager
		::ThrowIfOSErr_AC(posErr);
	else if (newPosition > dataSize)			// Hit the end of the stream
	{
		newPosition = dataSize;					// Position to end of stream
		err = eofErr;
	}

	fPosition = newPosition;
	::ThrowIfOSErr_AC(err);
}

//----------------------------------------------------------------------------------------
// TDragFlavorStreamRep::GetSize
//----------------------------------------------------------------------------------------

long TDragFlavorStreamRep::GetSize() const
{
	long dataSize;
	OSErr err = GetFlavorDataSize(TDragDropSession::fgDragDropSession->GetDragReference(), fItemReference, fFlavorType, &dataSize);
	if (err != noErr)
		dataSize = 0L;

	return dataSize;
}

//----------------------------------------------------------------------------------------
// TDragFlavorStreamRep::ReadBytes
//----------------------------------------------------------------------------------------

void TDragFlavorStreamRep::ReadBytes(void* p,
								  long count)
{
	if (count < 0)
		::ThrowIfOSErr_AC(paramErr);					// Negative count request

	if (GetSize() - fPosition < count)
		::ThrowIfOSErr_AC(eofErr);						// about to read past end of stream

	// read the bytes
	long bytesRead = count;
	::ThrowIfOSErr_AC(GetFlavorData(TDragDropSession::fgDragDropSession->GetDragReference(), fItemReference, fFlavorType, p, &bytesRead, fPosition));
	fPosition += bytesRead;
}

//----------------------------------------------------------------------------------------
// TDragFlavorStreamRep::WriteBytes
//----------------------------------------------------------------------------------------

void TDragFlavorStreamRep::WriteBytes(const void* p,
								   long count)
{
	::ThrowIfOSErr_AC(SetDragItemFlavorData(TDragDropSession::fgDragDropSession->GetDragReference(), fItemReference, fFlavorType, p, count, fPosition));
	fPosition += count;
}

//========================================================================================
// CLASS TDragFlavorStream
//========================================================================================

//----------------------------------------------------------------------------------------
// TDragFlavorStream::TDragFlavorStream
//----------------------------------------------------------------------------------------

TDragFlavorStream::TDragFlavorStream(FlavorType theFlavor, ItemReference theReference)
	:	CRandomAccessStream_AC(TH_new TDragFlavorStreamRep(theFlavor, theReference))
{
#if qDebug
	++fInstanceCount;							// increment the instance counter
#endif
}

//----------------------------------------------------------------------------------------
// TDragFlavorStream::~TDragFlavorStream
//----------------------------------------------------------------------------------------

TDragFlavorStream::~TDragFlavorStream()
{
#if qDebug
	--fInstanceCount;							// decrement the instance counter
#endif
}

#if qDebug

//----------------------------------------------------------------------------------------
// TDragFlavorStreamRep::CheckReferenceCount
//----------------------------------------------------------------------------------------

void TDragFlavorStream::CheckInstanceCount()
{
	// This method is called by TDragSession before returning control to the drag manager
	// after receiving a drop.  Any existing instances of TDragFlavorStream are about to
	// become invalid. If a positive instance count exists, a program break is
	// generated.
	if (fInstanceCount)
	{
		::ProgramBreak_AC("###TDragFlavorStream failed instance count check");
		fInstanceCount = 0;						// reset the count
	}
}

#endif // qDebug

//========================================================================================
// CLASS TInvalCursorCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TInvalCursorCommand::TInvalCursorCommand
//----------------------------------------------------------------------------------------

TInvalCursorCommand::TInvalCursorCommand()
	:	TCommand(cNoCommand, NULL, kCantUndo, kDoesNotCauseChange, NULL)
{
}

//----------------------------------------------------------------------------------------
// TInvalCursorCommand::DoIt
//----------------------------------------------------------------------------------------

void TInvalCursorCommand::DoIt()
{
	// Compute based on where the mouse is right now
	CPoint_AC globalMouse;

	::GetMouse(globalMouse);
	::LocalToGlobal(globalMouse);

	gDispatcher->UpdateAllWindows();			// necessary for calculation of visible regions
	gDispatcher->InvalidateMouseRegions();
	gDispatcher->TrackCursor(globalMouse);
}

#endif // qDrag

//----------------------------------------------------------------------------------------
// End of UDragDrop.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		06/13/96	Fix bug in grouped commands where the source and target commands were not
							separately identified when using !qUseODUndoStyle
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		 5/08/96	Create and use CFSSpec_AC. You should search/replace in your code to switch to
		 					CFSSpec_AC.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Update iterators to be OD stylish.
		04/18/96	More Use post-increment with iterators in while loops
		----- R10 -----
		  4/3/96	"FragLoad.h" has been renamed to "CodeFragments.h"
		03/26/96	fix compile error in reference to fEventRecord when qContainer is on
		03/05/96	[1326221] Move HasDragManager to CoreUtils, Copyright
		01/15/96	Replaced the FailCAErr with ::ThrowIfOSErr_AC(CAError());
		12/20/95	Slam cDragMove into pair of drag/drop commands.
		12/18/95	Remove linked commands. Add begin/end transaction to
							undo history around TrackDrag.
		11/28/95	Fix calls to CAGetDragDropDoc to match new interface of
							CALib 1.0v6 - Only takes the reference.
		 12/8/95	Split up includes for modular MacApp.
		11/29/95	Move TInvalCursorCommand here from UCommand.
		 10/4/95	Optimize UserRequestedCopy.
		 5/24/95	CALib support.
		----- 3.3 -----
		10/27/95	Correctly disable/enable busy cursor in StartDrag. Remove
							busy cursor code from all other functions.
		10/20/95	TDragDropSession::HandleLeaveHandler frees the drag item list.
		10/11/95	Register signature of TDragDropBehavior.
		 10/2/95	Test gBusyCursor before using it.
		----- 3.3b1 -----
		  9/1/95	Set and restore rA5 in all callbacks. Necessary for
		  					compatibility with AOCE. Add InitializeResidentDragSegment.
		 8/31/95	Remove fDragRegion. Test UserRequestedCopy in StartDrag
		 					instead of in UserIsDragging.
		 8/30/95	HandleDragToTrash returns a bool.
		 					Post TInvalCursorCommands.
		 8/22/95	Use TCommand::LinkToSecondary to establish command link.
		 8/22/95	TDragFlavorStream::SetPosition wasn't setting the position.
		 					Support linkedCommand identities. Post source command if
							available.
		 7/28/95	Add configuration functions to use instead of gConfiguration.
		 5/31/95	Include Folders.h.
		 5/23/95	Never have a drop target when the mouse is in an autoscroll
		 					area and the scroller can still scroll in the indicated
							direction.
		 5/22/95	Use FreeAll instead of DeleteAll to clear dragitemlist.
		 5/19/95	HandleAutoScroll doesn't hide/show drop hilite if
		 					sourceWindow != targetWindow.
		 5/17/95	Add HandleAutoScroll, HandleDragToTrash, IsDropLocationFinderTrash.
		 					ShowDropTargetHilite requests the hilite region from the view
		 					instead of expecting it as a parameter.
		 					Session tracks source scroller.
		 					Session tracks whether or not drag has exited source view.
		 					HandleEnterWindow fix to enable dragging into modal dialogs.
		 5/16/95	WindowRef
		 4/14/95	save/lock and restore handle state instead of lock and unlock
		  4/9/95	Don't conditionalize the TDragFlavorStream destructor on qDebug.
		  4/7/95	Remove the default argument from AddDragItem.
		  4/6/95	Add GetGlobalDragMouuse, SetGlobalPinnedDragMouse.
		  4/3/95	Cut possibly dangerous failure handling out of ReadBytes.
		 3/31/95	Add Get/Set drag bounds support.
		 3/30/95	Change ? to \? for strict ANSI compatibility w/PPCC.
							Added destructor to drag item iterator.
							ARM 8.4.3 x& cannot be initialized with volatile x.
		 3/30/95	Synch with TView drag and drop method name changes.
		 					Change gDragDropSession to TDragDropSession::fgDragDropSession.
		 3/28/95	Don't call SetDropTarget if the target hasn't changed..
		 3/28/95	Marked refCon param to DragSendDataProc unused.
		 3/22/95	Remove call to CanWindowAcceptDrag.  Add dragItemIterator
		 					argument to call to MouseToDropTarget.
		 3/17/95	MAVolatile.
		 3/15/95	Use CFlavorFlags.
		 3/15/95	Drag and drop face lift.
		 3/13/95	Change Free methods to destructors.
		 3/10/95	Add GetFlavorHandle.
		  3/9/95	SetDropTarget tells the target to resign before removing
		  					the drop hilite. This eliminates artifact problems in edit
		  					text drop tracking.
		  					Add TDragDropSession::GetCurrentDropTarget.
		  3/9/95	DragReceiveHandler only posts the target command.
		  3/8/95	DragReceiveHandler forces the application process
		  					to be wakened.  This causes the WNE that we may
		  					be in to return so that any commands that were posted
		  					will get processed.
		  3/7/95	DragReceiveHandler supports MakeDragDropCommand and
		  					copy/move variants.
		  					Drop target hilite region is converted to window
		  					view coordinates, and the window is focused whenever the
		  					drag manager has the potential to draw/undraw the hilite.
		 2/28/95	Use MA_REGISTER_CLASS instead of macroDontDeadStrip.
		 2/24/95	DragManager UPPs and callback glue are static members of
		 					TDragDropSession.
		 2/23/95	Add fUserRequestedCopy. IsUserDragging sets fUserRequestedCopy
		 					based on IsOptionKeyDown.
		 					DragReceiveHandler calls fDropTarget->ReceiveDropMove or
		 					fDropTarget->ReceiveDropCopy.
		 2/23/95	Renamed fCurrentDragSource to fDragSource.
		 					Renamed fCurrentDropTarget to fDropTarget.
		 2/22/95	BeginDrag resets fCurrentDragSource to nil.
		 2/21/95	Add TDragDropSession::GetCurrentDragSource.
		 2/13/95	Remove unnecessary initialization of static variables. See ARM §8.4
		 2/14/95	TDragDropSession::DragReceiveHandler tests and respects
							the return value of TView::GetDropLocationDescriptor.
		 2/10/95	TDragDropSession::BeginDrag now focuses on the
							drag source immediately after returning from
							TrackDrag. This fixes the problem with the current focus
							getting out of synch with the current port.
		 2/10/95	TDragDropSession::DragReceiveHandler now returns
							an OSErr.  When a drag is received when no
							target exists, an error is returned. This causes
							automatic zoom rects back to the source.
		  2/2/95	TDragFlavorStream supports writing data to streams.
							Added DragSendDataProc and DragSendDataProcGlue
							and the necessary UPP.
							Added TDragDropSession::AddDragFlavor,
							TDragDropSession::UserIsDragging, and
							TDragDropSession::BeginDrag.
		 1/31/95	TDragDropSession::GetFlavorSize doesn't call Failure
							if the requested flavor doesn't exist.
		 1/23/95	TDragDropSession::DragReceiveHandler requests an
							AEDesc from the target and calls ::SetDropLocation.
		 1/20/95	Add instance counting to TDragFlavorStream when
							built in debug mode.
		  1/4/95	Changed DragDropSession to track views as targets
							rather than TDragDropBehaviors.
		----- 3.5d3 Release -----
		12/15/94	Changed ::SetDropTarget to unhilite current
							drop target before telling it to resign.
		11/15/94	Missing a colon in debug code in
							UnregisterDroppableWindow.  Changed parameter passed
							to GetItemReference from an unsigned long to an
							unsigned short for consistency with the equivalent
							Drag Manager call.
		11/13/94	Move macroDontDeadStrip(TDragDropBehavior) to
							UMacAppGlobals.
		11/12/94	Include Errors.
		11/11/94	Check gConfiguration.hasDragManager at runtime
							in several places and react appropriately.
		11/11/94	Conditionally compile this unit out if qDrag
							is false.
		10/17/94	Initialized.
*/