//----------------------------------------------------------------------------------------
// UInsertPartCommand.cpp
// Copyright © 1994-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef __UINSERTPARTCOMMAND__
#include "UInsertPartCommand.h"
#endif

#if qContainer

#ifndef __UODPARTVIEW__
#include "UODPartView.h"
#endif

// MacApp

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// CALib

#if qContainer
	#ifndef _CALIB_
	#include "CALib.h"
	#endif
#endif

// Toolbox

#ifndef __STANDARDFILE__
#include <StandardFile.h>
#endif

#ifndef __STDLIB__
#include <stdlib.h>
#endif

//========================================================================================
// CLASS TInsertPartCommand
//========================================================================================
#undef Inherited
#define Inherited TCommand

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------


TInsertPartCommand::TInsertPartCommand(CommandNumber itsCommandNumber,
											   TDocument* itsDocument,
											   TODPartView* itsPartView) :
		TCommand(itsCommandNumber, itsDocument,
						 kCanUndo, kCausesChange, itsDocument),

	fODPartView(NULL),
	fDocument(NULL)
{
	bool  fileChosen = ChoosePartFile();
	if (fileChosen)
	{
//		ICommand(itsCommandNumber, itsDocument,
//						 kCanUndo, kCausesChange, itsDocument);
		fDocument = itsDocument;
		fODPartView = itsPartView;
	}
	
// ••• 	return fileChosen;
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------


TInsertPartCommand::~TInsertPartCommand()
{
}

//----------------------------------------------------------------------------------------
// TInsertPartCommand::DoIt()
//----------------------------------------------------------------------------------------


void TInsertPartCommand::DoIt()
{
	
	if (fODPartView)
	{
		
		//Remove the old part.
		if(fODPartView->HasPart())
		{
			fODPartView->RemovePart();
		}
		
		// IF THERE IS NO fODPartView, make one. for now, upper left? •••
		//if(!fODPartView)
		//fODPartView = new
		
		fODPartView->AquirePartFromFile(fFileSpec);
	}
}

//----------------------------------------------------------------------------------------
// TInsertPartCommand::UndoIt()
//----------------------------------------------------------------------------------------


void TInsertPartCommand::UndoIt()
{
	if(fODPartView->HasPart())
		fODPartView->RemovePart();
}

//----------------------------------------------------------------------------------------
// TInsertPartCommand::ChoosePartFile
//----------------------------------------------------------------------------------------


bool TInsertPartCommand::ChoosePartFile()
{
	::ThrowIfOSErr_AC(MAInteractWithUser()); 
	gClipboardMgr->AboutToLoseControl(true);			// so scrap gets converted

	bool				done = false;

	// Insure we can go modal at this time.
	WindowPtr		frontWindow = CAGetFrontDocWindow();
	if (CARequestModalFocus(frontWindow))
	{
		StandardFileReply	customReply;
		FileFilterYDUPP		cgfFileFilter = NewFileFilterYDProc(TInsertPartCommand::PartFileFilter);
		ModalFilterYDUPP 	cgfModalFilter = NewModalFilterYDProc(gModalFilterYDProcPtr);

		CustomGetFile(cgfFileFilter,
						-1,				// Pass all file types
						NULL,			// No type list
						&customReply,
						sfGetDialogID,
						kBestSystemLocation,
						NULL,			// Dialog hook function
						cgfModalFilter,
						NULL,			// Activate list
						NULL,			// Activate proc
						NULL);

		CARelinquishModalFocus(frontWindow);
	
		if (customReply.sfGood)
		{
			fFileSpec = customReply.sfFile;
			done = true;
		}
	}
	return done;	
}

//----------------------------------------------------------------------------------------
// TInsertPartCommand::PartFileFilter
//----------------------------------------------------------------------------------------


pascal Boolean TInsertPartCommand::PartFileFilter(CInfoPBPtr pb)
{
	HFileInfo*	fpb = (HFileInfo*)pb;

	if (!(fpb->ioFlAttrib & 16))
	{
		return (!(fpb->ioFlFndrInfo.fdCreator == kODShellSignature) &&
			(fpb->ioFlFndrInfo.fdType != 'APPL') &&
			(fpb->ioFlFndrInfo.fdType != 'shlb'));
	}
	return false;
}

//----------------------------------------------------------------------------------------
// TInsertPartCommand::Commit
//----------------------------------------------------------------------------------------


void TInsertPartCommand::Commit()
{
	if (!fCommandDone && fODPartView)
		delete fODPartView;
}

#endif // qContainer

//----------------------------------------------------------------------------------------
// End of UInsertPartCommand.cp



/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		----- R10 -----
		01/18/95 	gjc		Reworked to work outside of the DrawShapes 
							application. Now works with TODShapeView.
		12/14/95	Rename to UInsertPartCommand. 
							Rename TPartShape.h to UPartShape.h. 
		12/12/95	Conditionalized include of CALib.h.
		12/05/95	File filter wouldn't work right on some machines.
		12/01/95	Created. 
*/