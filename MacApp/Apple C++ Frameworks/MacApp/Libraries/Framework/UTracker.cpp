//----------------------------------------------------------------------------------------
// UTracker.cpp
// Copyright � 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/17/01	Use TrackMouseLocationWithOptions for tracking. Now we can
					support auto-scrolling while using Carbon Events. 
		01/02/01	Update copyright.
		12/26/00	[W] Changed PerformTracking and HandleTrackContinue.
		12/12/00	[C] Fix the conditionals in HandleTrackEnd. The old 
					implementation was okay for Classic code, it's only Carbon 
					code that can't call OSEventAvail. 
					Initial support for using TrackMouseLocation to wait 
					for the mouse to move. 
		11/10/00	Cosmetic.
		10/16/00	Change how tracker is deleted in TrackOnce.
		09/07/00	Added embedded documentation.
		08/09/00	[2216347] Delete self if new tracker created in TTracker::TrackOnce.
		05/23/00	[2279264] Remove false from ProgramReport_AC.
		10/04/99	Carbon: OSEventAvail now EventAvail.
		09/23/99	Carbon: change #warning to #pragma message, take out OSEventAvail().
		07/23/99	[C] Cannot call OpenCPort in DoFocus.
		03/24/99	Update copyright notice.
		03/23/99	Go back to native Toolbox region calls.
		11/06/98	CarbonSeed110398: CloseCPort is gone, use DisposePort instead.
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					CopyRgn_AC, SetPort_AC.  Include ImagingUtils_AC.h.
		10/26/98	Carbonize
		10/08/98	Move TDispatcher::TrackMouse to TTracker::PerformTracking.
					Undo context.
					Merge TCommandHandler into TEventHandler.
*/

#ifndef __UTRACKER__
#include "UTracker.h"
#endif

// ACS

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

// MacApp

#if defined(qDebug) && !defined(__UDEBUG__)
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UUndo__
#include "UUndo.h"
#endif

// Toolbox

#if qCarbonEvents
	#ifndef __CARBONEVENTS__
	#include <CarbonEvents.h>
	#endif
#endif

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

// ANSI

#ifndef __STDLIB__
#include <stdlib.h>
#endif

//========================================================================================
// CLASS TTracker
//========================================================================================

//----------------------------------------------------------------------------------------
// TTracker::TTracker:
//----------------------------------------------------------------------------------------

TTracker::TTracker(CommandNumber		itsCommandNumber,
				   TEventHandler*		itsContext,
				   bool					canUndo,
				   bool					causesChange,
				   MDependable_AC*		objectToNotify,
				   TView*				itsView,
				   TScroller*			itsScroller,
				   const CViewPoint&	itsMouse)
	:	TCommand(itsCommandNumber, itsContext, canUndo, causesChange, objectToNotify),
		fInitialPt(itsMouse),
		fView(itsView),
		fScroller(itsScroller),
		fDeskTopTrackingPort(NULL),
		fTrackPhase(trackBegin),
		fConstrainsMouse(false),
		fViewConstrain(true),
		fTrackNonMovement(false),
		fMovedOnce(false),
		fRestorePattern(false)
{
}

//----------------------------------------------------------------------------------------
// TTracker destructor
//----------------------------------------------------------------------------------------

TTracker::~TTracker()
{
	if (fRestorePattern)
		::PenNormal();
}

//----------------------------------------------------------------------------------------
// TTracker::AutoScroll:
//----------------------------------------------------------------------------------------

void TTracker::AutoScroll(const CViewPoint& delta)
// AutoScroll implements automatic scrolling in the scroller associated with
// the tracker.  MacApp calls AutoScroll when the mouse is being tracked and has strayed
// outside the scroller.
//
// delta:	Specifies the amount by which to offset the coordinates of the scroller
// 			view in the view coordinate space.
//
// Call?		Seldom.
// Override?	Seldom. Override TScroller::ScrollBy if the scroll
//				bar units are not the same as the scroller�s translation units.
{
	if (fScroller)
		fScroller->ScrollBy(delta, kRedraw);
}

//----------------------------------------------------------------------------------------
// TTracker::IsDoneTracking:
//----------------------------------------------------------------------------------------

bool TTracker::IsDoneTracking()
{
	return fView ? fView->IsDoneTracking() : !StillDown();
}

//----------------------------------------------------------------------------------------
// TTracker::Process:
//----------------------------------------------------------------------------------------

void TTracker::Process()
{
#if qDebugMsg
	if (gIntenseDebugging && this)
		ProgramReport_AC("Tracking Command: %s\n", typeid(*this).name());
#endif

	TTracker* finalCommand = PerformTracking(fInitialPt, TEventHandler::GetStdHysteresis(), this);
	if (finalCommand)
		PerformCommand(finalCommand);

	// WARNING: 'this' may be deleted inside PerformTracking or PerformCommand!
	// It is NOT safe to access any fields or call any functions
	// of the command after this point.
}

//----------------------------------------------------------------------------------------
// TTracker::PerformTracking:
//----------------------------------------------------------------------------------------

TTracker* TTracker::PerformTracking(const CViewPoint&	theMouse,
									CPoint_AC			hysteresis,
									TTracker*			theCommand)
{
	TTracker* currentTracker = NULL;

	try
	{
#if qMSWindows
		HDC hdc = NULL;
		TView* view = theCommand->fView;
		if (view)
		{
			hdc = ::GetDC(view->GetWindowsWindow());
			theCommand->fView->SetDrawingContext(new TDrawingContext(hdc));
		}
#endif
		currentTracker = theCommand->HandleTrackBegin(theMouse, hysteresis);
		theCommand = NULL;					// so failure handler works

#if qCarbonEvents
		bool useTrackMouseLocation = gDispatcher->UseCarbonEvents() &&
									 (&TrackMouseLocationWithOptions != 0);
#endif
		while (currentTracker && !currentTracker->IsDoneTracking())
		{
#if qCarbonEvents
			if (useTrackMouseLocation)
			{
				// Use the WithOptions version of TrackMouseLocation 
				// so we can do auto-scrolling even when the mouse hasn't moved. 
				CPoint_AC localMouse;
				MouseTrackingResult trackingResult = 0;
				const EventTimeout timeout = 50 * kEventDurationMillisecond; // 1/20 second
				ThrowIfOSErr_AC(TrackMouseLocationWithOptions(NULL, 0, timeout, &localMouse, NULL, &trackingResult));
				if (trackingResult == kMouseTrackingMouseReleased)
					break;
			}
#endif
			if (gDispatcher->IsFrontProcess())
				currentTracker = currentTracker->HandleTrackContinue();
		}

		if (currentTracker)
			currentTracker = currentTracker->HandleTrackEnd();

#if qMSWindows
		if (hdc)
		{
			view->SetDrawingContext(NULL);
			::ReleaseDC(view->GetWindowsWindow(), hdc);
		}
#endif
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);

		CompleteCommand(theCommand);
		CompleteCommand(currentTracker);

		throw;
	}

	return currentTracker;
}

//----------------------------------------------------------------------------------------
// TTracker::TrackConstrain:
//----------------------------------------------------------------------------------------

void TTracker::TrackConstrain(TrackPhase			aTrackPhase,
							  const CViewPoint&		anchorPoint,
							  const CViewPoint&		previousPoint,
							  CViewPoint&			nextPoint,
							  bool					mouseDidMove)
{
	if (fView)
		fView->TrackConstrain(aTrackPhase, anchorPoint, previousPoint, nextPoint, mouseDidMove);
}

//----------------------------------------------------------------------------------------
// TTracker::TrackFeedback:
//----------------------------------------------------------------------------------------

void TTracker::TrackFeedback(TrackPhase				aTrackPhase,
							 const CViewPoint&		anchorPoint,
							 const CViewPoint&		previousPoint,
							 const CViewPoint&		nextPoint,
							 bool					mouseDidMove,
							 bool					turnItOn)
{
	if (fView)
		fView->TrackFeedback(aTrackPhase, anchorPoint, previousPoint, nextPoint, mouseDidMove, turnItOn);
}

//----------------------------------------------------------------------------------------
// TTracker::TrackMouse:
//----------------------------------------------------------------------------------------

TTracker* TTracker::TrackMouse(TrackPhase		aTrackPhase,
							   CViewPoint&		anchorPoint,
							   CViewPoint&		previousPoint,
							   CViewPoint&		nextPoint,
							   bool				mouseDidMove)
{
	if (fView)
		fView->TrackMouse(aTrackPhase, anchorPoint, previousPoint, nextPoint, mouseDidMove);

	return (aTrackPhase == trackEnd && (!fView || !fView->ContainsMouse(nextPoint))) ? NULL : this;
}

//----------------------------------------------------------------------------------------
// TTracker::CleanUpFocus:
//----------------------------------------------------------------------------------------

void TTracker::CleanUpFocus()
// CleanUpFocus handles some focus issues with the port used for tracking
// the mouse.  MacApp calls this method as part of the mouse-tracking mechanism.
//
// Call?		Seldom.
// Override?	Seldom.
{
	if (fDeskTopTrackingPort)
	{
		SetPortWindowPort(gWorkPort);

#if !qCarbon
		CloseCPort((CGrafPtr) fDeskTopTrackingPort);
		::DisposeIfPtr_AC(reinterpret_cast<Ptr>(fDeskTopTrackingPort));
#else
		::DisposePort(fDeskTopTrackingPort);
#endif
		fDeskTopTrackingPort = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TTracker::DoFocus:
//----------------------------------------------------------------------------------------

void TTracker::DoFocus()
{
	if (fView)
	{
		if (fDeskTopTrackingPort)
			CleanUpFocus();

		if (!fView->Focus())
		{
#if qDebug
			::ProgramBreak_AC("TApplication.TrackMouse: Unable to focus fView.");
#endif
		}
	}
	else
	{											// focus on the desktop
		if (!fDeskTopTrackingPort)
		{
#if !qCarbon
			fDeskTopTrackingPort = (GrafPtr) NewPermPtr(sizeof(CGrafPort));
			OpenCPort((CGrafPtr)fDeskTopTrackingPort);
#else
			fDeskTopTrackingPort = ::CreateNewPort();
#endif

		}

#if !qCarbon
		//CopyRgn(GetGrayRgn(), TWindow::GetVisRegion(fDeskTopTrackingPort));
		//fDeskTopTrackingPort->portRect = (*TWindow::GetVisRegion(fDeskTopTrackingPort))->rgnBBox;
		::MacCopyRgn(GetGrayRgn(), fDeskTopTrackingPort->visRgn);
		fDeskTopTrackingPort->portRect = (*(fDeskTopTrackingPort->visRgn))->rgnBBox;
#else
		CTempRegion_AC visRegion;
		::GetPortVisibleRegion(fDeskTopTrackingPort, visRegion);
		::MacCopyRgn(GetGrayRgn(), visRegion);
		Rect visRect;
		::SetPortBounds(fDeskTopTrackingPort, ::GetRegionBounds(visRegion, &visRect));
#endif
		gDispatcher->InvalidateFocus();
		::SetPort_AC(fDeskTopTrackingPort);
	}
}

//----------------------------------------------------------------------------------------
// TTracker::BecomeTracker:
//----------------------------------------------------------------------------------------

void TTracker::BecomeTracker(TTracker* oldTracker)
{
	if (oldTracker)
	{
		fDeskTopTrackingPort = oldTracker->fDeskTopTrackingPort;
		fTrackPhase = oldTracker->fTrackPhase;

		fHysteresis = oldTracker->fHysteresis;
		fTrackPhase = oldTracker->fTrackPhase;
		fAnchorPoint = oldTracker->fAnchorPoint;
		fPreviousPoint = oldTracker->fPreviousPoint;
		fNextPoint = oldTracker->fNextPoint;
		fLastAnchorPoint = oldTracker->fLastAnchorPoint;
		fLastPreviousPoint = oldTracker->fLastPreviousPoint;
		fLastNextPoint = oldTracker->fLastNextPoint;
	}

	DoFocus();
}

//----------------------------------------------------------------------------------------
// TTracker::ConstrainOnce:
//----------------------------------------------------------------------------------------

void TTracker::ConstrainOnce(bool didMouseMove)
// ConstrainOnce handles the situation where the mouse needs to be constrained
// only during this tracking movement.
// MacApp calls this method as part of the mouse-tracking mechanism.
//
// didMouseMove:	TRUE if the mouse moved more than the hysteresis value since
// 					the last time TrackFeedback was called.
//
// Call?		Seldom.
// Override?	Seldom.
{
	if (fViewConstrain && (fView))
		fNextPoint.ConstrainTo(fView->GetExtent());

	if (fConstrainsMouse)
	{
		CViewPoint nextPoint = fNextPoint;
		TrackConstrain(fTrackPhase, fAnchorPoint, fPreviousPoint, nextPoint, didMouseMove);
		fNextPoint = nextPoint;
	}
}

//----------------------------------------------------------------------------------------
// TTracker::FeedbackOnce:
//----------------------------------------------------------------------------------------

void TTracker::FeedbackOnce(bool mouseDidMove, bool turnItOn)
{
	fRestorePattern = true;

	PenNormal();
	PenMode(patXor);

	if (turnItOn)
	{
		TrackFeedback(fTrackPhase, fAnchorPoint, fPreviousPoint,
					  fNextPoint, mouseDidMove, turnItOn);
		// save these to turn it off with
		if (mouseDidMove)
		{
			fLastAnchorPoint = fAnchorPoint;
			fLastPreviousPoint = fPreviousPoint;
			fLastNextPoint = fNextPoint;
		}
	}
	else
		TrackFeedback(fTrackPhase, fLastAnchorPoint, fLastPreviousPoint,
					  fLastNextPoint, mouseDidMove, turnItOn);
}

//----------------------------------------------------------------------------------------
// TTracker::TrackOnce:
//----------------------------------------------------------------------------------------

TTracker* TTracker::TrackOnce(bool didMouseMove)
{
	TView* oldView = fView;
	CViewPoint anchorPoint = fAnchorPoint;
	CViewPoint previousPoint = fPreviousPoint;
	CViewPoint nextPoint = fNextPoint;

	TTracker* newTracker = TrackMouse(fTrackPhase, anchorPoint, previousPoint, nextPoint, didMouseMove);

	fAnchorPoint = anchorPoint;
	fPreviousPoint = previousPoint;
	fNextPoint = nextPoint;

	if (newTracker == this)
	{
		if (fView != oldView)
			BecomeTracker(this);
	}
	else
	{
		if (newTracker)
			newTracker->BecomeTracker(this);
		else
			CleanUpFocus();

		// Free the old tracker.
		DeleteCommand(this);
	}

	return newTracker;

}

//----------------------------------------------------------------------------------------
// TTracker::HandleTrackBegin:
//----------------------------------------------------------------------------------------

TTracker* TTracker::HandleTrackBegin(const CViewPoint& theMouse, CPoint_AC hysteresis)
{
	fTrackPhase = trackBegin;

	fMovedOnce = false;
	fDeskTopTrackingPort = NULL;
	fAnchorPoint = theMouse;
	fPreviousPoint = theMouse;
	fNextPoint = theMouse;
	fHysteresis = hysteresis,

	BecomeTracker(NULL);

	ConstrainOnce(true);
	// in case Constrain changed the fNextPoint� guarantee that all 3 are the same on trackBegin
	fAnchorPoint = fNextPoint;
	fPreviousPoint = fNextPoint;

	TTracker* theTracker = TrackOnce(true);
	if (theTracker)
	{
		// in case TrackMouse changed the fNextPoint� guarantee that all 3 are the same on trackBegin
		theTracker->fAnchorPoint = theTracker->fNextPoint;
		theTracker->fPreviousPoint = theTracker->fNextPoint;

		theTracker->FeedbackOnce(true, true);
	}

	return theTracker;
}

//----------------------------------------------------------------------------------------
// TTracker::HandleTrackContinue:
//----------------------------------------------------------------------------------------

TTracker* TTracker::HandleTrackContinue()
{
	fTrackPhase = trackContinue;				// supply trackphase to all interested parties

	DoFocus();

	CPoint_AC theQDMouse;
	GetMouse(theQDMouse);
	if (fView)
		fNextPoint = fView->QDToView(theQDMouse);
	else
#if qMSWindows
	{
		POINT mappedPoint;
		mappedPoint.x = theQDMouse.h;
		mappedPoint.y = theQDMouse.v;
		MapWindowPoints(HWND_DESKTOP, CApplication_AC::fgProcess->fChildClientWindow, &mappedPoint, 1);
		CViewPoint palOrigin;
		fNextPoint.h = mappedPoint.x;
		fNextPoint.v = mappedPoint.y;
	}
#else
		fNextPoint = theQDMouse;
#endif

	if (!fMovedOnce)
	{
		ConstrainOnce(fPreviousPoint != fNextPoint);		// ensure that we are
															// playing on a level
															// field.
		CViewPoint amtMoved = fNextPoint - fAnchorPoint;
		if ((abs((int)amtMoved.h) >= fHysteresis.h) || (abs((int)amtMoved.v) >= fHysteresis.v))
			fMovedOnce = true;
	}

	CViewPoint delta;
	if (fMovedOnce || fTrackNonMovement)
	{
		if (fScroller && fView)
		{
			// convert fNextPoint to scroller coordinates
			CViewPoint mouseInScroller = fScroller->RootViewToLocal(fView->LocalToRootView(fNextPoint));

			// AutoScroll if the CPoint_AC is outside of the scroller's extent
			if (!fScroller->GetExtent().Contains(mouseInScroller))
			{
				fScroller->AutoScroll(mouseInScroller, delta);// Get the amount to autoscroll
				fNextPoint += delta;
			}
		}

		ConstrainOnce(fPreviousPoint != fNextPoint);
	}

	bool willScroll = delta != gZeroVPt;
	bool didMove = fPreviousPoint != fNextPoint;

	FeedbackOnce(didMove || willScroll, false);

	if (willScroll)
	{
		AutoScroll(delta);		// OK, now actually do the scrolling
		if (fView)
			fView->Update();				// Keep synchronized. ScrollDraw only
                                            // invalidated
		DoFocus();					// the focus changed
	}

	TTracker* theTracker = TrackOnce(didMove);
	if (theTracker)
	{
		theTracker->FeedbackOnce(didMove || willScroll, true);
		theTracker->fPreviousPoint = theTracker->fNextPoint;
	}

	return theTracker;
}

//----------------------------------------------------------------------------------------
// TTracker::HandleTrackEnd:
//----------------------------------------------------------------------------------------

TTracker* TTracker::HandleTrackEnd()
{
	fTrackPhase = trackEnd;						// supply trackphase to all interested parties

	DoFocus();

	if (!fMovedOnce)
	{
		fNextPoint = fPreviousPoint;			// normally same as original mouse down;
                                                // we don't use fAnchorPoint in case
                                                // someone has changed that -- it is more
                                                // likely that an app would change
                                                // fAnchorPoint than fPreviousPoint
	}
	else
	{
#if !qCarbon
		// With the classic tracking strategy, it's possible that the mouse has 
		// moved between the time HandleTrackContinue called GetMouse and the 
		// time that IsDoneTracking called StillDown. This code peeks into the 
		// event queue for a mouse up event. If there is one, it should have the 
		// definitive final location for the tracker. (This is assuming that
		// the user hasn't been mousing faster than the application can respond
		// so there aren't multiple mouse events in the queue.) 
		EventRecord peekEvent;
		if (::OSEventAvail(mUpMask + mDownMask, &peekEvent))
		{
			CPoint_AC theQDMouse = peekEvent.where;
			if (fView)
			{
				GlobalToLocal(theQDMouse);
				fNextPoint = fView->QDToView(theQDMouse);
			}
			else
				fNextPoint = theQDMouse;
			ConstrainOnce(true);
		}
#else
		// Carbon doesn't support OSEventAvail. It's possible to call EventAvail, 
		// but it's probably better to just use the last known mouse location. 

		// ���  Redo tracker to use TrackMouseLocation, which returns
		// a mouse location. 
#endif
	}
	// else we use the last known mouse position

	FeedbackOnce(true, false);
	TTracker* theTracker = TrackOnce(true);
	if (theTracker)
		theTracker->CleanUpFocus();

	return theTracker;
}

//----------------------------------------------------------------------------------------
// End of UTracker.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/25/96	[1345531] Added missing includes for noload buids
		06/09/96	Removed UStreamable to a separate file from UObject
		05/02/95	Call FreeIfObject, don't call Free directly since it will eventually be removed.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		----- R10 -----
		  4/3/96	OSEvents.h merged into Events.h.
		 3/27/96	Account that GetClassName can return a char* now.
		03/26/96	coerce CStrxxx_AC to const char* to get copies of the strings as c style strings
		 3/18/96	Made better use of TView calls that return CRect_AC/CViewPoint/CViewRect
		 3/06/96	Reactivated #include for UMemory.
		 3/01/96	Grouped some globals and global functions as static members.
		12/21/95	Have to include USegments after all.
		12/18/95	Include UDispatcher.
		12/15/95	Get rid of fLastCommand.
		 12/8/95	Bring back MAInteractWithUser.
		11/29/95	Move TTracker from UCommand to UTracker.
*/