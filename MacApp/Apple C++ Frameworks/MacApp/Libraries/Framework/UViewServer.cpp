//----------------------------------------------------------------------------------------
// UViewServer.cpp
// Copyright © 1987-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/12/00	Added extra debug words in NewTemplateWindow to explain what
					to do if the window’s target is in a tab pane.
		11/10/00	Cosmetic.
		09/01/00	Added embedded documentation.
		08/01/00	[W] Conditionalize implementation of NewTWindow.
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Include CMultiLocal.h.
		03/24/99	Update copyright notice.
		10/27/98	Carbonize
*/

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

// MacApp

#ifndef __UADORNERS__
#include "UAdorners.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CStreamContext_AC__
#include "CStreamContext_AC.h"
#endif

#ifndef __CRandomAccessStream_AC__
#include "CRandomAccessStream_AC.h"
#endif

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

// Toolbox

#ifndef __RESOURCES__
#include <Resources.h>
#endif

// ANSI

//----------------------------------------------------------------------------------------
// global declarations for globals defined in interface
CAutoPtr_AC<TViewServer> TViewServer::fgViewServer;

//========================================================================================
// CLASS TViewServer
//========================================================================================

//----------------------------------------------------------------------------------------
// TViewServer::IViewServer:
//----------------------------------------------------------------------------------------

TViewServer::TViewServer()
{
	fgViewServer = this;							// set the global reference.
}

//----------------------------------------------------------------------------------------
// TViewServer::Free:
//----------------------------------------------------------------------------------------

TViewServer::~TViewServer()
{
}

//----------------------------------------------------------------------------------------
// TViewServer::NewPaletteWindow:
//----------------------------------------------------------------------------------------

TWindow* TViewServer::NewPaletteWindow(ResNumber	itsRsrcID,
									   bool			wantHScrollBar,
									   bool			wantVScrollBar,
									   TView*		itsMainView,
									   TView*		itsPaletteView,
									   short		sizePalette,
									   VHSelect		whichWay)

{
	// create the window, adjust its resize limits, and add the palette view
	CAutoPtr_AC<TWindow> aWindow(NewTWindow(itsRsrcID));

	CRect_AC resizeLimits(aWindow->GetResizeLimits());
	resizeLimits[topLeft][whichWay] += sizePalette;
	aWindow->SetResizeLimits(resizeLimits);
	aWindow->AddSubView(itsPaletteView);

	// calculate location of itsMainView
	CViewPoint itsLocation;
	itsLocation[whichWay] = sizePalette;

	// add itsMainView to the window with optional scroller
	AddSubViewWithScroller(aWindow, itsMainView, wantHScrollBar, wantVScrollBar, itsLocation);

	return aWindow.release();
}

//----------------------------------------------------------------------------------------
// TViewServer::NewSimpleWindow:
//----------------------------------------------------------------------------------------

TWindow* TViewServer::NewSimpleWindow(ResNumber		itsRsrcID,
									  bool			wantHScrollBar,
									  bool			wantVScrollBar,
									  TView*		itsView)

{
	// create the window
	CAutoPtr_AC<TWindow> aWindow(NewTWindow(itsRsrcID));

	// add itsView to the window with optional scroller
	AddSubViewWithScroller(aWindow, itsView, wantHScrollBar, wantVScrollBar, gZeroVPt);

	return aWindow.release();
}

//----------------------------------------------------------------------------------------
// TViewServer::AddSubViewWithScroller:
//----------------------------------------------------------------------------------------

void TViewServer::AddSubViewWithScroller(TWindow*			aWindow,
										 TView*				itsView,
										 bool				wantHScrollBar,
										 bool				wantVScrollBar,
										 const CViewPoint&	itsLocation)
// AddSubViewWithScroller adds the specified view to the specified window,
// with scroll bars as requested. This method creates a scroller object if either a horizontal or vertical scroll bar is requested.
//
// aWindow:			Specifies the window to which the view will be added.
// itsView:			Specifies the subview to be added to the window.
// wantHScrollBar:	If true it specifies that a horizontal scroll bar should be
//					accommodated.
// wantVScrollBar	If true it specifies that a vertical scroll bar should be
//					accommodated.
// itsLocation:		Specifies the location of the upper-left corner of the scroller,
//					in view coordinates.
//
// Call?		As needed.
// Override?	Seldom.
{
	TScroller * aScroller = NULL;

	if (wantHScrollBar || wantVScrollBar)
	{
		// calculate scroller's dimensions
		CViewRect sBarOffsets;
		CViewPoint itsSize = aWindow->GetSize();

		// Account for scroller _not_ being located at CViewPoint (0,0)
		// as when a palette is sharing the window.
		itsSize -= itsLocation;

		if (wantHScrollBar)
		{
			itsSize.v -= kSBarSizeMinus1;
			if (!wantVScrollBar)
				sBarOffsets.right = -kSBarSizeMinus1;
		}
		if (wantVScrollBar)
		{
			itsSize.h -= kSBarSizeMinus1;
			if (!wantHScrollBar)
				sBarOffsets.bottom = -kSBarSizeMinus1;
		}

		// create the scroller
		aScroller = TH_new TScroller(itsLocation, itsSize, sizeRelSuperView, sizeRelSuperView, gZeroVPt, wantHScrollBar, wantVScrollBar);
		aScroller->fSBarOffsets = sBarOffsets;
		aWindow->AddSubView(aScroller);
		aScroller->HandlePostCreate(aWindow->GetDocument());
	}

	// add the subview
	if (aScroller)
		aScroller->AddSubView(itsView);
	else
		aWindow->AddSubView(itsView);

	aWindow->SetWindowTarget(itsView);

	// make sure window and subviews are the right size
#if !qCarbon
	aWindow->Resize(((CRect_AC &) GetWindowPort(aWindow->GetWindowRef())->portRect).GetSize(), kDontInvalidate);
#else
	CRect_AC portRect;
	::GetWindowPortBounds(aWindow->GetWindowRef(), portRect);
	aWindow->Resize(portRect.GetSize(), kDontInvalidate);
#endif
}

//----------------------------------------------------------------------------------------
// TViewServer::NewTWindow:
//----------------------------------------------------------------------------------------

TWindow* TViewServer::NewTWindow(ResNumber itsRsrcID)
{
	TWindow *	aWindow = NULL;
	WindowRef	aWMgrWindow = NULL;
	bool		canResize;
	bool		canClose;

#if !qMSWindows
	aWMgrWindow = gDispatcher->NewToolboxWindow(itsRsrcID, canResize, canClose);
	// NewToolboxWindow signals Failure

	try
	{
		aWindow = TH_new TWindow(aWMgrWindow, canResize, canClose, false);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		aWMgrWindow = TWindow::FreeIfWMgrWindow(aWMgrWindow);
		throw;
	}
#else
	// guess on these?  Should get reset later anyway
	canClose = true;
	canResize = true;

	aWindow = TH_new TWindow(aWMgrWindow, canResize, canClose, false);
	aWindow->CreateWindowsWindowFromWDEF(itsRsrcID);
#endif

	return aWindow;
}

//----------------------------------------------------------------------------------------
// TViewServer::NewTemplateWindow:
//----------------------------------------------------------------------------------------

TWindow* TViewServer::NewTemplateWindow(ResNumber viewRsrcID, TDocument* itsDocument)
{
	TWindow*theWindow = NULL;

	TView* aView = DoCreateViews(itsDocument, NULL, viewRsrcID, gZeroVPt);
	if (aView)
	{
		CAutoPtr_AC<TView> tempObject(aView);
#if qDebug
		if (!dynamic_cast_AC(TWindow*, aView))
			::ProgramBreak_AC("In NewTemplateWindow: Root view is not a window");
#endif
		theWindow = dynamic_cast_or_throw_AC(TWindow*, aView);

		if (theWindow->GetTargetID() != kNoIdentifier)
		{
			TView* theTarget = theWindow->FindSubView(theWindow->GetTargetID());
			if (theTarget)
				theWindow->SetWindowTarget(theTarget);
#if qDebug
			else
			{
#if 1
				::ProgramReport_AC("TViewServer::NewTemplateWindow: The window's indicated target view cannot be found.");
				CStr255_AC	errString("  Unable to find view with fTargetID: '"
							 + CStr255_AC(theWindow->GetTargetID())
							 + "'.");
				::ProgramReport_AC(errString);
				::ProgramBreak_AC("NOTE: To set the window target in a tab pane call SetWindow target after attaching the associated pane.");
#else
				CStr255_AC		errString("TViewServer::NewTemplateWindow: The window's indicated target view cannot be found.\n");
				errString += "  Unable to find view with fTargetID: '";
				errString += CStr255_AC(theWindow->GetTargetID());
				errString += "'.\n";
				errString += "NOTE: To set the window target in a tab pane call SetWindow target after attaching the associated pane.\n";
				::ProgramBreak_AC(CChar255_AC(errString));
#endif
			}
#endif
		}
		tempObject.release();
	}

	return theWindow;
}

//----------------------------------------------------------------------------------------
// TViewServer::ReadViewsFromResource:
//----------------------------------------------------------------------------------------

TView* TViewServer::ReadViewsFromResource(TDocument*			itsDocument,
										  TView*				parentView,
										  ResNumber				itsRsrcID,
										  const CViewPoint&		subviewOffset)
{
	#pragma unused (itsDocument)

	TView* firstView = NULL;					// Assume the worst.
	CAutoPtr_AC<TStream> itsViewStream(DoMakeViewStream(itsRsrcID, NULL));

	try
	{
		short numViews = itsViewStream->ReadInteger();

		if (numViews == kMAThreeOhTemplateVersion)// actually, the view template version
			firstView = ReadViewsFrom(itsViewStream, parentView, subviewOffset);// the new protocol
		else
			::ProgramBreak_AC("Incompatible version of 'View' resources");
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);

		CRandomAccessStream_AC* raViewStream = dynamic_cast_AC(CRandomAccessStream_AC*,itsViewStream.get());

		// set position so that when the view stream frees itself,
		// it won't truncate the handle (see THandleStream::Free)
		// If it did truncate the handle, we'd have no hope of ever
		// re-reading this 'View'
		if (raViewStream)
			raViewStream->SetPosition(raViewStream->GetSize());

		delete firstView;
		firstView = NULL;

		throw;
	}

	return firstView;
}

//----------------------------------------------------------------------------------------
// TViewServer::ReadViewsFrom:
//----------------------------------------------------------------------------------------

TView* TViewServer::ReadViewsFrom(CStream_AC*			itsStream,
								  TView*				parentView,
								  const CViewPoint&		subviewOffset)
{
	bool wasValid;
	TView* aView = dynamic_cast_AC(TView*,itsStream->ReadStreamObject(wasValid));
	if (wasValid && aView)
	{
		CAutoPtr_AC<TView> tempObject(aView);

		if (parentView)
			parentView->AddSubView(aView);

		if (subviewOffset != gZeroVPt)
			aView->Locate(aView->GetLocation() + subviewOffset, kDontInvalidate);

		tempObject.release();
	}
#if qDebugMsg
	else
		::ProgramBreak_AC("###Unknown TView in TViewServer::ReadViewsFrom.");
#endif

	return aView;
}

//----------------------------------------------------------------------------------------
// TViewServer::DoCreateViews:
//----------------------------------------------------------------------------------------

TView* TViewServer::DoCreateViews(TDocument*			itsDocument,
								  TView*				parentView,
								  ResNumber				itsRsrcID,
								  const CViewPoint&		subviewOffset)
{
#if qTemplateViews
	TView * rootView = ReadViewsFromResource(itsDocument, parentView, itsRsrcID, subviewOffset);
	if (rootView)
	{
		CAutoPtr_AC<TView> tempObject(rootView);

		rootView->HandlePostCreate(itsDocument);
		rootView->AdjustFrame();				// Make sure size gets adjusted by the size determiners

		tempObject.release();
	}

	return rootView;
#else
	return NULL;
#endif
}

//----------------------------------------------------------------------------------------
// TViewServer::DoMakeViewStream:
//----------------------------------------------------------------------------------------

CStream_AC* TViewServer::DoMakeViewStream(ResNumber itsRsrcID, Handle itsHandle)
{
	Handle viewStreamHandle;

	if (itsHandle)
		viewStreamHandle = itsHandle;
	else
	{
#if qDebug
		if (CountResources('View') == 0)
			::ProgramBreak_AC("Program has no 'View' resources! Is it built correctly?");
#endif
		// Try to get a new 'View' resource first.  If not found, then get a 'view' resource.
		viewStreamHandle = CMultiLocale_AC::GetResource('View', itsRsrcID);
#if qDebug
		if (!viewStreamHandle)
		{
			viewStreamHandle = CMultiLocale_AC::GetResource('view', itsRsrcID);
			if (viewStreamHandle)
			{
				::ProgramBreak_AC("Use ViewPromoter. Program contains 2.0 'view' resources");
				ReleaseResource(viewStreamHandle);
				viewStreamHandle = NULL;
			}
		}
#endif

		::ThrowIfNULLResource_AC(viewStreamHandle);
	}

	bool newEntry;

	// Create the stream context and its contents first, so that any memory failure here
	// only affects the context, and doesn't truncate the view stream resource handle.

	CAutoPtr_AC<THandleStream> itsViewStream(TH_new THandleStream(viewStreamHandle, sizeof(long)));

#if !qMSWindows
	CAutoPtr_AC<CStreamContext_AC> itsContext(TH_new CStreamContext_AC);

	itsContext->Add(&TAdorner::fgDimAdorner, kDontForceReplacement, newEntry);
	itsContext->Add(&TAdorner::fgDrawAdorner, kDontForceReplacement, newEntry);
	itsContext->Add(&TAdorner::fgEraseAdorner, kDontForceReplacement, newEntry);
	itsContext->Add(&TAdorner::fgHiliteAdorner, kDontForceReplacement, newEntry);
	itsContext->Add(&TAdorner::fgPrintAdorner, kDontForceReplacement, newEntry);
	itsContext->Add(&TAdorner::fgResizeIconAdorner, kDontForceReplacement, newEntry);
	itsContext->Add(&TAdorner::fgSelectionAdorner, kDontForceReplacement, newEntry);

	itsViewStream->SetContext(itsContext.release());
#else
	// ••• Terrible troubles getting VC++ to compile the above without the
	// link resulting in an undefined on:
	//		CAutoPtr_AC<CStreamContext_AC> operator->() const.
	CStreamContext_AC*	itsContext;
	try
	{
		itsContext = TH_new CStreamContext_AC;

		itsContext->Add(&TAdorner::fgDimAdorner, kDontForceReplacement, newEntry);
		itsContext->Add(&TAdorner::fgDrawAdorner, kDontForceReplacement, newEntry);
		itsContext->Add(&TAdorner::fgEraseAdorner, kDontForceReplacement, newEntry);
		itsContext->Add(&TAdorner::fgHiliteAdorner, kDontForceReplacement, newEntry);
		itsContext->Add(&TAdorner::fgPrintAdorner, kDontForceReplacement, newEntry);
		itsContext->Add(&TAdorner::fgResizeIconAdorner, kDontForceReplacement, newEntry);
		itsContext->Add(&TAdorner::fgSelectionAdorner, kDontForceReplacement, newEntry);

		itsViewStream->SetContext(itsContext);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		delete itsContext;
		throw;
	}
#endif

	return itsViewStream.release();
}

//----------------------------------------------------------------------------------------
// TViewServer::WriteViewsToResource:
//----------------------------------------------------------------------------------------

void TViewServer::WriteViewsToResource(TView*				view,
									   ResNumber			itsRsrcID,
									   const CStr255_AC&	name,
									   short				resourceAttributes)
{
#if qDebugMsg
	if (CMultiLocale_AC::DoesResourceExist('View', itsRsrcID))
		ProgramBreak_AC("###TViewServer::WriteViewsToResource warning: About to over-write 'View' resource id %d.\n", CMultiLocale_AC::GetExistingResourceID('View', itsRsrcID));
#endif

	CTempHandle_AC viewHandle(WriteViewsToHandle(view));// write the views to the handle
	::ThrowIfNULL_AC(viewHandle);

	CMultiLocale_AC::AddResource(viewHandle, 'View', itsRsrcID, name);// add the handle as a resource
	::ThrowIfResError_AC();

	SetResAttrs(viewHandle, resourceAttributes);// set the resource attributes
	::ThrowIfResError_AC();

	// Need the following ChangedResource call because the SetResAttrs call on the previous
	// line cleared the "resChanged" attribute of the resource.
	ChangedResource(viewHandle);
	::ThrowIfResError_AC();

	viewHandle.release();
}

//----------------------------------------------------------------------------------------
// TViewServer::WriteViewsToHandle:
//----------------------------------------------------------------------------------------

Handle TViewServer::WriteViewsToHandle(TView* view)
{
	CTempHandle_AC aHandle(NewPermHandle(kViewRsrcExpandAmt));// create a handle for the stream

	CAutoPtr_AC<TStream> itsViewStream(DoMakeViewStream(kNoResource, aHandle));

	itsViewStream->WriteInteger(kMAThreeOhTemplateVersion);// Write version number
	itsViewStream->WriteStreamObject(view, kStandardObject);

	return aHandle.release();
}

//----------------------------------------------------------------------------------------
// End of UViewServer.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/09/96	Removed UStreamable to a separate file from UObject
		05/25/96	[1353199] Potential memory leak when disposing windows.
		05/23/96	Account for STRICT_WINDOWS being taken out of ETO 21.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		----- R10 -----
		03/14/96	Replaced curly quotes with straight single quote.
		03/13/96	mwf 	Fixed bad MAVolatileInit in NewTemplateWindow.
		01/10/96	Enhanced debug message in NewTemplateWindow.
		12/18/95	Include UDispatcher.
		 12/8/95	Split up includes for modular MacApp.
		----- 3.3 -----
		10/10/95	TViewServer::NewTemplateWindow frees the new window if an
							exception is thrown.
		----- 3.3b1 -----
		 5/17/95	Use WindowRef accessors. Don't allocate our own storage
		 					under strict windows because we can't find out how much
							to allocate.
		 5/16/95	WindowRef
		 5/15/95	Change how NewTWindow allocates/deallocates storage for
		 					the wmgr window.
		  4/8/95	ARM 8.4.3 x& cannot be initialized with volatile x.
		 3/17/95	MAVolatile.
		 3/13/95	Change Free methods to destructors.
		02/22/95	1184041 Change NULL to NULL
*/