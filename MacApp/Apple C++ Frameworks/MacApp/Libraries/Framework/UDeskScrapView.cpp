//----------------------------------------------------------------------------------------
// UDeskScrapView.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/01/01	[C] Carbon scrap manager may return cantGetFlavorErr instead of noTypeErr. 
		04/24/01	Fixed comparison of scrap counts in CheckScrapContents. 
		04/23/01	Redesigned CClipboard_AC for Carbon. 
					Protected gClipboardMgr fields. 
		01/02/01	Update copyright.
		11/27/00	Use nil instead of NULL in call to TextBox_AC in Draw.
		11/10/00	Cosmetic.  Removed Inherited.
		11/09/00	[PB] Change initialization order to match declaration. 
					Need to get C string from standard string for printing. 
					Removed declaration of local static LookForScrapType function. 
					The real LookForScrapType is a static member function. 
		11/01/00	[PB] Include MacErrors instead of Errors. 
		09/18/00	[C] Call ScrapStillValid instead of ScrapCountStillValid.
		09/06/00	Added embedded documentation - TDeskScrapView::CheckScrapContents.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		07/23/99	[C] Scrap retrieval changed in CheckScrapContents and LookForScrapType.
		03/24/99	Update copyright notice.
		10/07/98	Use AsText instead of casting to char*. 
*/

#ifndef __UDESKSCRAPVIEW__
#include "UDeskScrapView.h"
#endif

// ACS

#ifndef __TextBox_AC__
#include "TextBox_AC.h"
#endif

// MacApp

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

//========================================================================================
// static data members
//========================================================================================

bool TDeskScrapView::gVarClipPicSize;

//static bool LookForScrapType(ResType theResType, ResType& resTypeFound);

//========================================================================================
// CLASS TDeskScrapView
//========================================================================================

MA_DEFINE_CLASS(TDeskScrapView);

//----------------------------------------------------------------------------------------
// TDeskScrapView constructor
//----------------------------------------------------------------------------------------

TDeskScrapView::TDeskScrapView()
	:	TView(gZeroVPt, CViewPoint(200, 200), sizeVariable, sizeVariable),
		fDataHandle(NULL),
			// Set our copy of the scrap count to the current count minus one.
			// We know the current scrap count increases in value over time,
			// so this is a way to produce a non-current value that will force an update. 
		fScrapCount(gClipboardMgr->GetScrapCount() - 1),
		fHavePicture(false),
		fHaveText(false)
{
	// Can't know the extent required until we actually read the data in, which we won't bother
	// to do unless forced to by receiving an Update event
}

//----------------------------------------------------------------------------------------
// TDeskScrapView destructor
//----------------------------------------------------------------------------------------

TDeskScrapView::~TDeskScrapView()
{
	if (this == gClipboardMgr->GetClipOrphanage())
		gClipboardMgr->ReleaseClipOrphanage();
}

//----------------------------------------------------------------------------------------
// TDeskScrapView::ReadFields: 
//----------------------------------------------------------------------------------------

void TDeskScrapView::ReadFields(CStream_AC* aStream)
{
	TView::ReadFields(aStream);

	// Set our copy of the scrap count to the current count minus one.
	// We know the current scrap count increases in value over time,
	// so this is a way to produce a non-current value that will force an update. 
	fScrapCount = gClipboardMgr->GetScrapCount() - 1;
}

//----------------------------------------------------------------------------------------
// TDeskScrapView::CalcMinFrame: 
//----------------------------------------------------------------------------------------

CViewRect TDeskScrapView::CalcMinFrame()
{
	CViewRect minFrame(TView::CalcMinFrame());

	if (fDataHandle)
		if (fHaveText)
		{
			// TEXT 
			if (Focus())
			{
				SetPortTextStyle(gSystemStyle);
				
				if (fSuperView)
					minFrame = SuperViewToLocal(fSuperView->GetFrame());

				CRect_AC qdArea(ViewToQD(minFrame));
				
				if (GetHandleSize(fDataHandle) < 32000)	// more than 32000 characters will kill TECalText
				{
					TEHandle aTEHandle = TENew(qdArea, qdArea);
					::ThrowIfNULL_AC((Ptr)aTEHandle);
	
					Handle oldHText = (*aTEHandle)->hText;	// We'll need this for TEDispose 
					(*aTEHandle)->hText = fDataHandle;
	
					TECalText(aTEHandle);
	
					minFrame.bottom = minFrame.top + Min_AC((*aTEHandle)->nLines * (*aTEHandle)->lineHeight, static_cast<short>(kMaxQDCoord));
	
					(*aTEHandle)->hText = oldHText;	// So TEDispose doesn't dispose our handle 
	
					TEDispose(aTEHandle);
				}
			}
		}
		else
		{
#if qDebugMsg
			if (gIntenseDebugging)
			{
				CRect_AC picFrame = (**(PicHandle)fDataHandle).picFrame;
				ProgramReport_AC("Picture Frame:");
				ProgramReport_AC("%s\n", picFrame.AsText().c_str());
			}
#endif
			if (!gVarClipPicSize)
			{
				CRect_AC picFrame = (*((PicHandle)fDataHandle))->picFrame;
				minFrame[botRight] = minFrame[topLeft] + CViewPoint(picFrame.GetSize());
			}
		}

	return minFrame;
}

//----------------------------------------------------------------------------------------
// TDeskScrapView::CheckScrapContents: 
//----------------------------------------------------------------------------------------

void TDeskScrapView::CheckScrapContents()
// CheckScrapContents is intended to determine whether anything is stored 
// in the desk scrap associated with the TDeskScrapView object and, if so,
// what type of data is stored there. TDeskScrapView::CheckScrapContents
// detects data of type 'TEXT' and of type 'PICT'.
//
// Call?		Seldom. MacApp calls CheckScrapContents before drawing 
//				the viewÕs contents.
// Override?	As needed.
{
	if (gClipboardMgr->GetScrapCount() != fScrapCount)
	{
		// Make sure we get rid of the old scrap handle if necessary 
		fDataHandle = ::DisposeIfHandle_AC(fDataHandle);

		ResType resTypeFound;
		fHavePicture = LookForScrapType(kPictType_AC, resTypeFound);
		fHaveText = LookForScrapType(kTextType_AC, resTypeFound);

		if (fHavePicture || fHaveText)
		{
			CTempHandle_AC aHandle(NewPermHandle(0));

			try
			{
				{
					CTempAllocation savedTemp(false);
					gClipboardMgr->GetScrap(aHandle, resTypeFound);
				}
				fDataHandle = aHandle.release();
				AdjustFrame();
				Focus();					// Make sure we're still focused 
			}
			catch(CException_AC& theException)
			{
				DoCatchMessage_AC(theException);
				fDataHandle = NULL;
				throw;
			}
		}
	}
}

//----------------------------------------------------------------------------------------
// TDeskScrapView::Draw: 
//----------------------------------------------------------------------------------------

void TDeskScrapView::Draw(const CViewRect& area)
{
	// Draw routine must not fail. Otherwise alert can cause an infinite loop of draw
	// fail, alert, update event, draw fail, etc..
	try
	{
#if qDebug
		AssumeFocused();
#endif

		// Has scrap been updated since we last drew? 
		CheckScrapContents();
	
		CRect_AC aRect;
		if (fHaveText)
		{
			SetPortTextStyle(gApplicationStyle);
			aRect = GetQDExtent();
	
			CTempHandleLock_AC tempHandleLock(fDataHandle);
			
			TextBox_AC(*fDataHandle, GetHandleSize(fDataHandle), aRect, teFlushDefault, kAutoWrap, nil, kNoEraseFirst, kNoSpaceForCaret);
		}
		else if (fHavePicture)
		{
			if (gVarClipPicSize)
				aRect = GetQDExtent();
			else
				aRect.Set(gZeroPt, ((CRect_AC &) (**((PicHandle)fDataHandle)).picFrame).GetSize());
	
			DrawPicture((PicHandle)fDataHandle, &aRect);
		}
	
		if (!gClipboardMgr->GetScrapCount() == fScrapCount)
		{
			Validate(aRect);				// avoid flicker upon clipboard installation
			fScrapCount = gClipboardMgr->GetScrapCount();
			gClipboardMgr->WrittenToDeskScrap();// Don't need to write it back out. 
		}
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		// do nothing. We could draw a string "unable to show the clipboard at this time"
		// definitely *don't* resignal.
	}
	

	TView::Draw(area);
}

//----------------------------------------------------------------------------------------
// TDeskScrapView::SuperViewChangedFrame: 
//----------------------------------------------------------------------------------------

void TDeskScrapView::SuperViewChangedFrame(const CViewRect& oldFrame,
												 const CViewRect& newFrame,
												 bool invalidate)
{
	if (oldFrame.GetSize() != newFrame.GetSize())
	{
		AdjustFrame();

		if (invalidate)
			ForceRedraw();		// because of word wrap
	}
}

//----------------------------------------------------------------------------------------
// TDeskScrapView::WriteToDeskScrap: 
//----------------------------------------------------------------------------------------

void TDeskScrapView::WriteToDeskScrap()
{
	// This view represents data that's already written to the desk scrap 
}

//----------------------------------------------------------------------------------------
// LookForScrapType: 
//----------------------------------------------------------------------------------------

bool TDeskScrapView::LookForScrapType(ResType theResType, ResType& resTypeFound)
{
	long dataLength = gClipboardMgr->GetFlavorSize(theResType);
	if (dataLength > 0)
		resTypeFound = theResType;
#if qDebugMsg
	else if ((dataLength < 0) && (dataLength != noTypeErr) && (dataLength != cantGetFlavorErr))
		ProgramReport_AC("LookForScrapType: err = %d\n", dataLength);
#endif

	return (dataLength > 0);
}

//----------------------------------------------------------------------------------------
// End of UDeskScrapView.cp



/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		05/03/96	Removed TDeskScrapView::Free. Now we check in TView::FreeFromClipboard instead.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Whoops, forgot to .DontRelease handle in CheckScrapContents
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		----- R10 -----
		03/28/96	CalcMinFrame now returns a CViewRect
		03/26/96	CStr255_AC to char* conversion now requires const
		 3/18/96	Made better use of TView calls that return CRect_AC/CViewPoint/CViewRect
		 3/01/96	Re-arranged data members, natural alignment results in 
		 					reduced storage size.
		 12/8/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		----- 3.3b1 -----
		  4/8/95	Unlock text data handle upon failure. 
		 3/20/95	Use LockHandle_AC instead of LockHandleHigh wherever possible. 
		 3/17/95	MAVolatile. 
		 3/16/95	Add back the Free method to prevent the clip orphanage from
		 					being freed. 
		 3/13/95	Change Free methods to destructors. 
		02/07/95	Create missing prototypes for static functions used internally. 
*/