//----------------------------------------------------------------------------------------
// USectionMgr.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		07/24/00	CW Pro 6: casting from pointer to long. 
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		04/18/00	Include UPrintMgr.h instead of UPrintHandler.h.
		03/24/99	Update copyright notice.
*/

#ifndef __USECTIONMGR__
#include "USectionMgr.h"
#endif

// MacApp

#ifndef __UADORNERS__
#include "UAdorners.h"
#endif

#ifndef __UAPPLEEVENTS__
#include "UAppleEvents.h"
#endif

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDESKSCRAPVIEW__
#include "UDeskScrapView.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UEDITIONDOCUMENT__
#include "UEditionDocument.h"
#endif

#ifndef __UERRORMGR__
#include "UErrorMgr.h"
#endif

#ifndef __UFILEBASEDDOCUMENT__
#include "UFileBasedDocument.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPrintMgr__
#include "UPrintMgr.h"
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

#ifndef __USECTION__
#include "USection.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// Toolbox

#ifndef __BALLOONS__
#include <Balloons.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MENUS__
#include <Menus.h>
#endif

#ifndef __PACKAGES__
#include <Packages.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __SCRAP__
#include <Scrap.h>
#endif

#ifndef __SCRIPT__
#include <Script.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

// ANSI


//----------------------------------------------------------------------------------------
// private global variables
bool pSectionMgrInitialized;


//========================================================================================
// CLASS TSectionMgr
//========================================================================================
MA_DEFINE_CLASS(TSectionMgr);

//----------------------------------------------------------------------------------------
// TSectionMgr::TSectionMgr:
//----------------------------------------------------------------------------------------
TSectionMgr::TSectionMgr() :
	TBehavior(kSectionMgrBehaviorID)
{
}

//----------------------------------------------------------------------------------------
// TSectionMgr::Free: 
//----------------------------------------------------------------------------------------
TSectionMgr::~TSectionMgr()
{
}

//----------------------------------------------------------------------------------------
// TSectionMgr::DoAESectionEvent: 
//----------------------------------------------------------------------------------------
void TSectionMgr::DoAESectionEvent(CommandNumber aCommandNumber,
								 const AppleEvent& message,
								 const AppleEvent& reply)
{
	TSectionCommand* theCommand = NULL;

	switch (aCommandNumber)
	{
		case cSectionRead:
			theCommand = TH_new TSectionReadEventCommand(aCommandNumber, message, reply);
			break;

		case cSectionWrite:
			theCommand = TH_new TSectionWriteEventCommand(aCommandNumber, message, reply);
			break;

		case cSectionScroll:
			theCommand = TH_new TSectionScrollEventCommand(aCommandNumber, message, reply);
			break;

		case cSectionCancel:
			theCommand = TH_new TSectionCancelEventCommand(aCommandNumber, message, reply);
			break;
	}

	if (theCommand)
		fOwner->PostCommand(theCommand);
}


//========================================================================================
// CLASS TSectionCommand
//========================================================================================
//----------------------------------------------------------------------------------------
// TSectionCommand::TSectionCommand
//----------------------------------------------------------------------------------------
TSectionCommand::TSectionCommand(CommandNumber itsCommandNumber,
									  TDocument* itsDocument,
									  TSection* itsSection) :
	TServerCommand(itsCommandNumber, itsDocument, kCantUndo, kDoesNotCauseChange, itsDocument),

	fSection(itsSection)
{
}

//----------------------------------------------------------------------------------------
// TSectionCommand::TSectionCommand
//----------------------------------------------------------------------------------------
TSectionCommand::TSectionCommand(CommandNumber itsCommandNumber,
								 const AppleEvent& itsMessage,
								 const AppleEvent& itsReply) :
	TServerCommand(itsCommandNumber, gDispatcher, kCantUndo, kDoesNotCauseChange, NULL,
				   itsMessage, itsReply),

	fSection(NULL)
{
	// get the section handle 
	SectionHandle aSectionHandle = fMessage->ReadSectionHandle(keyDirectObject);
#if qDebug
	if (gIntenseDebugging)
		ProgramReport_AC("SectionHandle from AppleEvent = %ld \n", reinterpret_cast<unsigned long>(aSectionHandle));
#endif
	
	TSectionMgr* aSectionMgr =
		dynamic_cast_or_throw_AC(TSectionMgr*,gDispatcher->GetBehaviorWithIdentifier(kSectionMgrBehaviorID));

	for (CSectionIterator iter(&aSectionMgr->fSectionList); iter.Current(); ++iter)
		if ((*iter).GetSectionHandle() == aSectionHandle)
		{
			fSection = iter;
			break;
		}

	if (!fSection)
		::ThrowException_AC(noErr, 0);	// silent failure
	
	// associate the command correctly 
	fContext = fSection->GetDocument();

#if qDebug
	::ThrowIfNonObject_AC(fContext);
#endif

	// ensure that the section is registered 
	::ThrowIfOSErr_AC(fSection->Register());
}

//----------------------------------------------------------------------------------------
// TSectionCommand destructor
//----------------------------------------------------------------------------------------
TSectionCommand::~TSectionCommand()
{
}

//========================================================================================
// CLASS TSectionReadEventCommand
//========================================================================================
//----------------------------------------------------------------------------------------
// TSectionReadEventCommand::TSectionReadEventCommand: 
//----------------------------------------------------------------------------------------
TSectionReadEventCommand::TSectionReadEventCommand(CommandNumber itsCommandNumber,
													   TDocument* itsDocument,
													   TSubscriber* itsSubscriber) :

	TSectionCommand(itsCommandNumber, itsDocument, itsSubscriber)
{
	fCausesChange = kCausesChange;
}

//----------------------------------------------------------------------------------------
// TSectionReadEventCommand destructor
//----------------------------------------------------------------------------------------
TSectionReadEventCommand::~TSectionReadEventCommand()
{
}

//----------------------------------------------------------------------------------------
// TSectionReadEventCommand::DoIt: 
//----------------------------------------------------------------------------------------
void TSectionReadEventCommand::DoIt()	// override 
{
	TSubscriber * aSubscriber = dynamic_cast_or_throw_AC(TSubscriber*,fSection);

	if ((!aSubscriber->GetDocument()->GetStopAllEditions()) && (aSubscriber->GetUpdateMode() == sumAutomatic))
		aSubscriber->Subscribe();
}


//========================================================================================
// CLASS TSectionWriteEventCommand
//========================================================================================
//----------------------------------------------------------------------------------------
// TSectionWriteEventCommand destructor
//----------------------------------------------------------------------------------------
TSectionWriteEventCommand::~TSectionWriteEventCommand()
{
}

//----------------------------------------------------------------------------------------
// TSectionWriteEventCommand::DoIt: 
//----------------------------------------------------------------------------------------
void TSectionWriteEventCommand::DoIt()	// override 
{
	TFile* itsFile = NULL;
	TFileBasedDocument* aFileBasedDocument = fSection->GetDocument();
	if (aFileBasedDocument && aFileBasedDocument->FileExists())
		itsFile = aFileBasedDocument->GetFile();
	
	dynamic_cast_or_throw_AC(TPublisher*,fSection)->Publish(itsFile);
}


//========================================================================================
// CLASS TSectionScrollEventCommand
//========================================================================================
//----------------------------------------------------------------------------------------
// TSectionScrollEventCommand destructor
//----------------------------------------------------------------------------------------
TSectionScrollEventCommand::~TSectionScrollEventCommand()
{
}

//----------------------------------------------------------------------------------------
// TSectionScrollEventCommand::DoIt: 
//----------------------------------------------------------------------------------------
void TSectionScrollEventCommand::DoIt()	// override 
{
	// at this point, the application has received and processed the 'odoc' AppleEvent 
	// so, the window containing the section should be frontmost

	// 1. bring the application to front (using the Process Manager) 
	gDispatcher->MakeFrontProcess();

	// 2. tell the document to reveal the selection and select it
	if (fContext)
		dynamic_cast_or_throw_AC(TEditionDocument*,fContext)->RevealSelection(fSection->GetDesignator());
}


//========================================================================================
// CLASS TSectionCancelEventCommand
//========================================================================================
//----------------------------------------------------------------------------------------
// TSectionCancelEventCommand::TSectionCancelEventCommand: 
//----------------------------------------------------------------------------------------
TSectionCancelEventCommand::TSectionCancelEventCommand(CommandNumber itsCommandNumber,
														   TDocument* itsDocument,
														   TSection* itsSection) :

	TSectionCommand(itsCommandNumber, itsDocument, itsSection)
{
	fCanUndo = kCanUndo;		// can undo the cancel
	fCausesChange = kCausesChange;
}

//----------------------------------------------------------------------------------------
// TSectionCancelEventCommand destructor
//----------------------------------------------------------------------------------------
TSectionCancelEventCommand::~TSectionCancelEventCommand()
{
	if (fCommandDone && fSection)
		fSection->Delete();
	
	delete fSection;
	fSection = NULL;
}

//----------------------------------------------------------------------------------------
// TSectionCancelEventCommand::DoIt: 
//----------------------------------------------------------------------------------------
void TSectionCancelEventCommand::DoIt()	// override 
{
	fSection->CancelSection(kCancel);
	dynamic_cast_or_throw_AC(TEditionDocument*,fContext)->DoDeleteBorder(fSection);
}

//----------------------------------------------------------------------------------------
// TSectionCancelEventCommand::UndoIt: 
//----------------------------------------------------------------------------------------
void TSectionCancelEventCommand::UndoIt()	// override 
{
	fSection->CancelSection(!kCancel);
	dynamic_cast_or_throw_AC(TEditionDocument*,fContext)->DoAddBorder(fSection);
}

//========================================================================================
// GLOBAL Procedures
//========================================================================================
//----------------------------------------------------------------------------------------
// InitUSectionMgr: 
//----------------------------------------------------------------------------------------
void InitUSectionMgr()

{
	if (!pSectionMgrInitialized)
	{
		// instantiate a section mgr and give the application this behavior
		gDispatcher->AddBehavior(TH_new TSectionMgr);

		pSectionMgrInitialized = true;
	}
}

//----------------------------------------------------------------------------------------
// End of USectionMgr.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/03/96	Use FailNonObject for object testing diagnostics.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/18/96	More Use post-increment with iterators in while loops
		----- R10 -----
		01/04/96	Get rid of TFileHandler. 
		12/19/95	Don't need failure handler in DoIt just for SetValidationError. 
							Move TSectionCancelEventCommand::Commit code to destructor. 
		12/08/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		----- 3.3b1 -----
		08/22/95	Changed calls to ReportError to SetValidationError.
		08/14/95	Add overloaded initializers for TServerCommand. 
		05/15/95	Remove support for pre-system 7. 
		04/12/95	Use #if instead of if qDebug. 
		03/17/95	Remove unnecessary volatile macro. 
		03/13/95	Change Free methods to destructors. 
		02/13/95	Remove unnecessary initialization of static variables. See ARM §8.4 
		09/14/94	Removed support for DoAppleCommand. Added support
							for DoAESectionCommand.
*/