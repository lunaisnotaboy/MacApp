//----------------------------------------------------------------------------------------
// UControl.cpp
// Copyright � 1987-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/22/01	Make IsDimmed const. Add SetDimmed. 
		04/12/01	Install font settings in CreateControl in case the control is not
					in a window at DoPostCreate time.
		03/01/01	Don't include Windows_AC. 
		01/02/01	Update copyright.
		12/26/00	[W] SetTransparentView in ctors.
		12/12/00	Don�t set font in Focus.  Added DoPostCreate and set font
					therein.  Removed TControl::Focus.
		11/09/00	[PB] Suppress GCC warnings about unused return variables. 
		11/03/00	[C] Don�t include Balloons.h.  gcc confused by view comparison in
					UpdateCoordinates so added a cast.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		10/24/00	EmbedControls takes const.
		10/16/00	[W] Added GetWindowsFontName and SetWindowsWindow.
		10/04/00	CWhileFocused shouldn't move the control back to its old
					location. SetCMgrVisibility should focus and set the control
					location before making it visible. 
		09/21/00	Override ClipFurtherTo and OffsetAndClipFurtherTo. On Carbon,
					clipping to the view may cut off control shadows. 
		09/07/00	Added embedded documentation.
		09/01/00	Stripped dead code.  Cosmetic, eliminated Inherited and added
					pragma unused's.
		07/31/00	[W] Added HandleWindowsEvent and CreateWindowsWindow.  Added
					implementation for SetText and CreateControl.
		07/05/00	Added GetEmbeddingControl and EmbedControls.  Some cosmetic cleanup.
		06/01/00	Test against HasAppearanceMgr_AC and do not change control owner
					in TCtlMgr::Draw.
		05/15/00	CW Pro 6: implicit int not allowed.
		04/18/00	Include UPrintMgr.h instead of UPrintHandler.h.
		03/31/00	Include UPrintHandler.h.
		03/17/00	Special case UpdateCoordinates for control manager controls.
					The origin needs to be zero and the view to QD offset is the
					location of the control relative to its window.
		07/12/99	Remove InvalidateInset.
					If we're activating or dimming a control while updating the
					window, draw it immediately instead of invalidating. This prevents
					an extra update to the window.
		04/15/99	Include CPattern_AC.h.
		03/29/99	Rename Patterns_AC to CPattern_AC to avoid confusion with the
					include file.
		03/24/99	Update copyright notice.
		03/23/99	Replace ...Rect_AC calls with standard Toolbox rect calls.
		03/23/99	Renamed SetPenPatToGray_AC to Patterns_AC::SetPenPatToGray.
		03/18/99	Removed '&' on parms to a variety of Toolbox calls.
		03/04/99	[2284753] Check Appearance version before drawing control when printing
					in TCtlMgr::Draw.
		02/18/98	[2306500] Added a check for printing in TCtlMgr::BeInPort.
		02/03/99	[C] Balloon help not available under Carbon.
		11/09/98	[2279100] Moved ContainsTarget from TControl to TView.
		11/05/98	Carbon - use SetPenPatToGray_AC(), GetGrafPtr_AC()
		10/29/98	[W] No longer necessary to include QTMLMapNames.h.  Use InvertRect_AC,
					SetPort_AC and include ImagingUtils_AC.h.
		10/26/98	Carbonize
*/

#ifndef __UCONTROL__
#include "UControl.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CIterator__
#include "CIterator_AC.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __CPattern_AC__
#include "CPattern_AC.h"
#endif

#ifndef __CToolboxControl_AC__
#include "CToolboxControl_AC.h"
#endif

#ifndef __ImagingStreaming_AC__
#include "ImagingStreaming_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __WindowUtils_AC__
#include "WindowUtils_AC.h"
#endif

// MacApp

#ifndef __UADORNERS__
#include "UAdorners.h"
#endif

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UDRAWINGENVIRONMENT__
#include "UDrawingEnvironment.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UPrintMgr__
#include "UPrintMgr.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// Toolbox

#if !qCarbon
	#ifndef __BALLOONS__
	#include <Balloons.h>
	#endif
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MACWINDOWS__
#include <MacWindows.h>
#endif

// ANSI

#ifndef __LIMITS__
#include <limits.h>
#endif


#ifndef __STDLIB__
#include <stdlib.h>
#endif

#ifndef __APPEARANCE__
#include <Appearance.h>
#endif

//========================================================================================
// CLASS CWhileFocused
//========================================================================================

//----------------------------------------------------------------------------------------
// CWhileFocused constructor
//----------------------------------------------------------------------------------------

CWhileFocused::CWhileFocused(TControl*		itsView,
							 CControl_AC*	itsControl,
							 bool			redraw,
							 bool			preferOutline)
	:	CWhileOutlinePreferred_AC(preferOutline),
		fControl(itsControl)
// CWhileFocused is the constructor method for the CWhileFocused class. Use 
// this method to construct CWhileFocused objects as needed to maintain the graphics
// environment when manipulating objects of class TCtlMgr or its subclasses. See
// CWhileFocused for more information.
//
// itsControl:	Specifies the CControl_AC object associated with the Control Manager 
// 				control being focused.
// redraw:		Specifies whether the control is to be redrawn. TRUE indicates 
// 				that the control is to be redrawn by the Focus method.
//
// Call?		As needed.
// Override?	NEVER. It is a constructor.
{
	Prepare(itsView, redraw);
}

//----------------------------------------------------------------------------------------
// CWhileFocused constructor
//----------------------------------------------------------------------------------------

CWhileFocused::CWhileFocused(TCtlMgr* itsView, bool redraw)
	:	CWhileOutlinePreferred_AC(itsView->fPreferOutline),
		fControl(itsView->GetControl())
{
	Prepare(itsView, redraw);
}

//----------------------------------------------------------------------------------------
// CWhileFocused destructor
//----------------------------------------------------------------------------------------

CWhileFocused::~CWhileFocused()
{
	Cleanup();
}

//----------------------------------------------------------------------------------------
// CWhileFocused::Prepare
//----------------------------------------------------------------------------------------

void CWhileFocused::Prepare(TControl* itsView, bool redraw)
{
	if (fControl)
	{
		fWasVisible = fControl->SetVisibility(false);
		if (redraw && itsView->Focus())
		{
			CRect_AC qdArea(itsView->ControlQDArea());
			fControl->SetLocation(qdArea[topLeft]);
			fControl->SetVisibility(fWasVisible);
		}
	}
}

//----------------------------------------------------------------------------------------
// CWhileFocused::Cleanup
//----------------------------------------------------------------------------------------

void CWhileFocused::Cleanup()
{
	if (fControl)
		fControl->SetVisibility(fWasVisible);	// �restore visibility
}

//========================================================================================
// CLASS TControlTracker
//========================================================================================

//----------------------------------------------------------------------------------------
// TControlTracker constructor
//----------------------------------------------------------------------------------------

TControlTracker::TControlTracker(TControl*			theControl,
								 const CViewPoint&	itsMouse)
	:	TTracker(cTrackingControl, theControl, kCantUndo, kDoesNotCauseChange, NULL,
				 theControl, theControl->GetScroller(kImmediateSuperView), itsMouse),
		fControl(theControl)
{

#if qDebug
	if (!theControl)
		::ProgramBreak_AC("Control passed to IControlTracker can''t be nil.");
#endif

	fTrackNonMovement = true;
	fViewConstrain = false;
}

//----------------------------------------------------------------------------------------
// TControlTracker destructor
//----------------------------------------------------------------------------------------

TControlTracker::~TControlTracker()
{
}

//========================================================================================
// CLASS TControl
//========================================================================================

MA_DEFINE_CLASS(TControl);

//----------------------------------------------------------------------------------------
// TControl constructor
//----------------------------------------------------------------------------------------

TControl::TControl(	const CViewPoint&		itsLocation,
					const CViewPoint&		itsSize,
					SizeDeterminer			itsHSizeDet,
					SizeDeterminer			itsVSizeDet,
					const CTextStyle_AC&	itsTextStyle)
	:	TView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
		fEventNumber(mOKHit),
		fTextStyleRsrcID(kNoResource),
		fTextStyle(itsTextStyle),
		fHilite(false),
		fSizeable(true),
		fPreferOutline(kDontPreferOutline)
{
#if qDebug
	if (itsSize.h > kMaxCoord || itsSize.v > kMaxCoord)
		::ProgramBreak_AC("The size in pixels of a TControl cannot exceed %ld\n", kMaxCoord);
#endif
	// By default, controls are assumed to require redrawing the entire frame when
	// the frame changes size.  Call SetFrameInvalidateDeterminer to change this default.
	fFrameInvalidateDeterminer = frameInvalidateWholeFrame;
#if qMSWindows
	SetTransparentView(true);
#endif
}

//----------------------------------------------------------------------------------------
// TControl copy constructor
//----------------------------------------------------------------------------------------

TControl::TControl(const TControl& inControl)
	:	TView(inControl),
		fInset(inControl.fInset),
		fEventNumber(inControl.fEventNumber),
		fTextStyleRsrcID(inControl.fTextStyleRsrcID),
		fTextStyle(inControl.fTextStyle),
		fHilite(inControl.fHilite),
		fSizeable(inControl.fSizeable),
		fPreferOutline(inControl.fPreferOutline)
{
}

//----------------------------------------------------------------------------------------
// TControl destructor
//----------------------------------------------------------------------------------------

TControl::~TControl()
{
}

//----------------------------------------------------------------------------------------
// TControl::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TControl::GetStandardSignature() const
{
	return kStdControl;
}

//----------------------------------------------------------------------------------------
// TControl::ReadFields:
//----------------------------------------------------------------------------------------

void TControl::ReadFields(CStream_AC* aStream)
{
	TView::ReadFields(aStream);

	fEventNumber = aStream->ReadLong();

	// set various flags
	HiliteState(aStream->ReadBoolean(), kDontRedraw);
	SetActiveState(!aStream->ReadBoolean(), kDontRedraw);
	fSizeable = aStream->ReadBoolean();

	*aStream >> fInset;

	fTextStyleRsrcID = aStream->ReadInteger();
	if (fTextStyleRsrcID != kNoResource)
		fTextStyle = MAGetTextStyle(fTextStyleRsrcID);

	fPreferOutline = aStream->ReadBoolean();

#if qDebug
	if ((fSize.h > kMaxCoord) || (fSize.v > kMaxCoord))
		::ProgramBreak_AC("The size in pixels of a TControl cannot exceed %ld\n", kMaxCoord);
#endif
}

//----------------------------------------------------------------------------------------
// TControl::WriteFields:
//----------------------------------------------------------------------------------------

void TControl::WriteFields(CStream_AC* aStream) const
{
	TView::WriteFields(aStream);

	aStream->WriteLong(fEventNumber);				// write its fEventNumber

	aStream->WriteBoolean(fHilite);
	aStream->WriteBoolean(!fIsActive /*fDimmed*/);
	aStream->WriteBoolean(fSizeable);

	*aStream << fInset;

	aStream->WriteInteger(fTextStyleRsrcID);
	aStream->WriteBoolean(fPreferOutline);
}

//----------------------------------------------------------------------------------------
// TControl::ComputeFrame:
//----------------------------------------------------------------------------------------

void TControl::ComputeFrame(CViewRect& newFrame)
{
	TView::ComputeFrame(newFrame);
	if (!fSizeable)
	{
		// �we need to adjust the bot/right offset
		// If view is going to change size, then doesn't change control's actual size
		fInset[botRight] += newFrame.GetSize() - fSize;
	}
}

//----------------------------------------------------------------------------------------
// TControl::ContainsMouse:
//----------------------------------------------------------------------------------------

bool TControl::ContainsMouse(const CViewPoint& theMouse)
{
	return ControlArea().Contains(theMouse) && TView::ContainsMouse(theMouse);
}

//----------------------------------------------------------------------------------------
// TControl::ControlArea:
//----------------------------------------------------------------------------------------

CViewRect TControl::ControlArea()
// ControlArea returns the view rectangle that is the control�s active area.
// For example, MacApp uses this method when tracking the mouse pointer in 
// a control view.
//
// Call?		As needed.
// Override?	Never.
{
	CViewRect theArea(GetExtent());

	theArea.Inset(fInset);

	CntlAdornment itsAdornment;
	GetAdornment(itsAdornment);
	if (macroIn(itsAdornment, adnShadow))
	{
		CPoint_AC itsPenSize;
		GetPenSize(itsPenSize);
		theArea[botRight] -= CViewPoint(itsPenSize);
	}

	return theArea;
}

//----------------------------------------------------------------------------------------
// TControl::ControlQDArea:
//----------------------------------------------------------------------------------------

CRect_AC TControl::ControlQDArea()
{
	return ViewToQD(ControlArea());
}

//----------------------------------------------------------------------------------------
// TControl::Dim:
//----------------------------------------------------------------------------------------

void TControl::Dim()
{
#if qDebug
	AssumeFocused();
#endif

	CPattern_AC::SetPenPatToGray();
	PenMode(patBic);
	PaintRect(ControlQDArea());
}

//----------------------------------------------------------------------------------------
// TControl::DimState:
//----------------------------------------------------------------------------------------

void TControl::DimState(bool state, bool redraw)
{
	SetActiveState(!state, redraw); // synonym
}

//----------------------------------------------------------------------------------------
// TControl::Activate:
//----------------------------------------------------------------------------------------

void TControl::Activate(bool entering)
{
	//if (fWasActive != entering)
	//{
		// AddAdorner checks if adorner has already been added.  DeleteAdorner does
		// nothing if adorner has already been removed.

		if (!entering)							// dim adorner draws the inactive state
			AddAdorner(&TAdorner::fgDimAdorner, kAdornLast - 10, kDontRedraw);
		else
			DeleteAdorner(&TAdorner::fgDimAdorner, kDontRedraw);
	//}

//		if(!HasPendingUpdate())
//			DrawContents();
//		else
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TControl::DoMouseCommand:
//----------------------------------------------------------------------------------------

void TControl::DoMouseCommand(CViewPoint&		theMouse,
							  TToolboxEvent*	event,
							  CPoint_AC			hysteresis)
{
	#pragma unused (event, hysteresis)

	PostCommand(TH_new TControlTracker(this, theMouse));
}

//----------------------------------------------------------------------------------------
// TControl::DoEvent:
//----------------------------------------------------------------------------------------

void TControl::DoEvent(EventNumber		eventNumber,
					   TEventHandler*	source,
					   TEvent*			event)
{
	switch (eventNumber)
	{
		case mTurnOn:
			HiliteState(true,kRedraw);
			break;

		case mTurnOff:
			HiliteState(false,kRedraw);
			break;

		case mToggle:
			HiliteState(!fHilite,kRedraw);
			break;

		default:
			TView::DoEvent(eventNumber, source, event);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TControl::Flash:
//----------------------------------------------------------------------------------------

void TControl::Flash()
{
	HiliteState(true, kRedraw);
	DelayFuture_AC(8);
	HiliteState(false, kRedraw);
}

//----------------------------------------------------------------------------------------
// TControl::Hilite:
//----------------------------------------------------------------------------------------

void TControl::Hilite()
{
#if qDebug
	AssumeFocused();
#endif

	::MacInvertRect(ControlQDArea());
}

//----------------------------------------------------------------------------------------
// TControl::HiliteState:
//----------------------------------------------------------------------------------------

void TControl::HiliteState(bool state, bool redraw)
{
	if (state != fHilite)
	{
		fHilite = state;
		if (state)								// hilite adorner draws the hilite state
			AddAdorner(&TAdorner::fgHiliteAdorner, kAdornLast - 5, kDontRedraw);
		else
			DeleteAdorner(&TAdorner::fgHiliteAdorner, kDontRedraw);
		if (redraw && IsDrawable())
			Hilite();
	}
}

//----------------------------------------------------------------------------------------
// TControl::Inset:
//----------------------------------------------------------------------------------------

void TControl::Inset(const CViewPoint& delta, bool redraw)
{
	if (fSizeable)
	{
		fInset += delta;

		if (redraw)
			ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TControl::InstallColor:
//----------------------------------------------------------------------------------------

void TControl::InstallColor(const CRGBColor_AC& theColor, bool redraw)
{
	fTextStyle.tsColor = theColor;
	if (redraw)
		DrawContents();
}

//----------------------------------------------------------------------------------------
// TControl::InstallTextStyle:
//----------------------------------------------------------------------------------------

void TControl::InstallTextStyle(const CTextStyle_AC& theTextStyle, bool redraw)
{
	fTextStyle = theTextStyle;
	if (redraw)
		DrawContents();
}

//----------------------------------------------------------------------------------------
// TControl::IsDimmed:
//----------------------------------------------------------------------------------------

bool TControl::IsDimmed() const
{
	return !IsActive(); // fDimmed; synonym.
}

//----------------------------------------------------------------------------------------
// TControl::IsDimmed:
//----------------------------------------------------------------------------------------

void TControl::SetDimmed(bool dimmed)
{
	return SetActiveState(!dimmed, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TControl::GetAdornExtent:
//----------------------------------------------------------------------------------------

CViewRect TControl::GetAdornExtent()
{
	CViewRect itsAdornExtent = GetExtent();

	CntlAdornment itsAdornment;
	GetAdornment(itsAdornment);
	if (macroIn(itsAdornment, adnShadow))
	{
		CPoint_AC itsPenSize;
		GetPenSize(itsPenSize);
		itsAdornExtent[botRight] -= CViewPoint(itsPenSize);
	}

	return itsAdornExtent;
}

//----------------------------------------------------------------------------------------
// TControl::GetEventNumber:
//----------------------------------------------------------------------------------------

EventNumber TControl::GetEventNumber()
{
	return fEventNumber;
}

//----------------------------------------------------------------------------------------
// TControl::SetAdornment:
//----------------------------------------------------------------------------------------

void TControl::SetAdornment(/*CntlAdornment*/ short newAdornment, bool redraw)
//!!! Using short rather than CntlAdornment because of a compiler bug
{
	TCompatibilityAdorner* itsAdorner = dynamic_cast_AC(TCompatibilityAdorner*, AdornerWithID(kCompatibilityAdorner));
	if (!itsAdorner)
	{
		if (newAdornment)
		{
			itsAdorner = TH_new TCompatibilityAdorner(newAdornment);
			AddAdorner(itsAdorner, kAdornAfter, redraw);
		}
	}
	else
	{
		itsAdorner->fAdornment = newAdornment;
		if (redraw)
			ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TControl::GetAdornment:
//----------------------------------------------------------------------------------------

void TControl::GetAdornment(CntlAdornment& itsAdornment)
{
	TAdorner* itsAdorner = AdornerWithID(kCompatibilityAdorner);
	itsAdornment = 0;
	if (itsAdorner)
		itsAdornment = dynamic_cast_AC(TCompatibilityAdorner*,itsAdorner)->fAdornment;
}

//----------------------------------------------------------------------------------------
// TControl::SetPenSize:
//----------------------------------------------------------------------------------------

void TControl::SetPenSize(CPoint_AC newPenSize)
{
	if (newPenSize != CPoint_AC(1,1))
	{
		CreateDrawingEnvironment();
		fDrawingEnvironment->fPenSize = newPenSize;
	}
}

//----------------------------------------------------------------------------------------
// TControl::GetPenSize:
//----------------------------------------------------------------------------------------

void TControl::GetPenSize(CPoint_AC& itsPenSize)
{
	if (fDrawingEnvironment)
		itsPenSize = fDrawingEnvironment->fPenSize;
	else
		itsPenSize.Set(1,1);
}

//----------------------------------------------------------------------------------------
// TControl::SetInset:
//----------------------------------------------------------------------------------------

void TControl::SetInset(const CViewRect& newInset, bool redraw)
{
	if (fSizeable)
	{
		fInset = newInset;

		// Resize(fSize.Copy(), redraw);
		if (redraw)
			ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TControl::TrackFeedback:
//----------------------------------------------------------------------------------------

void TControl::TrackFeedback(TrackPhase			aTrackPhase,
							 const CViewPoint&	anchorPoint,
							 const CViewPoint&	previousPoint,
							 const CViewPoint&	nextPoint,
							 bool				mouseDidMove,
							 bool				turnItOn)

{
	#pragma unused (aTrackPhase, anchorPoint, previousPoint, nextPoint, mouseDidMove, turnItOn)
	// do nothing
}

//----------------------------------------------------------------------------------------
// TControl::TrackMouse:
//----------------------------------------------------------------------------------------

void TControl::TrackMouse(TrackPhase	aTrackPhase,
						  CViewPoint&	anchorPoint,
						  CViewPoint&	previousPoint,
						  CViewPoint&	nextPoint,
						  bool			mouseDidMove)
{
	#pragma unused (anchorPoint, previousPoint, mouseDidMove)

	switch (aTrackPhase)
	{
		case trackBegin:
			HiliteState(true, kRedraw);
			break;
		case trackContinue:
			HiliteState(ContainsMouse(nextPoint), kRedraw);
			break;
		case trackEnd:
			if (ContainsMouse(nextPoint))
			{
				switch (fEventNumber)
				{
					// The defchoice determines different kinds of tracking behavior
					case mCheckBoxHit:
						// Toggle highlighting
						HandleEvent(mToggle,this,NULL);
						break;
					case mRadioHit:
						// Once it's on, it's on, until a cluster turns it off
						HandleEvent(mTurnOn,this,NULL);
						break;
					default:
						// Button action. Turn off highlighting.
						HandleEvent(mTurnOff,this,NULL);
						break;
				}
				HandleEvent(fEventNumber, this, NULL);
			}
			break;
	}
}

#if qMSWindows

//----------------------------------------------------------------------------------------
// TControl::GetWindowsFontName: 
//----------------------------------------------------------------------------------------

// There's probably a better place to put this code - maybe a method in
// CTextStyle_AC?
//    void CTextStyle_AC::GetWindowsFontName(char* fontName).
// or even 
//    HFONT GetLogicalFont()
// We also need to go through this do a better job at matching fonts.
// and ensuring the font names used exist on the machine I'm running on
// similar to how macApp addresses font names that are not predefined
// constants.

void TControl::GetWindowsFontName(short int fontNo, char* fontName)
{
	enum // some common Mac font ID constants not included in QTML
	{
		newYork=2,
		geneva,
		monaco,
	    times = 20,
		helvetica,
		courier,
		symbol
	};

	switch (fontNo)
	{
		case helvetica:
		case geneva:
			strcpy(fontName, "Arial");
			break;

		case newYork:
		case times:
			strcpy(fontName, "Times New Roman");
			break;
	
		case symbol:
			strcpy(fontName, "Symbol");
			break;
	
		case monaco:
		case courier:
			strcpy(fontName, "Courier New");
			break;
	
		case systemFont:
		case applFont:
		default:
			strcpy(fontName, "MS Sans Serif");
			break;
	}
}

//----------------------------------------------------------------------------------------
// TControl::SetWindowsWindow: 
//----------------------------------------------------------------------------------------

void TControl::SetWindowsWindow(HWND windowsWindow)
{
	TView::SetWindowsWindow(windowsWindow);
	if (windowsWindow)
	{
		LOGFONT	logicalFont;
		memset(&logicalFont, 0, sizeof(logicalFont));
		GetWindowsFontName(fTextStyle.tsFont, logicalFont.lfFaceName);
		if (fTextStyle.tsSize > 0)
			logicalFont.lfHeight = -fTextStyle.tsSize;
		else
			logicalFont.lfHeight = 8;
		if (fTextStyle.tsFace & bold)
			logicalFont.lfWeight = FW_BOLD;
		if (fTextStyle.tsFace & italic)
			logicalFont.lfItalic = true;
		logicalFont.lfWidth = 0;
		if (fTextStyle.tsFace & underline)
			logicalFont.lfUnderline = true;
		//if (fTextStyle.tsFace & outline)
			//logicalFont.lfUnderline = true;
		//if (fTextStyle.tsFace & shadow)
			//logicalFont.lfUnderline = true;
		//if (fTextStyle.tsFace & condense)
			//logicalFont.lfUnderline = true;
		//if (fTextStyle.tsFace & extend)
			//logicalFont.lfUnderline = true;
		logicalFont.lfWidth = 0;
		HFONT fontHandle = CreateFontIndirect(&logicalFont);
		::SendMessage(windowsWindow, WM_SETFONT, (WPARAM)fontHandle, true);
	}
}

#endif

//========================================================================================
// CLASS TCtlMgr
//========================================================================================

MA_DEFINE_CLASS(TCtlMgr);

//----------------------------------------------------------------------------------------
// TCtlMgr constructor
//----------------------------------------------------------------------------------------

TCtlMgr::TCtlMgr(const CViewPoint&		itsLocation,
				 const CViewPoint&		itsSize,
				 SizeDeterminer			itsHSizeDet,
				 SizeDeterminer			itsVSizeDet,
				 const CStr255_AC&		itsTitle,
				 const CTextStyle_AC&	itsTextStyle)
	:	TControl(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTextStyle),
		fTitle(MANewStringPtr(itsTitle)),
		fControl(NULL)

	// Compatibility Note: this warning now applies to CToolboxControl_AC's constructor:
	// These MUST be initialized because SetLongValues tests each new value against
	// the old value before doing anything. If the fLongMax value should happen to
	// have a (bogus - uninitialized) value that matches itsMax, fBitsToShift won't
	// be initialized and the control manager control will behave erratically.
	//fBitsToShift(0),
	//fLongVal(itsVal),
	//fLongMin(itsMin),
	//fLongMax(itsMax)
	//fProcID(itsProcID)
{
#if qMSWindows
	SetNeedsOwnWindowsWindow(true);
	SetTransparentView(false);
#endif
	//if (fTitle)
	//	*fTitle = itsTitle;
}

//----------------------------------------------------------------------------------------
// TCtlMgr copy constructor
//----------------------------------------------------------------------------------------

TCtlMgr::TCtlMgr(const TCtlMgr& inCtlMgr)
	:	TControl(inCtlMgr),
		fTitle(MANewStringPtr(MAEvalStringPtr(inCtlMgr.fTitle))),
		fControl(NULL)
		//fBitsToShift(inCtlMgr.fBitsToShift),
		//fLongVal(inCtlMgr.fLongVal),
		//fLongMin(inCtlMgr.fLongMin),
		//fLongMax(inCtlMgr.fLongMax)
		//fProcID(inCtlMgr.fProcID)
{
	// Copy-constructed controls must have HandlePostCreate called on them just like any
	// other well-adjusted procedurally-created control.
}

//----------------------------------------------------------------------------------------
// TCtlMgr destructor
//----------------------------------------------------------------------------------------

TCtlMgr::~TCtlMgr()
{
	// fTitle and fControl are auto-pointers
}

//----------------------------------------------------------------------------------------
// TCtlMgr::BeInPort:
//----------------------------------------------------------------------------------------

void TCtlMgr::BeInPort(GrafPtr itsPort)
{
	if (!gPrinting)		// Don't create the control when printing.
	{
		if (fControl)
		{
			if (itsPort)
				SetCMgrVisibility(fShown);

			WindowRef itsOldPort = fControl->GetWindowRef();
			// ��� Temporary fix for custom controls: they always return NULL for itsOldPort,
			// but we don't want to delete them if the port is unchanged, so we test for NULL.
			if (itsOldPort && itsOldPort != (WindowRef) itsPort)
			{
				// Back-store the title before moving to a new home.
				if (itsPort)
					fTitle = MANewStringPtr(fControl->GetTitle());

				// We can't move controls between ports, so delete the old control.
				// A new one will be created in the new port.

				// ��� It would really help if we had a copy construction method for controls
				// This is, unfortunately, not possible for the controls themselves, because
				// many Appearance controls are constructed with "magic" values that cannot
				// be recovered from the control itself for copy construction, but TCtlMgr
				// classes typically remember the "magic" values used to create their
				// controls, and hence, using DeleteControl followed by CreateControl is
				// about the best we can expect.

				DeleteControl();
			}
		}

		if (itsPort && !fControl)
		{
			// Scrollers that auto-create scroll bars have AddSubView called on the scroll bars.
			// This code ensures that the controls are created, since ReadFields won't get
			// called on them.
			CreateControl();
		}

		// Call Inherited at end so controls will be created top-down (containers first).
		TControl::BeInPort(itsPort);
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::InstallTextStyle:
//----------------------------------------------------------------------------------------

void TCtlMgr::InstallTextStyle(const CTextStyle_AC& theTextStyle, bool redraw)
{
	// Set the underlying control's text style before calling inherited.
	if (fControl)
	{
		CWhileFocused itsFocus(this, kDontRedraw);
		fControl->SetFontStyle(CControlTextStyle_AC(theTextStyle));
	}

	TControl::InstallTextStyle(theTextStyle, redraw);
}


//----------------------------------------------------------------------------------------
// TCtlMgr::CreateControl:
//----------------------------------------------------------------------------------------

void TCtlMgr::CreateControl()
{
#if qMSWindows
	if (GetWindowsWindow() == NULL)
		CreateWindowsWindow();
#else
	if (!fControl)
	{
		GrafPtr itsPort = GetGrafPort();
		if (!itsPort)
			ThrowError_AC(minErr);

		CStr255_AC itsTitle(MAEvalStringPtr(fTitle));
		fControl = DoMakeControl(GetWindowFromPort_AC(itsPort), ControlQDArea(), false, fIsActive, itsTitle);

		// Make sure the control is set to the correct text style.
		// The fControl is not allways there in DoPostCreate.
		if (fControl && fTextStyleRsrcID != kNoResource)
			InstallTextStyle( fTextStyle, kDontRedraw);

		SetActiveState(fIsActive, kDontRedraw);
		HiliteState(fHilite, kDontRedraw);

#if !qCarbon
		SetCMgrVisibility(itsPort != gWorkPort);
#else
		SetCMgrVisibility(itsPort != gWorkCPort);	// gWorkPort is a WindowRef, gWorkCPort is a CGrafPtr
#endif

		fTitle.reset(); // whatever stored title there was has been used so we don't need it here anymore
	}
#endif
}

//----------------------------------------------------------------------------------------
// TCtlMgr::DoMakeControl:
//----------------------------------------------------------------------------------------

CControl_AC* TCtlMgr::DoMakeControl(WindowRef			theWindow,
									const CRect_AC&		boundsRect,
									bool				isVisible,
									bool				isEnabled,
									const CStr255_AC&	itsTitle)
{
	#pragma unused (theWindow, boundsRect, isVisible, isEnabled, itsTitle)

	SubClassResponsibility_AC();
	return NULL;
}

//----------------------------------------------------------------------------------------
// TControl::DoPostCreate
//----------------------------------------------------------------------------------------

void TCtlMgr::DoPostCreate(TDocument* itsDocument)
// DoPostCreate sets the controls text style if any has been specified.
//
// itsDocument:		A TDocument* representing the document into which this control
//					is being installed.
//
// Call?			Only as the inherited DoPostCreate when implementing a custom
//					class deriving from TButton and which has its own DoPostCreate.
// Override?		As needed.
{
	TControl::DoPostCreate(itsDocument);
	
	if (fControl && fTextStyleRsrcID != kNoResource)
		InstallTextStyle(fTextStyle, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TCtlMgr::DeleteControl:
//----------------------------------------------------------------------------------------

void TCtlMgr::DeleteControl()
{
	fControl.reset();
}

//----------------------------------------------------------------------------------------
// TCtlMgr::GetEmbeddingControl:
//----------------------------------------------------------------------------------------

const TCtlMgr* TCtlMgr::GetEmbeddingControl() const
// GetEmbeddingControl sees if we wrap a CToolbocControl_AC.  If so then return our pointer,
// otherwise keep scanning upward in view hierarchy until it finds the top
// of the hierarchy or a view which wraps a CToolboxControl_AC that can embed.  Return the
// TCtlMgr if found otherwise NULL.
//
// Call:		Never.
// Override:	Never.  TCtlMgr overrides this in order to test to see if it
//				wraps a CToolboxControl_AC that can embed.
{
	const TCtlMgr*			aToolboxControlView = NULL;
	CToolboxControl_AC*		aToolboxControl = dynamic_cast<CToolboxControl_AC*>(fControl.get());
	if (aToolboxControl && aToolboxControl->CanEmbed())
		aToolboxControlView = this;

	// Keep looking if it wasn't us.
	if (aToolboxControlView == NULL && fSuperView)
		aToolboxControlView = TView::GetEmbeddingControl();

	return aToolboxControlView;
}

//----------------------------------------------------------------------------------------
// TCtlMgr::EmbedControls:
//----------------------------------------------------------------------------------------

void TCtlMgr::EmbedControls(const TCtlMgr* embeddingView) const
// See if we contain a CToolboxControl_AC and embed ourselves if so.  Otherwise,
// call the inherited behavior.
//
// embeddingView:	A pointer to a TCtlMgr which wraps a CToolboxControl_AC that
//					can embed other CToolboxControl_AC's.
// Call:			Never.
// Override:		Never.
{
	// If we wrap a CToolboxControl_AC then ask the embedding view to embed us.
	CToolboxControl_AC*		theControl = dynamic_cast<CToolboxControl_AC*>(fControl.get());
	if (theControl)
		embeddingView->EmbedControl(theControl);
	else
		TView::EmbedControls(embeddingView);
}

//----------------------------------------------------------------------------------------
// TCtlMgr::EmbedControl:
//----------------------------------------------------------------------------------------

void TCtlMgr::EmbedControl(CToolboxControl_AC* controlToEmbed) const
// EmbedControl will embed another control within the CToolboxControl_AC
// that we wrap thus establishing a proper control hierarchy.
//
// controlToEmbed:	A pointer to a CToolboxControl_AC that we are to embed.
//
// Call:			Never.
// Override:		Never.
{
	// If we wrap a CToolboxControl_AC then ask the embedding view to embed us.
	CToolboxControl_AC*		theControl = dynamic_cast<CToolboxControl_AC*>(fControl.get());
	if (theControl)
		theControl->EmbedControl(controlToEmbed);
#if qDebug
	else
		::ProgramBreak_AC("TCtlMgr::EmbedControl: We do not wrap a CToolboxControl_AC but attempting"
						  " to embed a control within us.");
#endif
}

//----------------------------------------------------------------------------------------
// TCtlMgr::InstallColor:
//----------------------------------------------------------------------------------------

void TCtlMgr::InstallColor(const CRGBColor_AC& theColor, bool redraw)
{
	if (fControl)
	{
		fControl->InstallColor(theColor);
	}

	TControl::InstallColor(theColor, redraw);
}

//----------------------------------------------------------------------------------------
// TCtlMgr::Activate:
//----------------------------------------------------------------------------------------

void TCtlMgr::Activate(bool entering)
{
	if (fControl && (fControl->IsActive() != entering))
	{
//		bool directredraw = !HasPendingUpdate();
		{
			CWhileFocused itsWhileFocused(this, false);
			fControl->SetActive(entering);
		}

//		if (directredraw)
//			DrawContents();
//		else

		TWindow* window = GetWindow();
		if (window && window->GetUpdating())
			DrawContents();
		else
			ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::DoMouseCommand:
//----------------------------------------------------------------------------------------

void TCtlMgr::DoMouseCommand(CViewPoint&		theMouse,
							 TToolboxEvent*		event,
							 CPoint_AC			hysteresis)
{
	#pragma unused (hysteresis)

	CPoint_AC theQDMouse(ViewToQD(theMouse));

	if (fControl) // if (fCMgrControl)
	{
		CWhileFocused itsWhileFocused(this, kRedraw);
		if (fControl->ContainsMouse(theQDMouse))
		{
			short trackResult = fControl->TrackMouse(theQDMouse, event->GetModifiers());
			if (trackResult)
			{
				// ��� Control value is already set, no need to do this any more.
				//long newLongValue = GetVal() == GetMax() ? fLongMax : static_cast<long>(GetVal()) << fBitsToShift;
				//SetLongVal(newLongValue, kRedraw);

				HandleEvent(fEventNumber, this, NULL);

				gDispatcher->InvalidateMouseRegions();
			}
		}
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::Draw:
//----------------------------------------------------------------------------------------

void TCtlMgr::Draw(const CViewRect& area)
{
	static bool controlPrintingReentrancyFlag;
	if (IsCMgrVisible())
	{
#if qDebug
		AssumeFocused();
#endif
		// for controls, spool the picture and draw that to overcome font problems

		// HOWEVER, controls are often drawn dimmed with grayisTextOR and I quote from IM Text on TextMode:
		// "The grayishTextOr transfer mode draws dimmed text on the screen. You can use it for black-and-white
		// or color graphics ports. The grayishTextOr transfer mode is not considered a standard transfer mode
		// because currently it is not stored in pictures, and printing with it is undefined. (It does not pass
		// through the QuickDraw bottleneck routines.)"

		bool spooledPrintOK = false;

		// If we've got native Appearance controls then skip AsPict.
		if (gPrinting && !controlPrintingReentrancyFlag && !HasAppearanceMgr_AC())
		{
			PicHandle	aPH = NULL;
			GrafPtr		printPort = GetGrafPtr_AC();
			// spool picture, take care as this will call TCtlMgr.Draw()
			controlPrintingReentrancyFlag = true;
			aPH = AsPict();
			controlPrintingReentrancyFlag = false;
			// if success, print this picture
			if (aPH)
			{
				::SetPort_AC(printPort);
				::DrawPicture(aPH, GetQDExtent());
				DisposeIfPicHandle(aPH);
				spooledPrintOK = true;
			}
		}

		// if we did not spool to a pict (successfully) use Draw1Control()
		if (!spooledPrintOK)
		{
			PenNormal();
			if (gPrinting && !IsActive() /*fDimmed*/)
			{
				// grayishTextOr is not defined for printers or for Pictures (blech!)
				SetActiveState(false, kDontRedraw);		//DimState(false, kRedraw);
				TControl::Dim();	// let our ancestor do it the old dumb way

				// restore things
				PenNormal();
				SetActiveState(fIsActive, kDontRedraw);	//DimState(fDimmed, kDontRedraw);
			}
			else
				fControl->DrawControl();
		}
	}

	TControl::Draw(area);						// to get adornment
}

//----------------------------------------------------------------------------------------
// TCtlMgr::BecameTarget:
//----------------------------------------------------------------------------------------

void TCtlMgr::BecameTarget()
{
	TControl::BecameTarget();

	if (fControl)
	{
		CWhileFocused itsWhileFocused(this, kRedraw);
		fControl->SetKeyboardFocus(kControlFocusNextPart);
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::ResignedTarget:
//----------------------------------------------------------------------------------------

void TCtlMgr::ResignedTarget()
{
	TControl::ResignedTarget();

	if (fControl)
	{
		CWhileFocused itsWhileFocused(this, kRedraw);
		fControl->SetKeyboardFocus(kControlFocusNoPart);
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::DoKeyEvent:
//----------------------------------------------------------------------------------------

void TCtlMgr::DoKeyEvent(TToolboxEvent* event)
{
	if (fControl)
	{
		CWhileFocused itsWhileFocused(this, kRedraw);

		ControlPartCode partKeyed = fControl->HandleKeyDown(event->GetKeyCode(),
															event->GetText()[1],
															event->GetModifiers());
#if qProjectBuilder
		(void) partKeyed;
#endif
	}

	// Pass the event along.  This is important for handling tab key and other key
	// events elsewhere in the view hierarchy.
	TControl::DoKeyEvent(event);
}

#if qMSWindows

//----------------------------------------------------------------------------------------
// TCtlMgr::HandleWindowsEvent:
//----------------------------------------------------------------------------------------

long TCtlMgr::HandleWindowsEvent(HWND hwnd, UINT message, WPARAM wParam, LPARAM lParam)
{
	long result = 0;
	switch (message)
	{
    	// let the controls handle drawing and scrolling themselves
		case WM_PAINT:
			result = DefaultWindowProcedure(hwnd, message, wParam, lParam);
			break;

		default:
			result = TControl::HandleWindowsEvent(hwnd, message, wParam, lParam);
			break;
	}
	return result;
}

//----------------------------------------------------------------------------------------
// TCtlMgr::CreateWindowsWindow:
//----------------------------------------------------------------------------------------

void TCtlMgr::CreateWindowsWindow()
{
	if (GetWindowsWindow() == NULL)
	{
		TControl::CreateWindowsWindow();

		CStr255_AC	itsTitle(MAEvalStringPtr(fTitle));
		char		title[256];

		itsTitle.CopyTo(title);
		::SetWindowText(GetWindowsWindow(), title);
		fTitle.reset(); // whatever stored title there was has been used so we don't need it here anymore
		::SetWindowLong(GetWindowsWindow(), GWL_ID, GetEventNumber());
	}
}

#endif

//----------------------------------------------------------------------------------------
// TCtlMgr::IsCMgrVisible:
//----------------------------------------------------------------------------------------

bool TCtlMgr::IsCMgrVisible()
{
	return (fControl && fControl->IsVisible());
}

//----------------------------------------------------------------------------------------
// TCtlMgr::GetText:
//----------------------------------------------------------------------------------------

CStr255_AC TCtlMgr::GetText() const
{
	CStr255_AC returnVal;
	if (fControl)
		returnVal = fControl->GetTitle();

	return returnVal;
}


//----------------------------------------------------------------------------------------
// TCtlMgr::GetVariant:
//----------------------------------------------------------------------------------------

#if qBackwardCompatible

short TCtlMgr::GetVariant()
{
	short variant = 0;

	if (dynamic_cast_AC(CToolboxControl_AC*,fControl.get()))
		variant = (dynamic_cast_AC(CToolboxControl_AC*,fControl.get()))->GetVariant();
	return variant;
}

#endif

//----------------------------------------------------------------------------------------
// TCtlMgr::HiliteState:
//----------------------------------------------------------------------------------------

void TCtlMgr::HiliteState(bool state, bool redraw)
{
	// if the control is dimmed, leave it alone!
	if (fControl && fControl->IsActive() && fControl->IsHilited() != state)
	{
		CWhileFocused itsWhileFocused(this, redraw);

		fControl->SetHilite(state);
	}
	fHilite = state;
}

//----------------------------------------------------------------------------------------
// TCtlMgr::Inset:
//----------------------------------------------------------------------------------------

void TCtlMgr::Inset(const CViewPoint& delta, bool redraw)
{
	TControl::Inset(delta, kDontRedraw);

	AdjustCtlMgrControl(redraw);
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetInset:
//----------------------------------------------------------------------------------------

void TCtlMgr::SetInset(const CViewRect& newInset, bool redraw)
{
	TControl::SetInset(newInset, kDontRedraw);

	AdjustCtlMgrControl(redraw);
}

//----------------------------------------------------------------------------------------
// TCtlMgr::AdjustCtlMgrControl:
//----------------------------------------------------------------------------------------

void TCtlMgr::AdjustCtlMgrControl(bool redraw)
// AdjustCtlMgrControl adjusts the active area of the control and relocates 
// it when the control�s frame changes. MacApp uses this method to update the
// appearance of a Control Manager control.
//
// redraw:	If true, the control is redrawn with its new control area in its 
//			new location. If false, it is not redrawn, even though the new value
//			may affect its appearance. You can set redraw to false when you know
//			that the object will eventually be redrawn and you want to avoid drawing
//			it twice, which makes the screen appear to flicker or flash.
//
// Call?		Seldom.
// Override?	As needed.
{
	if (fControl)
	{
		CWhileFocused itsWhileFocused(this, redraw);

		CRect_AC qdArea(ControlQDArea());

		fControl->SetLocation(qdArea[topLeft]);
		if (fSizeable)
			fControl->SetSize(CPoint_AC(abs(qdArea.GetLength(hSel)), abs(qdArea.GetLength(vSel))));
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetFrame:
//----------------------------------------------------------------------------------------

void TCtlMgr::SetFrame(const CViewRect& newFrame, bool invalidate)
{
	CViewRect oldFrame(GetFrame());

	TControl::SetFrame(newFrame, invalidate);

	if (newFrame != oldFrame)
		AdjustCtlMgrControl(kDontRedraw /*invalidate*/);
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetCMgrVisibility:
//----------------------------------------------------------------------------------------

bool TCtlMgr::SetCMgrVisibility(bool beVisible)
{
	bool wasVisible = false;

	if (fControl)
	{
		if (beVisible && Focus())
			fControl->SetLocation(ControlQDArea()[topLeft]);

		wasVisible = fControl->SetVisibility(beVisible);
	}

	return wasVisible;
}

//----------------------------------------------------------------------------------------
// TCtlMgr::Show:
//----------------------------------------------------------------------------------------

void TCtlMgr::Show(bool state, bool redraw)
{
	SetCMgrVisibility(state);

	TControl::Show(state, redraw);
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetText:
//----------------------------------------------------------------------------------------

void TCtlMgr::SetText(const CStr255_AC& itsText, bool redraw)
{
#if !qMSWindows
	if (fControl)
	{
		if (CompareStrings(GetText(), itsText))
		{
			CWhileFocused itsWhileFocused(this, redraw);

			fControl->SetTitle(itsText);
			if (IsFocused())					// we were focused if redraw was true
			{
				CRect_AC r(fControl->GetBounds());

				// Because Control Manager invalidates it, but it was actually drawn.
				// Note: we only validate the area that is currently Drawable
				CTempRegion_AC rgnToValidate;
				::RectRgn(rgnToValidate, &r);
				GrafPtr currentPort;
				::GetPort(&currentPort);
#if !qCarbon
				::SectRgn(rgnToValidate, currentPort->clipRgn, rgnToValidate);
#else
				{
					CTempRegion_AC clipRgn;
					::GetPortClipRegion(currentPort, clipRgn);
					::SectRgn(rgnToValidate, clipRgn, rgnToValidate);
				}
#endif
				Validate(rgnToValidate);
			}
		}
	}
	else
	{
		fTitle.reset(MANewStringPtr(itsText));

		//if (fTitle)
		//	*fTitle = itsText;
	}
#else
	HWND window = GetWindowsWindow();
	if (window != NULL)
	{
		char title[256];

		itsText.CopyTo(title);
		::SetWindowText(window, title);
		fTitle.reset(); // whatever stored title there was has been used so we don't need it here anymore
	}
	else
		fTitle.reset(MANewStringPtr(itsText));
#endif
}


//----------------------------------------------------------------------------------------
// TCtlMgr::GetLongMax:
//----------------------------------------------------------------------------------------

ViewCoordinate TCtlMgr::GetMaximum()
{
	return fControl ? fControl->GetMaximum() : 0;
}

//----------------------------------------------------------------------------------------
// TCtlMgr::GetLongMin:
//----------------------------------------------------------------------------------------

ViewCoordinate TCtlMgr::GetMinimum()
{
	return fControl ? fControl->GetMinimum() : 0;
}

//----------------------------------------------------------------------------------------
// TCtlMgr::GetLongVal:
//----------------------------------------------------------------------------------------

ViewCoordinate TCtlMgr::GetValue() const
{
	return fControl ? fControl->GetValue() : 0;
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetViewSize
//----------------------------------------------------------------------------------------

ViewCoordinate TCtlMgr::GetViewSize() const
{
	return fControl ? fControl->GetViewSize() : 0;
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetMaximum:
//----------------------------------------------------------------------------------------

void TCtlMgr::SetMaximum(ViewCoordinate itsMax, bool redraw)
{
	if (fControl && fControl->GetMaximum() != itsMax)
	{
		CWhileFocused itsWhileFocused(this, redraw);

		fControl->SetMaximum(itsMax);
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetMinimum:
//----------------------------------------------------------------------------------------

void TCtlMgr::SetMinimum(ViewCoordinate itsMin, bool redraw)
{
	if (fControl && fControl->GetMinimum() != itsMin)
	{
		CWhileFocused itsWhileFocused(this, redraw);

		fControl->SetMinimum(itsMin);
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetValue:
//----------------------------------------------------------------------------------------

void TCtlMgr::SetValue(ViewCoordinate itsVal, bool redraw)
{
	if (fControl && fControl->GetValue() != itsVal)
	{
		CWhileFocused itsWhileFocused(this, redraw);

		fControl->SetValue(itsVal);
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetValues:
//----------------------------------------------------------------------------------------

void TCtlMgr::SetValues(ViewCoordinate itsVal,
							ViewCoordinate itsMin,
							ViewCoordinate itsMax,
							bool redraw)
{
	if (fControl)
	{
		CWhileFocused itsWhileFocused(this, redraw);
		fControl->SetValues(itsVal, itsMin, itsMax);
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::SetViewSize
//----------------------------------------------------------------------------------------

void TCtlMgr::SetViewSize(ViewCoordinate newViewSize, bool redraw)
{
	if (fControl)
	{
		CWhileFocused itsWhileFocused(this, redraw);
		fControl->SetViewSize(newViewSize);
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::GetHelpState:
//----------------------------------------------------------------------------------------

short TCtlMgr::GetHelpState()
{
	short helpState = 0;
#if !qCarbon
	if (IsEnabled())
	{
		long ctlValue = GetValue();
		if (ctlValue == 1)
			helpState = kHMCheckedItem;
		else
			if (ctlValue > 1)
				helpState = kHMOtherItem;
			else
				helpState = kHMEnabledItem;
	}
	else
		helpState = kHMDisabledItem;
#endif
	return helpState;
}

#if qCarbon
//----------------------------------------------------------------------------------------
// TCtlMgr::ClipFurtherTo:
//----------------------------------------------------------------------------------------

void TCtlMgr::ClipFurtherTo(RgnHandle rRgn, CPoint_AC deltaOrg)
{
#pragma unused (rRgn, deltaOrg)
}

//----------------------------------------------------------------------------------------
// TCtlMgr::OffsetAndClipFurtherTo:
//----------------------------------------------------------------------------------------

void TCtlMgr::OffsetAndClipFurtherTo(RgnHandle rRgn, CPoint_AC deltaOrg)
{
#pragma unused (rRgn)
#if qDebug
	AssumeFocused();
#endif

	// First offset the clip Rgn
	if (deltaOrg != gZeroPt)
	{
		CGrafPtr port = ::GetCGrafPtr_AC();
		RgnHandle clipRegion = GetClipRegion();
		::MacOffsetRgn(clipRegion, deltaOrg.h, deltaOrg.v);
		::SetPortClipRegion(port, clipRegion);
	}
}
#endif // qCarbon

//----------------------------------------------------------------------------------------
// TCtlMgr::UpdateCoordinates:
//----------------------------------------------------------------------------------------

void TCtlMgr::UpdateCoordinates() const
{
	// we can't update our coordinates until our superview updates theirs
	// however once a views coordinates are valid we don't have to walk up
	// the tree any further.
	if (fCoordinatesAreInvalid)
	{
		TCtlMgr* nonConstThis = const_cast<TCtlMgr*>(this);
		CViewPoint oldViewToQDOffset(fViewToQDOffset);

		if (fSuperView)
			fSuperView->UpdateCoordinates();

		if (TPrintHandler::gCurrPrintHandler && (dynamic_cast<const TView*>(this) == TPrintHandler::gCurrPrintHandler->fView))
		{
			// Printing

			CViewPoint actualViewToQDOffset = TPrintHandler::gCurrPrintHandler->GetViewToQDOffset() +
											  CViewPoint(TPrintHandler::gCurrPrintHandler->GetQDOrigin());

			nonConstThis->fViewToQDOffset = actualViewToQDOffset;// to allow testing of the Extent
			if (CViewRect(-kMaxQDCoord, -kMaxQDCoord, kMaxQDCoord, kMaxQDCoord).Contains(GetExtent()))
			{
				nonConstThis->fQDOrigin = actualViewToQDOffset.ToPoint();
				nonConstThis->fViewToQDOffset.Clear();
			}
			else
			{
				const short kMaxOriginFixup = 1024;
				CPoint_AC deltaOrigin(static_cast<short>(actualViewToQDOffset.h % kMaxOriginFixup),
									  static_cast<short>(actualViewToQDOffset.v % kMaxOriginFixup));
				nonConstThis->fViewToQDOffset = actualViewToQDOffset - CViewPoint(deltaOrigin);
				nonConstThis->fQDOrigin = deltaOrigin;
			}

			// When printing, the grafPort is supplied.
			nonConstThis->fVisibleExtent = GetExtent();
		}
		else if (fSuperView)
		{
			// Drawing in a superview

			// The control needs to always have its location in window coordinates.
			nonConstThis->fViewToQDOffset = CViewPoint(GetRootView()->GetQDOrigin()) - LocalToRootView(gZeroVPt);
			nonConstThis->fQDOrigin.Clear();

			// Update my visible extent by intersecting my extent with my superview's visible extent

			// When drawing the scrap, the grafPort is supplied.
			if (dynamic_cast<const TView*>(this) == gDrawingPictScrapView)
				nonConstThis->fVisibleExtent = GetExtent();
			else
				nonConstThis->fVisibleExtent = SuperViewToLocal(GetFrame() & fSuperView->GetVisibleExtent());
		}
		else
		{
			// Drawing as the root view

			nonConstThis->fViewToQDOffset.Clear();
			nonConstThis->fQDOrigin.Clear();
			nonConstThis->fVisibleExtent = GetExtent();
		}

		nonConstThis->fCoordinatesAreInvalid = false;

		if (fViewToQDOffset != oldViewToQDOffset)
		{
			nonConstThis->AdjustCtlMgrControl(kDontRedraw);
		}
	}
}

//----------------------------------------------------------------------------------------
// TCtlMgr::IdleControl:
//----------------------------------------------------------------------------------------

void TCtlMgr::IdleControl()
{
	if (fControl && Focus())
	{
		fControl->Idle();
	}
}

//----------------------------------------------------------------------------------------
// End of UControl.cpp

/*
	Historical Change Record:
		----- R13 -----
		07/17/97	Added accessors for opacity
		07/14/97	[1615635] (Printing) Disable checkbox, radio button & popup aren't printed.
							Got rid of TControl::AsPictForPrinting abomination too.
		07/12/97	[1615468] (TWindow) Update region is not correct
		06/30/97	[1353169] fprinf(stderr, blah) to ProgramBreak_AC(blah)
		06/24/97	Removed SetFrame, added fFrameInvalidateDeterminer default.
		06/22/97	Minor changes for VC++.
		06/22/97	Changed static_cast_AC to reinterpret_cast_AC in TCtlMgr::CreateCMgrControl.
		06/05/97	EXPORT_AC, EXPORT_MA, no-load fixes, Memory_AC, Windows_AC, no CW11orLATER, removed segmentation, etc...
		05/22/97	Partial streams fixes.
		04/29/97	Changed BeInPort to use fShown state when setting CMgr visibility.
		04/23/97	Remove Clone declarations from classes we don't clone.
		04/23/97	ReadFields methods don't free themselves on failure.
		04/22/97	Make the global adorners objects not pointers to objects.
		04/17/97	CreateAGAControl is now called from CreateCMgrControl.
		04/16/97	Fixed Activate to work better emulated.
		04/14/97	Update for real xxx_cast operators.
		04/13/97	Update List and Dependency names for ACS.
		04/09/97	properly use dynamic casting for all down/side casts
		04/04/97	Appearance Manager support.
		04/08/97	Update for TAdorner/TBehavior/TEventHandler/TCommandHandler/TCommand/
							TFileBasedDocument/TSection/TEditionDocument protected fields.
		04/04/97	Update for TView/TWindow protected fields.
		04/02/97	Update for TView view coordinate tranform methods.
		03/27/97	Make it go with new streaming
		03/27/97	Add opacity to TScrollbar.
		03/25/97	AC_ to _AC Name change.
		03/24/97	Migrated Dependencies and Lists to ACS
		03/21/97	Migrated to CViewRect, CViewPoint, ViewCoordinate.
		03/19/97	Updated for TextBox_AC, CWhileOutlinePreferred_AC, etc.
		03/11/97	Update exception support to latest.
		03/07/97	Massive Changes: Use Exceptions_AC, new to TH_new, use Blah_AC,
							Update Copyright, Moved Obsolete APIs into Compatibility.h, etc..
		02/25/97	Merged Gray Council 2.1 changes.
		02/19/97	Use embedded objects instead of auto_ptr based object where possible.
		02/15/97	Fleshed out copy constructor.
		02/07/97	Added qGrayscaleAppearance support.
		01/17/97	Updated qMSWindows conditionals.
		01/13/97	Updated qWindows conditionals.
		12/05/96	Added qWindows conditionals.
		10/21/96	Properly create the ToolBox control when creating controls procedurally.
		09/30/96	Fix cloning by turning clone methods into copy constructors
		08/28/96	Remove superview/document arguments to TView (and derived) constructors.
		08/16/96	Use constructors for all TView descendents
		08/15/96	Use constructors for all TCommand descendents
		08/10/96	Fixed -noload compiles, made more datamembers auto_ptrs, FreeIfObject->delete
		08/07/96	Goodbye TObject!
		08/01/96	T[Sorted]List now takes a void* T[Sorted]VoidList now typedefed to T[Sorted]List
		07/22/96	Use templates for many Iterator subclasses.
		07/18/96	Change TScrollerScrollBar::fScrollers to CAutoPtr_AC based.
		07/17/96	define template CAutoPtr_AC and use it in place of CTempObject
		07/16/96	Removed MAVolatile
		07/16/96	Replacing Failxxx with Throwxx procs
		07/16/96	Goodbye Exception Macros (TRY, CATCH_ALL, ENDTRY)
		07/16/96	Goodbye MDestructo
		07/15/96	Boolean->bool
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/09/96	Added CopyHandle_AC: a better HandToHand replacement. And created
		 					PermCopyHandle a better PermHandToHand.
		05/08/96	Cleanup CRGBColor_AC and add new class CTextStyle_AC
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/29/96	Create and use functions that return their data as results for:
							TStream::ReadCharacter/CViewPoint/Rect/CViewRect/RGBColor/String. Create compatible inlines
							so users don't have to change their code.
		04/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/26/96	Made TControl::ControlArea/ControlQDArea non virtual. Made TView/TControl::GetAdornExtent
							return their CViewRect as function results
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Eliminated custom embedded FailInfo handling, derive from MDestructo
		04/20/96	Remove implementation of CWhileFocused::operator new
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/27/96	FailInfo has a default constructor so failInfo.Reset was redundant in CWhileFocused constructors
		03/18/96	Made better use of TView calls that return CRect_AC/CViewPoint/CViewRect
		03/18/96	Remove compatibility hacks.
		03/14/96	Use CPascalStr_AC::Empty.
		03/07/96	[1312486] TCtlMgr::AdjustCtlMgrControl() and CWhileFocused::~CWhileFocused()
		 					Also, added TControl::ControlQDArea to complement TControl::ControlArea since
							most callers of ControlArea convert the results to QD coordinates anyways.
		03/05/96	Derive CRGBColor_AC from RGBColor so it is really compatible. We don't
		 					use CFront anymore so the only reason not to is gone now.
		03/04/96	Remove gratuitous inlining, Removed ::Success in favor of FailInfo::Success,
		 					restructured Try macro to reduce code bulk by about 2400 bytes. Removed ::HandlerExists
		 					in favor of FailInfo::HandlerExists. Made gTopHandler a static member of FailInfo
		03/04/96	[1325889] Remove bogus comments refering to SetDynamicSize
							and 2.0 compatiblity. Change copywrite.
		11/28/95	Use <> for including stdlib.
							Split up includes for modular MacApp.
		----- 3.3 -----
		11/09/95	[1260351] (Display) Non-Rectangular Regions in MacApp. The support
		 					in TView::ContainsMouse and TControl::ContainsMouse for GetExtentRegion
							was left out when Non-Rectangular Region support was originally checked-in.
							Or it was lost during an integration. Anyway, the support has been
							re-integrated and Non-Rectangular views work now.
		10/11/95	TCtlMgr::SetText uses CompareStrings to determine if the
							string has changed. (N.Nallick)
		----- 3.3b1 -----
		09/01/95	CWhileFocused::operator new comment out size parameter.
		09/01/95	CWhileFocused::operator new returns nil.
		  					CWhileFocused installs correct cleanup proc.
		08/30/95	Return old state in SetCMgrVisibility. Store old control location
							in CWhileFocused::fOldControlLocation. Update CWhileFocused to have
							a Failure catcher to cleanup in case of failure. Removed the
							CWhileFocused::Restore call per Greg F. and removed the
							CWhileFocused::Focus call, it just uses the constructor.
		08/29/95	Move controls to the window's control list in TCtlMgr::BeInPort
		08/28/95	Don't keep controls off the owning window anymore. Only remove them
							for the duration of the SelectWindow call.
		07/31/95	ClickThrough: TScrollBar sets fHandlesFirstClick to true.
		07/28/95	Add configuration functions to use instead of gConfiguration.
		07/05/95	Back off from strict windows so we can compile with
		  					all the headers.
		05/24/95	Include UWindow.h
		05/17/95	More strict controls changes.
		05/16/95	ControlRef, WindowRef
		04/08/95	Use size limits from limits.h instead of MacAppTypes.
		03/28/95	Add compatibility hacks for the 2.0f1 headers.
		03/17/95	MAVolatile.
		03/14/95	1202993 (ICE0003) MA Control manager bug
		03/13/95	Change Free methods to destructors.
		03/06/95	Nest iterator in its own block in TScrollerScrollBar::Free so
							fScrollers is not in use when it is time to free it.
		02/21/95	Add compatibility hack so we can compile with the 1.0 headers.
		02/20/95	Update for USESOLDROUTINENAMES=0.
		02/07/95	Create missing prototypes for static functions used internally.
*/