//----------------------------------------------------------------------------------------
// UUndo.cpp
// Copyright � 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/11/01	Use CString_AC instead of CStr255_AC.
		01/02/01	Update copyright.
		10/11/00	When deleting a command, clear its undo handler reference. 
					TUndoRedoCommand needs to have its undo handler reference. 
		12/08/99	Used BaseIterator instead of Iterator in four places.
		03/24/99	Update copyright notice.
		03/19/99	Rename GetMessage to GetExceptionMessage
					since it conflicts with a Windows define.
		01/15/99	CAEDesc_AC is now in ACS. 
		11/12/98	[2279244] Replaced dynamic_cast with dynamic_cast_AC.
		10/30/98	[W] Don't make a gUndoStackHook for Windows.
		10/08/98	Use TCommand::DeleteCommand so CPostponeDelete will work. 
					Undo handler list. CActionIterator. MPurgeable. 
					Can set command number at end of transaction. 
					ClearActions doesn't need to care about transaction level or direction. 
					Undo handler's Abort method now deletes all the commands in the
					transaction. This prevents a leak of the other commands. 
					Delete a command only if its free on completion flag says to. 
					Change FindTransaction to Contains. 
					RemoveCommandAction needs to remove all transactions up to
					and including the one containing the command. 
					Actually make a CUndoStackHook. 
					Undo context: 
					Change undo handler to a behavior. Each context can have its own undo
					handler. There no longer is any need for marking or filtering in
					an undo handler. Moved undo menu setup to the undo handler. 
					Undo/redo command target for recording is the context of the undo handler. 
					Fixed a bug where action type was set to kEndAction for transactions
					containing only one action -- type should have been set to kSingleAction. 
					Merge TCommandHandler into TEventHandler. 
*/

#ifndef __UUNDO__
#include "UUndo.h"
#endif

// MacApp

#ifndef __PLATFORMMEMORY__
#include "PlatformMemory.h"
#endif

#if qAppleEventAware
	#ifndef __UAPPLEEVENTS__
	#include "UAppleEvents.h"
	#endif
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

// Toolbox

#if qAppleEventAware
	#ifndef __AEREGISTRY__
	#include <AERegistry.h>
	#endif
#endif

// ANSI

#ifndef __STDIO__
#include <stdio.h>
#endif


//========================================================================================
// GLOBAL Variables
//========================================================================================

#if !qMSWindows
CUndoStackHook gUndoStackHook;
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// GetUndoText: 
//----------------------------------------------------------------------------------------

CString_AC GetUndoRedoText(bool cmdDone, CommandNumber aCommandNumber)
// GetUndoRedoText generates a string suitable for using as the undo or redo menu item
// text.  It does this by determining the state of the current command (it'll be
// undoable, redoable or not undoable) and then substituting the command's title
// into the appropriate string.
//
// cmdDone:			A bool indicating whether the command was last done.  If false then
//					it was last undone.
// aCommandNumber:	A CommandNumber representing the last command performed.
//
// Call?			As needed though this is usually only called by MacApp while in the
//					process of setting up the menus.
{
	short newMenuState = bzRedo;

	if (aCommandNumber == cCantUndo)
		newMenuState = bzCantUndo;
	else if (cmdDone)
		newMenuState = bzUndo;

	CString_AC	undoRedoTitle(static_cast<ResNumber>(kIDBuzzString), newMenuState);
	CString_AC	cmdName;

	if (aCommandNumber != cNoCommand && aCommandNumber != cCantUndo)
		cmdName = CommandToName(aCommandNumber);

	return undoRedoTitle.DoSubstitution(cmdName);
}

//========================================================================================
// CLASS CUndoAction
//========================================================================================

//----------------------------------------------------------------------------------------
// CUndoAction::CUndoAction:
//----------------------------------------------------------------------------------------

CUndoAction::CUndoAction(TCommand* command, EActionType actionType, CommandNumber id)
	:	fCommand(command),
		fID(id),
		fActionType(actionType)
{
}

//----------------------------------------------------------------------------------------
// Copy constructor
//----------------------------------------------------------------------------------------

CUndoAction::CUndoAction(const CUndoAction& rhs)
	:	fCommand(rhs.fCommand),
		fID(rhs.fID),
		fActionType(rhs.fActionType)
{
}
				
//----------------------------------------------------------------------------------------
// CUndoAction::IsDone:
//----------------------------------------------------------------------------------------

bool CUndoAction::IsDone()
{
	return fCommand ? fCommand->GetCommandDone() : false;
}

//----------------------------------------------------------------------------------------
// CUndoAction::operator=
//----------------------------------------------------------------------------------------

CUndoAction& CUndoAction::operator=(const CUndoAction& rhs)
{
	fCommand = rhs.fCommand;
	fID = rhs.fID;
	fActionType = rhs.fActionType;
	
	return *this;
}

//----------------------------------------------------------------------------------------
// CUndoAction::DeleteCommand
//----------------------------------------------------------------------------------------

void CUndoAction::DeleteCommand()
{
	// Disconnect the command for deleting so debug code won't complain
	// about being deleted while we have a reference to it. 
	TCommand* command = fCommand;
	if (command)
	{
		fCommand = NULL;
		command->SetUndoHandler(NULL);
		TCommand::DeleteCommand(command);
	}

	fID = cCantUndo;
}
	
//----------------------------------------------------------------------------------------
// CUndoAction::TotalSize:
//----------------------------------------------------------------------------------------

Size CUndoAction::TotalSize(bool justLocked) const
{
	return fCommand ? fCommand->TotalSize(justLocked) : 0;
}

//----------------------------------------------------------------------------------------
// CUndoAction::Purge:
//----------------------------------------------------------------------------------------

Size CUndoAction::Purge(Size /*needed*/)
{
	Size totalPurged = 0;

	if (fCommand)
	{
		totalPurged = fCommand->TotalSize(false);
		DeleteCommand();
	}

	return totalPurged;
}


//========================================================================================
// CLASS TActionStack
//========================================================================================

//----------------------------------------------------------------------------------------
// TActionStack constructor
//----------------------------------------------------------------------------------------

TActionStack::TActionStack()
{
	SetAllocationIncrement(kDefaultUndoStackDepth); 
}
				
//----------------------------------------------------------------------------------------
// TActionStack::Top
//----------------------------------------------------------------------------------------

CUndoAction* TActionStack::Top()
{
	return (fSize > 0) ? &At(fSize) : static_cast<CUndoAction*>(NULL);
}

//----------------------------------------------------------------------------------------
// TActionStack::PushAction:
//----------------------------------------------------------------------------------------

void TActionStack::PushAction(const CUndoAction& action)
{
	InsertLast(action);
	
	// Don't purge actions here (to the max desired), only purge them when DoIt is called.
}

//----------------------------------------------------------------------------------------
// TActionStack::Delete:
//----------------------------------------------------------------------------------------

void TActionStack::Delete(CUndoAction* action)
{
	for (Iterator iter(this); iter; ++iter)
	{
		if (iter == action)
		{
			DeleteElementsAt(iter.CurrentIndex(), 1);
			break;
		}
	}
}

//----------------------------------------------------------------------------------------
// TActionStack::FreeAll:
//----------------------------------------------------------------------------------------

void TActionStack::FreeAll()
{
	for (Iterator iter(this); iter; ++iter)
		(*iter).DeleteCommand();

	DeleteAll();
}

//----------------------------------------------------------------------------------------
// TActionStack::ClearTransactions:
//----------------------------------------------------------------------------------------

void TActionStack::ClearTransactions(ArrayIndex_AC count)
{
	if (count > 0)
	{
		ArrayIndex_AC actionCount = 0;
		for (CActionIterator iter(this); iter && count; ++iter)
		{
			iter->DeleteCommand();
			++actionCount;
			if (!iter.GetLevel())
				--count;
		}

		DeleteElementsAt(1, actionCount);
	}
}

//----------------------------------------------------------------------------------------
// TActionStack::CountTransactions:
//----------------------------------------------------------------------------------------

ArrayIndex_AC TActionStack::CountTransactions()
{
	ArrayIndex_AC count = 0;

	for (CActionIterator iter(this); iter; ++iter)
	{
		if (!iter.GetLevel())
			++count;
	}

	return count;
}

//----------------------------------------------------------------------------------------
// TActionStack::Contains:
//----------------------------------------------------------------------------------------

ArrayIndex_AC TActionStack::Contains(TCommand* command)
{
	ArrayIndex_AC index = 0;
	
	if (command)
	{
		for (Iterator iter(this); iter; ++iter)
		{
			if (iter->GetCommand() == command)
			{
				index = iter.CurrentIndex();
				break;
			}
		}
	}
	
	return index;
}

//----------------------------------------------------------------------------------------
// TActionStack::RemoveCommandAction:
//----------------------------------------------------------------------------------------

bool TActionStack::RemoveCommandAction(TCommand* command)
{
	// Remove all transactions up to and including the one containing the command. 

	bool found = false;

	ArrayIndex_AC count = 0;
	{
		for (CActionIterator iter(this); iter; ++iter)
		{
			if (iter->GetCommand() == command)
				found = true;

			// Count complete transactions
			if (!iter.GetLevel())
			{
				++count;

				// Break out when we've got a complete transaction containing
				// the command
				if (found)
					break;
			}
		}
	}

	if (found && (count > 0))
		ClearTransactions(count);

	return found;
}

//----------------------------------------------------------------------------------------
// TActionStack::TotalSize:
//----------------------------------------------------------------------------------------

Size TActionStack::TotalSize(bool justLocked) const
{
	Size totalSize = 0;

	for (Iterator iter(this); iter; ++iter)
		totalSize += (*iter).TotalSize(justLocked);

	return totalSize;
}

//----------------------------------------------------------------------------------------
// TActionStack::Purge:
//----------------------------------------------------------------------------------------

Size TActionStack::Purge(Size needed)
{
	// Strategy is to purge one transaction at a time from the stack. The grow zone proc
	// will keep calling us back until enough memory has been made available. 
	
	// We always purge from the beginning of the stack. If we're the undo stack, these
	// are the oldest actions. If we're the redo stack, these are the newest actions,
	// but they're the farthest from the top action which is showing in the redo menu
	// item. In other words, purging never causes the redo menu item to change from
	// "redo this" to "redo that". What will happen is the redo stack will be trimmed
	// until we get to the last action, and the user will see the menu item change from
	// "redo this" to "can't redo" (actually a disabled "redo"). 

	Size totalPurged = 0;

	ArrayIndex_AC count = 0;
	for (CActionIterator iter(this); iter; ++iter)
	{
		totalPurged += (*iter).Purge(needed);
		
		// Break out after purging one complete transaction
		if (!iter.GetLevel())
		{
			++count;
			break;
		}
	}

	if (count > 0)
		ClearTransactions(count);

	return totalPurged;
}

//========================================================================================
// CLASS CActionIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CActionIterator constructor
//----------------------------------------------------------------------------------------

CActionIterator::CActionIterator(const TActionStack* inList,
								 ArrayIndex_AC inLowBound, ArrayIndex_AC inHighBound,
								 bool inForward)
	:	BaseIterator(inList, inLowBound, inHighBound, inForward),
		fLevel(0)
{
	// Iterator::First has already been called by our superclass constructor, so all we
	// have to do is compute the transaction level. This way is more efficient than 
	// calling our First which would call Iterator::First a second time. 
	ActionLevel();
}

//----------------------------------------------------------------------------------------
// CActionIterator constructor
//----------------------------------------------------------------------------------------

CActionIterator::CActionIterator(const TActionStack* inList, bool inForward)
	:	BaseIterator(inList, inForward),
		fLevel(0)
{
	// Iterator::First has already been called by our superclass constructor, so all we
	// have to do is compute the transaction level. This way is more efficient than 
	// calling our First which would call Iterator::First a second time. 
	ActionLevel();
}

//----------------------------------------------------------------------------------------
// CActionIterator::First: 
//----------------------------------------------------------------------------------------

CUndoAction* CActionIterator::First()
{
	CUndoAction* action = BaseIterator::First();
	fLevel = 0;
	ActionLevel();
	return action;
}

//----------------------------------------------------------------------------------------
// CActionIterator::Next: 
//----------------------------------------------------------------------------------------

CUndoAction* CActionIterator::Next()
{
	CUndoAction* action = BaseIterator::Next();
	ActionLevel();
	return action;
}

//----------------------------------------------------------------------------------------
// CActionIterator::ActionLevel: 
//----------------------------------------------------------------------------------------

void CActionIterator::ActionLevel()
{
	CUndoAction* action = Current();
	if (action)
	{
		EActionType actionType = action->GetActionType();
		if (actionType == kEndAction)
			++fLevel;
		else if (actionType == kBeginAction)
			--fLevel;
	}
}


//========================================================================================
// CLASS TUndoHandler
//========================================================================================

//----------------------------------------------------------------------------------------
// TUndoHandler Global Variables
//----------------------------------------------------------------------------------------

TUndoHandler* TUndoHandler::fgFirstUndoHandler;
TUndoHandler* TUndoHandler::fgLastUndoHandler;
ArrayIndex_AC TUndoHandler::fgMaxDesiredItems = kDefaultUndoStackDepth;

//----------------------------------------------------------------------------------------
// TUndoHandler constructor
//----------------------------------------------------------------------------------------

TUndoHandler::TUndoHandler() :
	TBehavior(kStdUndoBehavior),
	fInTransaction(0),
	fActionState(kInSingleAction),
	fActionCommand(cNoCommand),
	fNextUndoHandler(NULL)
{
	InsertLast();
}

//----------------------------------------------------------------------------------------
// TUndoHandler destructor
//----------------------------------------------------------------------------------------

TUndoHandler::~TUndoHandler()
{
	ClearActionHistory();

	Remove();
}

//----------------------------------------------------------------------------------------
// TUndoHandler::DoSetupMenus: 
//----------------------------------------------------------------------------------------

void TUndoHandler::DoSetupMenus()
{
	TBehavior::DoSetupMenus();

	// setup the undo menu item
	CommandNumber undoCommand = GetUndoID();
	gDispatcher->SetUndoText(undoCommand);

	// setup the undo menu item
	CommandNumber redoCommand = GetRedoID();
	gDispatcher->SetRedoText(redoCommand);

	// setup the undo/redo menu item
	bool cmdDone = undoCommand != cNoCommand; 
	CommandNumber undoRedoCommand = cmdDone ? undoCommand : redoCommand;
	gDispatcher->SetUndoRedoText(cmdDone, undoRedoCommand != cNoCommand ? undoRedoCommand : cCantUndo);
}

//----------------------------------------------------------------------------------------
// TUndoHandler::DoMenuCommand: 
//----------------------------------------------------------------------------------------

void TUndoHandler::DoMenuCommand(CommandNumber aCommandNumber) // override
{
	// ===================================================================================
	// Some commands will be posted to perform actions that must _ALWAYS_ be available.
	// The allocation cannot be allowed to fail. So we do a temp allocation which by
	// definition cannot be allowed to fail. This strategy is used wherever we want to use
	// command objects but don't want to leave the user twisting in the breeze. NOTE:
	// Don't forget to allow for this memory in your mem! resource if you copy this style
	// in your own code.
	// ===================================================================================

	switch (aCommandNumber)
	{
		case cUndo:
		case cRedo:
		case cUndoRedo:
			{
				CTempAllocation  tempAllocation(true);
				CTempObjectAllocation tempObjectAllocation(true);

				TUndoRedoCommand* undoRedoCommand = TH_new TUndoRedoCommand(aCommandNumber, this);
				undoRedoCommand->SetUseAppleEvent(true);
				fOwner->PostCommand(undoRedoCommand);
			}
			break;

		default:
			TBehavior::DoMenuCommand(aCommandNumber);
			break;
	}
}

#if qAppleEventAware
//----------------------------------------------------------------------------------------
// TUndoHandler::DoScriptCommand
//----------------------------------------------------------------------------------------

bool TUndoHandler::DoScriptCommand(CommandNumber aCommandNumber,
								   TAppleEvent* /*message*/,
								   TAppleEvent* /*reply*/)
{
	bool handled = false;

	switch (aCommandNumber)
	{
		case cAEUndo:
			if (CommandEnabled(cUndo))
				handled = UndoRedoInContext(aCommandNumber);
			break;
		
		case cAERedo:
			if (CommandEnabled(cRedo))
				handled = UndoRedoInContext(aCommandNumber);
			break;

		default:
			break;
	}

	return handled;
}
#endif // qAppleEventAware

//----------------------------------------------------------------------------------------
// TUndoHandler::UndoRedoInContext: 
//----------------------------------------------------------------------------------------

bool TUndoHandler::UndoRedoInContext(CommandNumber aCommandNumber)
// Handles the undo event. TDispatcher will handle this for itself, but if
// you handle undo/redo in another context you should call this from that object's
// DoScriptCommand method.
{
	bool completed = false;
	if (aCommandNumber == cAEUndo || aCommandNumber == cAERedo)
	{
		CTempAllocation tempAllocation(true);
		CTempObjectAllocation tempObjectAllocation(true);
		
		// Generate the proper undo or redo command.
		TUndoRedoCommand* anUndoOrRedoCommand = TH_new TUndoRedoCommand(aCommandNumber, this);
		anUndoOrRedoCommand->Process();

		completed = true;
	}

	return completed;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::AddActionToHistory:
//----------------------------------------------------------------------------------------

void TUndoHandler::AddActionToHistory(TCommand* command, CommandNumber id)
{
	EActionType action = kSingleAction;
	if (fActionState == kInBeginAction)
	{
		action = kBeginAction;
		fActionState = kInCollectActions;
		if (fActionCommand != cNoCommand)
			id = fActionCommand;
		++fInTransaction;
	}

	fUndoStack.PushAction(CUndoAction(command, action, id));
	
	command->SetUndoHandler(this);

	fRedoStack.FreeAll();
}

//----------------------------------------------------------------------------------------
// TUndoHandler::BeginAction:
//----------------------------------------------------------------------------------------

void TUndoHandler::BeginAction(CommandNumber inCommand)
{
	fActionCommand = inCommand;
	fActionState = kInBeginAction;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::EndAction:
//----------------------------------------------------------------------------------------

void TUndoHandler::EndAction(CommandNumber inCommand)
{
	if (fActionState == kInCollectActions)
	{
		CUndoAction* action = fUndoStack.Top();
		if (action)
		{
			// If the transaction has only one action, change it to a single action. 
			// Otherwise, change the last action in the transaction to an end action. 
			EActionType actionType = (action->GetActionType() == kBeginAction) ? kSingleAction : kEndAction;
			action->SetActionType(actionType);
		}

		--fInTransaction;

		if (inCommand != cNoCommand)
		{
			for (CActionIterator iter(&fUndoStack, kIterateBackward_AC); iter; ++iter)
			{
				iter->SetCommandNumber(inCommand);

				// Break out when we're done with the top transaction
				if (!iter.GetLevel())
					break;
			}
		}
	}

	fActionState = kInSingleAction;
	fActionCommand = cNoCommand;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::ClearActionHistory:
//----------------------------------------------------------------------------------------

void TUndoHandler::ClearActionHistory()
{
	fRedoStack.FreeAll();
	fUndoStack.FreeAll();
}

//----------------------------------------------------------------------------------------
// TUndoHandler::Contains:
//----------------------------------------------------------------------------------------

bool TUndoHandler::Contains(TCommand* command)
{
	return command && (fUndoStack.Contains(command) || fRedoStack.Contains(command));
}

//----------------------------------------------------------------------------------------
// TUndoHandler::Abort:
//----------------------------------------------------------------------------------------

void TUndoHandler::Abort()
{
	long level = fInTransaction;
		// start with fInTransaction so we can abort a partial transaction
	do
	{
		EActionType actionType = AbortAction();
		if (actionType == kEndAction)
			++level;
		else if (actionType == kBeginAction)
		{
			--level;
#if qDebug
			::Assertion_AC(level >= 0, "Bad undo stack");
#endif
		}
	} while (level);
}

//----------------------------------------------------------------------------------------
// TUndoHandler::AboutToDo:
//----------------------------------------------------------------------------------------

void TUndoHandler::AboutToDo(TCommand* /*command*/)
{
	// Purge some actions if we've busted through the max desired.
	ArrayIndex_AC count = fUndoStack.CountTransactions() + fRedoStack.CountTransactions();
	if (count > fgMaxDesiredItems)
	{
		// Prefer to delete from the undo stack, but don't delete the transaction
		// that we're about to do
		
		// ��� Need to check if actions are done before clearing them !!!

		if (fUndoStack.CountTransactions() > 1)
			fUndoStack.ClearTransactions(1);
		else
			fRedoStack.ClearTransactions(1);
	}
}

//----------------------------------------------------------------------------------------
// TUndoHandler::SetMaxDesiredItems:
//----------------------------------------------------------------------------------------

ArrayIndex_AC TUndoHandler::SetMaxDesiredItems(ArrayIndex_AC newDepth)
{
	ArrayIndex_AC returnVal = fgMaxDesiredItems;
	
	fgMaxDesiredItems = newDepth;
	
	return returnVal;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::Undo:
//----------------------------------------------------------------------------------------

void TUndoHandler::Undo()
{
#if qDebug
	::Assertion_AC(!fInTransaction, "Undo during transaction");
#endif
	long level = 0;
	do
	{
		EActionType actionType = UndoAction();
		if (actionType == kEndAction)
			++level;
		else if (actionType == kBeginAction)
		{
			--level;
#if qDebug
			::Assertion_AC(level >= 0, "Bad undo stack");
#endif
		}
	}

	while (level);
}

//----------------------------------------------------------------------------------------
// TUndoHandler::GetUndoID:
//----------------------------------------------------------------------------------------

CommandNumber TUndoHandler::GetUndoID()
{
	CUndoAction* foundAction = fUndoStack.Top();
	return foundAction ? foundAction->GetCommandNumber() : cNoCommand;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::Redo:
//----------------------------------------------------------------------------------------

void TUndoHandler::Redo()
{
#if qDebug
	::Assertion_AC(!fInTransaction, "Redo during transaction");
#endif
	long level = 0;
	do
	{
		EActionType actionType = RedoAction();
		if (actionType == kBeginAction)
			++level;
		else if (actionType == kEndAction)
		{
			--level;
#if qDebug
			::Assertion_AC(level >= 0, "Bad redo stack");
#endif
		}
	}
	while (level);
}

//----------------------------------------------------------------------------------------
// TUndoHandler::GetRedoID:
//----------------------------------------------------------------------------------------

CommandNumber TUndoHandler::GetRedoID()
{
	CUndoAction* foundAction = fRedoStack.Top();
	return foundAction ? foundAction->GetCommandNumber() : cNoCommand;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::RemoveCommandAction:
//----------------------------------------------------------------------------------------

void TUndoHandler::RemoveCommandAction(TCommand* command)
{
	if (!fUndoStack.RemoveCommandAction(command))
		fRedoStack.RemoveCommandAction(command);
}

//----------------------------------------------------------------------------------------
// Purging
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TUndoHandler::TotalSize:
//----------------------------------------------------------------------------------------

Size TUndoHandler::TotalSize(bool justLocked) const
{
	return fUndoStack.TotalSize(justLocked) + fRedoStack.TotalSize(justLocked);
}

//----------------------------------------------------------------------------------------
// TUndoHandler::Purge:
//----------------------------------------------------------------------------------------

Size TUndoHandler::Purge(Size needed)
{
	// All the actions in the undo stack are older than the actions in the redo stack. 
	// Strategy is to purge one action at a time from the undo stack until we have enough
	// memory or the undo stack is empty, then to work on the redo stack. 

	Size totalPurged = 0;
	
	if (fUndoStack.GetSize() > 0)
		totalPurged = fUndoStack.Purge(needed);
	else
		totalPurged = fRedoStack.Purge(needed);

	return totalPurged;
}

//----------------------------------------------------------------------------------------
// Undo Handler List
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TUndoHandler::InsertLast:
//----------------------------------------------------------------------------------------

void TUndoHandler::InsertLast()
{
	// Add this undo handler to the end of the list. 
	
	// If there already is an undo handler at the end of the list, we come after it. 
	// By definition, the last undo handler will not have a next undo handler, so
	// we don't need to set our own fNextUndoHandler to anything. Note that this
	// allows a chain of undo handlers to be added to the list if anyone ever needs to. 
	if (fgLastUndoHandler)
		fgLastUndoHandler->fNextUndoHandler = this;

	// We're the new one at the end. 
	fgLastUndoHandler = this;
	
	// If the list was empty, we're also the one at the beginning. 
	if (!fgFirstUndoHandler)
		fgFirstUndoHandler = this;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::Remove:
//----------------------------------------------------------------------------------------

void TUndoHandler::Remove()
{
	TUndoHandler* previous = NULL;
	TUndoHandler* current = fgFirstUndoHandler;

	// Find ourselves in the list
	while (current && (this != current))
	{
		previous = current;
		current = current->fNextUndoHandler;
	}

	// Make sure we were found in the list, but don't complain about double removes
	if (current && (this == current))
	{
		if (previous)
		{
			// Unlink from previous handler
			previous->fNextUndoHandler = fNextUndoHandler;
		}
		else
		{
			// Unlink from head of list
			fgFirstUndoHandler = fNextUndoHandler;
		}

		// Previous handler or list head now owns our next handler
		fNextUndoHandler = NULL;

		// If we were the last handler, the previous handler becomes the new last handler. 
		// If 'previous' is NULL and we're the last handler, the list is becoming empty,
		// so this code does the right thing in all cases. 
		if (this == fgLastUndoHandler)
			fgLastUndoHandler = previous;
	}
}

//----------------------------------------------------------------------------------------
// For internal use only
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TUndoHandler::AbortAction:
//----------------------------------------------------------------------------------------

EActionType TUndoHandler::AbortAction()
{
	CUndoAction* action = fUndoStack.Top();
	::ThrowIfNonObject_AC(action);

	TCommand* command = action->GetCommand();

	if (command && command->GetCommandDone() && command->CanBeUndone() &&
		(command->GetValidationError() == noErr))
		AbortCommand(command);

	EActionType actionType = action->GetActionType();
	action->DeleteCommand();
	fUndoStack.Delete(action);

	return actionType;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::AbortCommand:
//----------------------------------------------------------------------------------------

void TUndoHandler::AbortCommand(TCommand* command)
{
	try
	{
		command->Abort();
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		command->SetValidationError(theException.GetError());
		CommandNumber aCommandNumber = command->GetIdentifier();

		::ThrowNewMessage_AC(theException.GetError(), theException.GetExceptionMessage(),
							 CException_AC::BuildMessage(aCommandNumber, messageCommandError));
	}
	
}

//----------------------------------------------------------------------------------------
// TUndoHandler::UndoAction:
//----------------------------------------------------------------------------------------

EActionType TUndoHandler::UndoAction()
{
	CUndoAction* action = fUndoStack.Top();
	::ThrowIfNonObject_AC(action);

	TCommand* command = action->GetCommand();

	if (command && command->GetCommandDone() && command->CanBeUndone() &&
		(command->GetValidationError() == noErr))
		UndoCommand(command);

	EActionType actionType = action->GetActionType();
	fRedoStack.PushAction(*action);
	fUndoStack.Delete(action);
	
	return actionType;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::UndoCommand:
//----------------------------------------------------------------------------------------

void TUndoHandler::UndoCommand(TCommand* command)
{
	try
	{
		command->PrepareForUndoRedo();
		command->UndoIt();
		command->FinishUndoRedo();
		command->RevealUndoRedo();
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		command->SetValidationError(theException.GetError());
		CommandNumber aCommandNumber = command->GetIdentifier();

		::ThrowNewMessage_AC(theException.GetError(), theException.GetExceptionMessage(),
							 CException_AC::BuildMessage(aCommandNumber, messageCommandError));
	}
	
}

//----------------------------------------------------------------------------------------
// TUndoHandler::RedoAction:
//----------------------------------------------------------------------------------------

EActionType TUndoHandler::RedoAction()
{
	CUndoAction* action = fRedoStack.Top();
	::ThrowIfNonObject_AC(action);

	TCommand* command = action->GetCommand();

	if (command && !command->GetCommandDone() && command->CanBeUndone() &&
		(command->GetValidationError() == noErr))
		RedoCommand(command);

	EActionType actionType = action->GetActionType();
	fUndoStack.PushAction(*action);
	fRedoStack.Delete(action);
	
	return actionType;
}

//----------------------------------------------------------------------------------------
// TUndoHandler::RedoCommand:
//----------------------------------------------------------------------------------------

void TUndoHandler::RedoCommand(TCommand* command)
{
	try
	{
		command->PrepareForUndoRedo();
		command->RedoIt();
		command->FinishUndoRedo();
		command->RevealUndoRedo();
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		command->SetValidationError(theException.GetError());
		CommandNumber aCommandNumber = command->GetIdentifier();

		::ThrowNewMessage_AC(theException.GetError(), theException.GetExceptionMessage(),
							 CException_AC::BuildMessage(aCommandNumber, messageCommandError));
	}
	
}

//========================================================================================
// CLASS TUndoRedoCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TUndoRedoCommand constructor
//----------------------------------------------------------------------------------------

TUndoRedoCommand::TUndoRedoCommand(CommandNumber itsCommandNumber, TUndoHandler* undoHandler) :
	TCommand(itsCommandNumber, undoHandler->GetOwner(), kCantUndo, kDoesNotCauseChange, NULL),
	fHandler(undoHandler)
{
}


//----------------------------------------------------------------------------------------
// TUndoRedoCommand destructor
//----------------------------------------------------------------------------------------

TUndoRedoCommand::~TUndoRedoCommand()
{
}

#if qAppleEventAware

//----------------------------------------------------------------------------------------
// TUndoRedoCommand::MakeAppleEvent: 
//----------------------------------------------------------------------------------------

TAppleEvent* TUndoRedoCommand::MakeAppleEvent()
{
	AEEventID eventID = IsUndo() ? static_cast<AEEventID>(kAEUndo) : static_cast<AEEventID>(kAERedo);

	CAutoPtr_AC<TAppleEvent> theEvent(TH_new TAppleEvent(kAEMiscStandards, eventID, gServerAddress, kAEWaitReply));

	MScriptableObject* target = dynamic_cast_AC(MScriptableObject*, fContext);
	ThrowIfNonObject_AC(target);

	CTempDesc_AC targetDesc;
	target->MakeObjectSpecifier(targetDesc, target->GetSpecifierForm());
	theEvent->WriteParameter(keyDirectObject, targetDesc);

	return theEvent.release();
}

#endif // qAppleEventAware

//----------------------------------------------------------------------------------------
// TUndoRedoCommand::IsUndo:
//----------------------------------------------------------------------------------------

bool TUndoRedoCommand::IsUndo()
{
	bool result = true;

	switch (fIdentifier)
	{
		case cUndo:
		case cAEUndo:
			result = true;
			break;
		
		case cRedo:
		case cAERedo:
			result = false;
			break;
		
		case cUndoRedo:
			ThrowIfNonObject_AC(fHandler);
			result = (fHandler->GetRedoID() == cNoCommand);
			break;
	}

	return result;
}
	

//----------------------------------------------------------------------------------------
// TUndoRedoCommand::DoIt:
//----------------------------------------------------------------------------------------

void TUndoRedoCommand::DoIt()
{
	ThrowIfNonObject_AC(fHandler);
	if (IsUndo())
		fHandler->Undo();
	else
		fHandler->Redo();
}
	

#if !qMSWindows

//========================================================================================
// CLASS CUndoStackHook
//========================================================================================

//----------------------------------------------------------------------------------------
// CUndoStackHook::TotalSize:
//----------------------------------------------------------------------------------------

Size CUndoStackHook::TotalSize(bool justLocked) const
{
	Size total = 0;

	for (TUndoHandler* current = TUndoHandler::FirstUndoHandler(); current; current = current->NextUndoHandler())
		total += current->TotalSize(justLocked);

	return total;
}

//----------------------------------------------------------------------------------------
// CUndoStackHook::Purge:
//----------------------------------------------------------------------------------------

Size CUndoStackHook::Purge(Size needed)
{
	Size totalPurged = 0;

	// Iterate over all the undo handlers
	for (TUndoHandler* current = TUndoHandler::FirstUndoHandler(); current; current = current->NextUndoHandler())
	{
		// Ask the undo handler to purge an action
		totalPurged = current->Purge(needed);

		// If anything got purged,
		if (totalPurged > 0)
		{
			// Move the undo handler to the end of the list so other handlers will
			// get purged first if we have to purge some more. 
			current->Remove();
			current->InsertLast();
			
			// Return to the grow zone proc. It will call us again if we didn't purge
			// enough. This could hammer the heap pretty hard, but we really don't want 
			// to purge the undo stack more than necessary, plus we can't count on the
			// returned 'totalPurged' size to be very accurate. 
			break;
		}
	}

	return totalPurged;
}

#endif // !qMSWindows

//----------------------------------------------------------------------------------------
// End of UUndo.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		06/13/96	Fix bug in grouped commands where the source and target commands were not
							separately identified when using !qUseODUndoStyle
		06/11/96	Fix a problem with undo/redo menu items when posing modally.
		06/11/96	fix a looping problem in ClearActions
		06/10/96	Filter the removal of undo actions by the context of their related commands.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		04/26/96	Made C/CCoordPoint_AC/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CCoordPoint_AC/Rects.
		04/26/96	Make and use an overload of CommandToName that returns a CStr255_AC function result.
		04/26/96	Fix bug where the command being executed would fail and cause the undo
							handler to crash or substitute the wrong error code to the user.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/26/96	Added CUndoStackHook.
		03/14/96	Use CPascalStr_AC::Empty.
		02/28/96	[1158847] Unesscessary ReSignals in UndoHandler::AbortCommand,
							::UndoCommand, ::RedoCommand, copyright.
		12/15/95	Initial version. 
*/