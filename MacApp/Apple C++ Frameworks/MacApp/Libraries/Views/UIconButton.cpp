//----------------------------------------------------------------------------------------
// UIconButton.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		11/05/00	Use the toolbox control for TIconPopup. 
					Value and menu ID were transposed in call to CreateBevelMenuButton_AC. 
					Don't allow the minimum to ever be set > 0 for a popup button. 
					Override SetMinimum instead of CreateControl. 
		07/31/00	[W] Re-enable TIconPopup for Windows.  Cosmetic.
		06/06/00	Added TIconPopup::CreateControl.
		02/22/00	[W] TIconPopup not available for Windows.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		11/02/98	Include CStream_AC.h.
*/

#ifndef __UICONBUTTON__
#include "UIconButton.h"
#endif

#if qAppearance || qEmulateStandardControls

// ACS

#ifndef __CStream_AC__
#include "CStream_AC.h"
#endif

#ifndef __CToolboxControl_AC__
#include "CToolboxControl_AC.h"
#endif

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

// ACS

#if qEmulateStandardControls

	#ifndef __CIconButton_AC__
	#include "CIconButton_AC.h"
	#endif

	#ifndef __AGA_AC__
	#include "AGA_AC.h"
	#endif

#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

//----------------------------------------------------------------------------------------
// We need to subclass the ACS Popup in order to have MacApp's GetMenu called at
// the appropriate times by that class.

#if qEmulateStandardControls

class CMacAppIconPopup : public CIconPopup_AC
{
public:
	CMacAppIconPopup(const CRect_AC& bounds, bool isEnabled, 
					MenuRef itsMenuRef = NULL, 
					const CTextStyle_AC& itsTextStyle = CTextStyle_AC::kSystemStyle, 
					DisposalKind menuRefDisposalKind = kDontDispose, 
					RefHandling refHandling = kNothing, 
					SInt16 offIconID = kNoIconID, 
					SInt16 onIconID = kNoIconID, 
					SInt16 itsCurrentItem = 1,
					ButtonFrameType frameType = kAutoFrame, 
					ControlContentType imageType = kControlContentIconSuiteRes)
		:	CIconPopup_AC(bounds, isEnabled, itsMenuRef, itsTextStyle,
						  menuRefDisposalKind, refHandling, offIconID, onIconID, 
						  itsCurrentItem, frameType, imageType)
		{ }
		
	virtual ~CMacAppIconPopup() { }

	virtual MenuRef LoadMenuRef(SInt16 menuID);
		// overridden to call MAGetMenu
};

#endif // qEmulateStandardControls

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUIconButton
//----------------------------------------------------------------------------------------

void InitUIconButton()
{
	static bool UIconButtonInitialized;

	if (!UIconButtonInitialized)
	{	
		if (qTemplateViews)
		{
			// Register all of the classes defined here. If you prefer, you can
			// selectively register just the classes you will use.
		
			REGISTER_SIGNATURE_AC(TIconButton, kStdIconButton);
			REGISTER_SIGNATURE_AC(TIconCheckBox, kStdIconCheckBox);
			REGISTER_SIGNATURE_AC(TIconRadio, kStdIconRadio);
			REGISTER_SIGNATURE_AC(TIconPopup, kStdIconPopup);
		}
		UIconButtonInitialized = true;
	}
}

//----------------------------------------------------------------------------------------
// GetProcIDFromBounds
//----------------------------------------------------------------------------------------

static ControlVariant GetVariantFromBounds(const CRect_AC& itsBounds)
// Determines bevel button proc ID based on button bounds width
{
	SInt16 buttonWidth = itsBounds.GetLength(hSel);
	if (buttonWidth > 39)
		return kControlBevelButtonLargeBevelVariant;
	else if (buttonWidth > 21)
		return kControlBevelButtonNormalBevelVariant;
	else
		return kControlBevelButtonSmallBevelVariant;
}

//----------------------------------------------------------------------------------------
// SetControlContentRsrcID
//----------------------------------------------------------------------------------------

static void SetControlContentRsrcID(CControl_AC* control, ControlContentType contentType, ResNumber rsrcID)
// Helper function so glue code isn't repeated four times.
{
	if (control)
	{
		ControlButtonContentInfo info;
		info.contentType = contentType;
		info.u.resID = rsrcID;
		control->SetButtonContent(info);
	}
}

//========================================================================================
// CLASS TIconButton
//========================================================================================

MA_DEFINE_CLASS(TIconButton);

//----------------------------------------------------------------------------------------
// TIconButton constructor
//----------------------------------------------------------------------------------------

TIconButton::TIconButton(const CViewPoint& itsLocation, const CViewPoint& itsSize, 
						SizeDeterminer itsHSizeDet, SizeDeterminer itsVSizeDet, 
						const CStr255_AC& itsLabel, ResNumber itsRsrcID,
						ControlContentType contentType)
	:	TButton(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsLabel),
		fRsrcID(itsRsrcID),
		fContentType(contentType)
{
}

//----------------------------------------------------------------------------------------
// TIconButton destructor
//----------------------------------------------------------------------------------------

TIconButton::~TIconButton()
{
}

//----------------------------------------------------------------------------------------
// TIconButton::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TIconButton::GetStandardSignature() const
{
	return kStdIconButton;
}

//----------------------------------------------------------------------------------------
// TIconButton::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TIconButton::DoMakeControl(WindowRef theWindow,
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CIconButton_AC(boundsRect, isEnabled, fRsrcID, kAutoFrame, fContentType);
	else
#endif
		return CreateBevelButton_AC(theWindow, boundsRect, isVisible, isEnabled, 
									kControlBehaviorPushbutton, fContentType, fRsrcID, 0, 
									GetVariantFromBounds(boundsRect), this);
}

//----------------------------------------------------------------------------------------
// TIconButton::ReadFields: 
//----------------------------------------------------------------------------------------

void TIconButton::ReadFields(CStream_AC* aStream)
{
	TButton::ReadFields(aStream);

	*aStream >> fRsrcID;
	SetContentRsrcID(fContentType, fRsrcID);
}

//----------------------------------------------------------------------------------------
// TIconButton::WriteFields: 
//----------------------------------------------------------------------------------------

void TIconButton::WriteFields(CStream_AC* aStream) const
{
	TButton::WriteFields(aStream);

	*aStream << fRsrcID;
}

//----------------------------------------------------------------------------------------
// TIconButton::SetContentRsrcID: 
//----------------------------------------------------------------------------------------

void TIconButton::SetContentRsrcID(ControlContentType contentType, ResNumber rsrcID)
{
	fRsrcID = rsrcID;
	fContentType = contentType;
	
	SetControlContentRsrcID(GetControl(), contentType, rsrcID);
}

//========================================================================================
// CLASS TIconCheckBox
//========================================================================================

MA_DEFINE_CLASS(TIconCheckBox);

//----------------------------------------------------------------------------------------
// TIconCheckBox constructor
//----------------------------------------------------------------------------------------

TIconCheckBox::TIconCheckBox(const CViewPoint& itsLocation, const CViewPoint& itsSize, 
				SizeDeterminer itsHSizeDet, SizeDeterminer itsVSizeDet, 
				const CStr255_AC& itsLabel, SInt16 isTurnedOn, ResNumber itsRsrcID,
				ControlContentType contentType)
	:	TCheckBox(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsLabel, isTurnedOn),
		fRsrcID(itsRsrcID),
		fContentType(contentType)
{
}

//----------------------------------------------------------------------------------------
// TIconCheckBox destructor
//----------------------------------------------------------------------------------------

TIconCheckBox::~TIconCheckBox()
{
}

//----------------------------------------------------------------------------------------
// TIconCheckBox::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TIconCheckBox::GetStandardSignature() const
{
	return kStdIconCheckBox;
}

//----------------------------------------------------------------------------------------
// TIconCheckBox::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TIconCheckBox::DoMakeControl(WindowRef theWindow, 
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CIconCheckBox_AC(boundsRect, isEnabled, 
									CCustomControl_AC::kNoAutomaticState, fInitialState,
									fRsrcID, fRsrcID, kAutoFrame, fContentType);
	else
#endif
		return CreateBevelButton_AC(theWindow, boundsRect, isVisible, isEnabled, 
									kControlBehaviorPushbutton, fContentType, 
									fRsrcID, fInitialState, GetVariantFromBounds(boundsRect), this);
}

//----------------------------------------------------------------------------------------
// TIconCheckBox::ReadFields: 
//----------------------------------------------------------------------------------------

void TIconCheckBox::ReadFields(CStream_AC* aStream)
{
	TCheckBox::ReadFields(aStream);

	*aStream >> fRsrcID;
	SetContentRsrcID(fContentType, fRsrcID);
}

//----------------------------------------------------------------------------------------
// TIconCheckBox::WriteFields: 
//----------------------------------------------------------------------------------------

void TIconCheckBox::WriteFields(CStream_AC* aStream) const
{
	TCheckBox::WriteFields(aStream);

	*aStream << fRsrcID;
}

//----------------------------------------------------------------------------------------
// TIconCheckBox::SetContentRsrcID: 
//----------------------------------------------------------------------------------------

void TIconCheckBox::SetContentRsrcID(ControlContentType contentType, ResNumber rsrcID)
{
	fRsrcID = rsrcID;
	fContentType = contentType;

	SetControlContentRsrcID(GetControl(), contentType, rsrcID);
}

//========================================================================================
// CLASS TIconRadio
//========================================================================================

MA_DEFINE_CLASS(TIconRadio);

//----------------------------------------------------------------------------------------
// TIconRadio constructor
//----------------------------------------------------------------------------------------

TIconRadio::TIconRadio(const CViewPoint& itsLocation, const CViewPoint& itsSize, 
						SizeDeterminer itsHSizeDet, SizeDeterminer itsVSizeDet, 
						const CStr255_AC& itsTitle, SInt16 isTurnedOn, ResNumber itsRsrcID,
						ControlContentType contentType)
	:	TRadio(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTitle, isTurnedOn),
		fRsrcID(itsRsrcID),
		fContentType(contentType)
{
}

//----------------------------------------------------------------------------------------
// TIconRadio destructor
//----------------------------------------------------------------------------------------

TIconRadio::~TIconRadio()
{
}

//----------------------------------------------------------------------------------------
// TIconRadio::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TIconRadio::GetStandardSignature() const
{
	return kStdIconRadio;
}

//----------------------------------------------------------------------------------------
// TIconRadio::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TIconRadio::DoMakeControl(WindowRef theWindow,
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CIconRadioButton_AC(boundsRect, isEnabled, 
							MExclusiveObject_AC::kNoGroupID, MExclusiveObject_AC::kNoGroupID,
							 CCustomControl_AC::kNoAutomaticState, fInitialState, 
							 fRsrcID, fRsrcID, kAutoFrame, 
							 fContentType);
	else
#endif // qEmulateStandardControls
		return CreateBevelButton_AC(theWindow, boundsRect, isVisible, isEnabled, 
									kControlBehaviorPushbutton, fContentType, 
									fRsrcID, fInitialState, GetVariantFromBounds(boundsRect), this);
}

//----------------------------------------------------------------------------------------
// TIconRadio::ReadFields: 
//----------------------------------------------------------------------------------------

void TIconRadio::ReadFields(CStream_AC* aStream)
{
	TRadio::ReadFields(aStream);

	*aStream >> fRsrcID;
	SetContentRsrcID(fContentType, fRsrcID);
}

//----------------------------------------------------------------------------------------
// TIconRadio::WriteFields: 
//----------------------------------------------------------------------------------------

void TIconRadio::WriteFields(CStream_AC* aStream) const
{
	TRadio::WriteFields(aStream);

	*aStream << fRsrcID;
}

//----------------------------------------------------------------------------------------
// TIconRadio::SetContentRsrcID: 
//----------------------------------------------------------------------------------------

void TIconRadio::SetContentRsrcID(ControlContentType contentType, ResNumber rsrcID)
{
	fRsrcID = rsrcID;
	fContentType = contentType;
	
	SetControlContentRsrcID(GetControl(), contentType, rsrcID);
}

//========================================================================================
// CLASS TIconPopup
//========================================================================================

MA_DEFINE_CLASS(TIconPopup);

//----------------------------------------------------------------------------------------
// TIconPopup constructor
//----------------------------------------------------------------------------------------

TIconPopup::TIconPopup(const CViewPoint& itsLocation,
					   const CViewPoint& itsSize,
					   SizeDeterminer itsHSizeDet,
					   SizeDeterminer itsVSizeDet,
					   short itsMenuID,
					   short itsCurrentItem,
					   short itsItemOffset,
					   short itsStrListID,
					   short itsIndex,
					   /* Style */ short itsStyle,
					   short itsJust,
					   bool useAddResMenu,
					   ResType useAddResMenuResType,
					   const CTextStyle_AC& itsTextStyle,
					   ResNumber itsRsrcID,
					   ControlContentType contentType)
	:	TPopup(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsMenuID,
			   itsCurrentItem, itsItemOffset, itsStrListID, itsIndex,
			   itsStyle, itsJust, useAddResMenu, useAddResMenuResType, itsTextStyle),
	fRsrcID(itsRsrcID),
	fContentType(contentType)
{
}

//----------------------------------------------------------------------------------------
// TIconPopup destructor
//----------------------------------------------------------------------------------------

TIconPopup::~TIconPopup()
{
}

//----------------------------------------------------------------------------------------
// TIconPopup::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TIconPopup::GetStandardSignature() const
{
	return kStdIconPopup;
}

//----------------------------------------------------------------------------------------
// TIconPopup::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TIconPopup::DoMakeControl(WindowRef theWindow,
									const CRect_AC& boundsRect, 
									bool /*isVisible*/, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
	{
		CTextStyle_AC	textStyle(fTextStyle);

		textStyle.tsFace = normal;	// the actual popup can't have a style, even though AdLib allows it to be set

		return TH_new CMacAppIconPopup(boundsRect, isEnabled, GetMenuRef(), 
						textStyle, CMacAppIconPopup::kDontDispose, CMacAppIconPopup::kReload, fRsrcID, fRsrcID, 1, kAutoFrame, 
						fContentType);
	}
	else
#endif // qEmulateStandardControls
	{
		// Set up the port's text style -- NewControl needs this.

		SetPortTextStyle(fTextStyle);
		PenNormal();

		return CreateBevelMenuButton_AC(theWindow,						// WindowRef theWindow, 
										boundsRect,						// const CRect_AC& boundsRect = CRect_AC::kZeroRect,
										false,							// bool isVisible = false,
										isEnabled,						// bool isActive = true, 
										kControlBehaviorPushbutton,		// short itsBehaviorType = 0,						// control behavior (toggle etc.)
										fContentType,					// short itsContentType = 0,						// content type (icon suite, etc.)
										fRsrcID,						// ResID itsRsrcID = 0,							// ID of icon suite, pict, etc.
										0,								// short itsValue = 0,
										GetMenuID(),					// short itsMenuID = 0,							// rsrc ID of 'MENU' or 'CMNU' rsrc (or 0 for no menu)
										false,							// bool positionMenuOnRight = false,
										GetVariantFromBounds(boundsRect),	// ControlVariant bevelVariant = kControlBevelButtonSmallBevelVariant, 
										this);							// MControlHandler_AC* actionHandler = NULL);
	}
}

//----------------------------------------------------------------------------------------
// TIconPopup::ReadFields: 
//----------------------------------------------------------------------------------------

void TIconPopup::ReadFields(CStream_AC* aStream)
{
	TPopup::ReadFields(aStream);

	*aStream >> fRsrcID;
	SetContentRsrcID(fContentType, fRsrcID);
}

//----------------------------------------------------------------------------------------
// TIconPopup::WriteFields: 
//----------------------------------------------------------------------------------------

void TIconPopup::WriteFields(CStream_AC* aStream) const
{
	TPopup::WriteFields(aStream);

	*aStream << fRsrcID;
}

//----------------------------------------------------------------------------------------
// TIconPopup::SetContentRsrcID: 
//----------------------------------------------------------------------------------------

void TIconPopup::SetContentRsrcID(ControlContentType contentType, ResNumber rsrcID)
{
	fRsrcID = rsrcID;
	fContentType = contentType;
	
	SetControlContentRsrcID(GetControl(), contentType, rsrcID);
}

//----------------------------------------------------------------------------------------
// TIconPopup::GetValue: 
//----------------------------------------------------------------------------------------

ViewCoordinate TIconPopup::GetValue() const
{
	return GetControl() ? GetControl()->GetButtonMenuValue() : 0;
}

//----------------------------------------------------------------------------------------
// TIconPopup::SetValue: 
//----------------------------------------------------------------------------------------

void TIconPopup::SetValue(ViewCoordinate newVal, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetButtonMenuValue(static_cast<short>(newVal));
	}
}
	
//----------------------------------------------------------------------------------------
// TIconPopup::SetValues: 
//----------------------------------------------------------------------------------------

void TIconPopup::SetValues(ViewCoordinate itsVal,
						   ViewCoordinate itsMin,
						   ViewCoordinate itsMax,
						   bool redraw)
{
#pragma unused (itsMin)

	// Set the menu value instead of the button state.
	SetMaximum(itsMax, redraw);
	//SetMinimum(itsMin, redraw);
	SetValue(itsVal, redraw);
}
	
//----------------------------------------------------------------------------------------
// TIconPopup::SetMinimum: 
//----------------------------------------------------------------------------------------

void TIconPopup::SetMinimum(ViewCoordinate itsMin, bool redraw)
{
#pragma unused (itsMin, redraw)
	// Don't set the minimum because it could cause the button part to always
	// draw using its pushed down image. 
}
	
//----------------------------------------------------------------------------------------
// TIconPopup::GetState: 
//----------------------------------------------------------------------------------------

short TIconPopup::GetState() const
{
	return GetControl() ? GetControl()->GetValue() : 0;
}

//----------------------------------------------------------------------------------------
// TIconPopup::SetState: 
//----------------------------------------------------------------------------------------

void TIconPopup::SetState(short newState, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetValue(newState);
	}
}

#if qEmulateStandardControls
//----------------------------------------------------------------------------------------
// TPopup::LoadMenuRef: 
//----------------------------------------------------------------------------------------

MenuRef CMacAppIconPopup::LoadMenuRef(SInt16 menuID)
{
#if !qMSWindows
	return ::MAGetMenu(menuID);
#else
	#pragma unused (menuID)
	#pragma message("CMacAppIconPopup::LoadMenuRef: Implement.")
#endif
}

#endif // qEmulateStandardControls
#endif // qAppearance || qEmulateStandardControls


//----------------------------------------------------------------------------------------
// End of UIconButton.cpp
