//----------------------------------------------------------------------------------------
// USeparator.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __USEPARATOR__
#include "USeparator.h"
#endif

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUSeparator
//----------------------------------------------------------------------------------------

void InitUSeparator()
{
	static bool USeparatorInitialized;

	if (!USeparatorInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TSeparator, kStdSeparator);
		}
		USeparatorInitialized = true;
	}
}

//========================================================================================
// CLASS TSeparator
//========================================================================================
#undef Inherited
#define Inherited TView

MA_DEFINE_CLASS(TSeparator);

//----------------------------------------------------------------------------------------
// TSeparator constructor
//----------------------------------------------------------------------------------------

TSeparator::TSeparator(const CViewPoint& itsLocation, const CViewPoint& itsSize, SizeDeterminer itsHSizeDet, SizeDeterminer itsVSizeDet) :
	TView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
	fWasActive(false)
{
	// Appearance & emulation have insets and we can't predict where our separator line needs to be redrawn.
	SetFrameInvalidateDeterminer(frameInvalidateWholeFrame);
}

//----------------------------------------------------------------------------------------
// TSeparator copy constructor
//----------------------------------------------------------------------------------------

TSeparator::TSeparator(const TSeparator& otherSeparator) :
	TView(otherSeparator),
	fWasActive(false)
{
	// Appearance & emulation have insets and we can't predict where our separator line needs to be redrawn.
	SetFrameInvalidateDeterminer(frameInvalidateWholeFrame);
}

//----------------------------------------------------------------------------------------
// TSeparator destructor
//----------------------------------------------------------------------------------------

TSeparator::~TSeparator()
{
}

//----------------------------------------------------------------------------------------
// TSeparator::Draw
//----------------------------------------------------------------------------------------

void TSeparator::Draw(const CViewRect& /*area*/)
{
	DrawSeparator(GetQDExtent(), IsActive());
}

//----------------------------------------------------------------------------------------
// TSeparator::Activate
//----------------------------------------------------------------------------------------

void TSeparator::Activate(bool entering)
{	
	if (fWasActive != entering && Focus() && IsVisible())
	{
		fWasActive = entering;

//		if (!HasPendingUpdate())
//			DrawContents();
//		else
			ForceRedraw(); //DrawSeparator(GetQDExtent(), entering);	
	}
}

//----------------------------------------------------------------------------------------
// TSeparator::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TSeparator::GetStandardSignature() const
{
	return kStdSeparator;
}

//----------------------------------------------------------------------------------------
// TSeparator::DrawSeparator
//----------------------------------------------------------------------------------------

void TSeparator::DrawSeparator(const CRect_AC& itsExtent, bool isEnabled)
{
	::AGADrawSeparator(itsExtent, isEnabled, kRGBColorRamp[r2], kSeparatorAutomatic);
}

