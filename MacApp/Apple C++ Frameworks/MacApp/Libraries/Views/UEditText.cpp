//----------------------------------------------------------------------------------------
// UEditText.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/21/01	Clean up includes. 
		04/07/01	[PB] SetText was comparing between signed and unsigned. 
		04/02/01	Removed TEditText::ImageText -- it was not setting text style.
		01/24/01	[W] Convert tempTempText in GetText.
		01/11/01	Use CString_AC instead of string and CStr255_AC.
		01/02/01	Update copyright.
		12/28/00	Work around StripLineFeeds and CopyTo are only in CPascalStr. 
		12/26/00	[W] Changed DoPostCreate.  Reworked justification in
					SetJustification.  StripLineFeeds in GetText.  Handle
					WM_PAINT in HandleWindowsEvent.
		12/15/00	Change parm in SetText from CStr255_AC to string.  Changed
					fDataHandle to fString and all associated code to handle a string.
		11/30/00	DonÕt check fTEView against nil in BecomeTarget.
		11/27/00	Use nil instead of NULL in call to TextBox_AC in ImageText.
		11/09/00	[PB] Change initialization order to match declaration. 
		11/05/00	Cast gEmptyString for ParamText.
		10/16/00	[W] Custom window creation in DoPostCreate.  Do not set
					fTEView in BecameTarget.
		09/01/00	Stripped dead code.  Cosmetic.
		07/31/00	[W] No floating TE view for Windows.  Added SetWindowsWindow,
					GetWindowsClassName and HandleWindowsEvent.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		07/12/99	Optimize becoming a target by setting the target directly to the
					TEView, skips temporarily setting the target to the edit text. 
		03/24/99	Update copyright notice.
		03/18/99	Removed '&' on parms to a variety of Toolbox calls.
*/

#ifndef __UEDITTEXT__
#include "UEditText.h"
#endif

// MacApp

#ifndef __UDIALOG__	
#include "UDialog.h"
#endif

#ifndef __UDIALOGTEVIEW__	
#include "UDialogTEView.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#if qDrag
	#ifndef __UDRAGDROP__
	#include "UDragDrop.h"
	#endif
#endif

#ifndef __UMACAPPUTILITIES__	
#include "UMacAppUtilities.h"
#endif

#ifndef __USTATICTEXT__
#include "UStaticText.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UTECOMMANDS__
#include "UTECommands.h"
#endif

// ACS

#ifndef __TextBox_AC__
#include "TextBox_AC.h"
#endif

//----------------------------------------------------------------------------------------

#if !qMSWindows

TFloatingTEManager gFloatingTEManager;			// The floating TEView used with edit text
                                                // fields.
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUEditText: 
//----------------------------------------------------------------------------------------

void InitUEditText()
{
	static bool UEditTextInitialized;

	if (!UEditTextInitialized)
	{	
		if (qTemplateViews)
		{
			// So the linker doesn't dead strip these 
#if !qMSWindows
			REGISTER_SIGNATURE_AC(TDialogTEView, kStdDialogTEView);
#endif
			REGISTER_SIGNATURE_AC(TEditText, kStdEditText);
		}
	
		UEditTextInitialized = true;
	}
}

//----------------------------------------------------------------------------------------
// AcquireFloatingTEView: 
//----------------------------------------------------------------------------------------

TDialogTEView* AcquireFloatingTEView()
{
#if !qMSWindows
	return gFloatingTEManager.AcquireFloatingTE();
#else
	return NULL;
#endif
}

//----------------------------------------------------------------------------------------
// ReleaseFloatingTEView: 
//----------------------------------------------------------------------------------------

void ReleaseFloatingTEView(TDialogTEView* aDialogTEView)
{
#if !qMSWindows
	gFloatingTEManager.ReleaseFloatingTE(aDialogTEView);
#endif
}

//========================================================================================
// CLASS TEditText
//========================================================================================

MA_DEFINE_CLASS(TEditText);

//----------------------------------------------------------------------------------------
// TEditText constructor
//----------------------------------------------------------------------------------------

TEditText::TEditText(const CViewPoint&	itsLocation,
					 const CViewPoint&	itsSize,
					 short				itsMaxChars)
	:	TStaticText(itsLocation, itsSize, sizeFixed, sizeFixed, kNoResource, 0),
		fTEView(NULL),
		fControlChars(macroAsSetElem(chLeft)
					  | macroAsSetElem(chRight)
					  | macroAsSetElem(chUp)
					  | macroAsSetElem(chDown)
					  | macroAsSetElem(chBackspace)),
		fMaxChars(itsMaxChars)
{
#if qMSWindows
	SetWindowsWindowStyle(WS_CHILD | WS_TABSTOP);
#endif	

	fTextStyle = gSystemStyle;
	SetPenSize(CPoint_AC(1,1));				// Éand a thin frame 
	fWantsToBeTarget = true;
	fEventNumber = mEditTextHit;

	fCursorID = iBeamCursor;
	fLetsSubViewsHandleCursor = false;

	SetAdornment(kFrame, kDontRedraw);

	Inset(CViewPoint(2, 2), kDontRedraw);	// Default is a little, teeny insetÉ 

	SetEnable(true);
}

//----------------------------------------------------------------------------------------
// TEditText::Free: 
//----------------------------------------------------------------------------------------

TEditText::~TEditText()
{
	RemoveFloatingTEView();
}

//----------------------------------------------------------------------------------------
// TEditText::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TEditText::GetStandardSignature() const
{
	return kStdEditText;
}

//----------------------------------------------------------------------------------------
// TEditText::ReadFields: 
//----------------------------------------------------------------------------------------

void TEditText::ReadFields(CStream_AC* aStream)
{
	TStaticText::ReadFields(aStream);
	
	fMaxChars = aStream->ReadInteger();
	fControlChars = aStream->ReadLong();
}

//----------------------------------------------------------------------------------------
// TEditText::WriteFields: 
//----------------------------------------------------------------------------------------

void TEditText::WriteFields(CStream_AC* aStream) const
{
	TStaticText::WriteFields(aStream);

	aStream->WriteInteger(fMaxChars);
	aStream->WriteLong(fControlChars);
}

//----------------------------------------------------------------------------------------
// TCheckBox::DoPostCreate:
//----------------------------------------------------------------------------------------

void TEditText::DoPostCreate(TDocument* itsDocument)
// DoPostCreate is used to set the Windows-related control style.
//
// itsDocument:		A TDocument* which points to the document into which this control
//					is being installed.
//
// Override:		As needed.
// Call:			Only as the inherited DoPostCreate when implementing a custom
//					class deriving from TEditText and which has its own DoPostCreate.
{
	TStaticText::DoPostCreate(itsDocument);

#if qMSWindows
	DWORD windowStyle = 0;
	switch (fJust)
	{
		
		case teCenter:
			windowStyle = WS_CHILD | WS_TABSTOP | ES_CENTER | WS_BORDER;
			break;

		case teFlushRight:
			windowStyle = WS_CHILD | WS_TABSTOP | ES_RIGHT | WS_BORDER;
			break;

		default:
			windowStyle = WS_CHILD | WS_TABSTOP | WS_BORDER;
			break;
	}
	if (fSize.v >= fTextStyle.tsSize*2)
		windowStyle |= ES_MULTILINE;
	if (!IsEnabled())
		windowStyle |= ES_READONLY;
	SetWindowsWindowStyle(windowStyle);
#endif
}

//----------------------------------------------------------------------------------------
// TEditText::WriteSubViews: 
//----------------------------------------------------------------------------------------

void TEditText::WriteSubViews(CStream_AC* aStream) const
{
	// remove floating TEView, if any
	
	TStaticText::WriteSubViews(aStream);
	
	// restore floating TEView, if any
}

//----------------------------------------------------------------------------------------
// TEditText::HandleMouseDown: 
//----------------------------------------------------------------------------------------

bool TEditText::HandleMouseDown(const CViewPoint&	theMouse,
								TToolboxEvent*		event,
								CPoint_AC			hysteresis,
								EMouseDownType		mouseDownType)
{
	bool returnVal = false;
	
	if (TStaticText::HandleMouseDown(theMouse,event,hysteresis, mouseDownType))
	{
		HandleEvent(fEventNumber,this,NULL);
		returnVal = true;
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TEditText::DoMouseCommand: 
//----------------------------------------------------------------------------------------

void TEditText::DoMouseCommand(CViewPoint&			theMouse,
								TToolboxEvent*	event,
								CPoint_AC			hysteresis)
{	
	if (fTEView)
		fTEView->DoMouseCommand(theMouse, event, hysteresis);
	else
		TStaticText::DoMouseCommand(theMouse, event, hysteresis);
}

//----------------------------------------------------------------------------------------
// TEditText::BecomeTarget: 
//----------------------------------------------------------------------------------------

bool TEditText::BecomeTarget()
{
	bool valid = true;

#if qMSWindows
	#pragma message("TEditText::BecomeTarget: Implement.")
#else

	// Validate the current target, if there is one, before installing the TEView or
	// targeting it. We don't need to validate the current target if it's our own TEView. 
	TEventHandler* currentTarget = GetTarget();
	if (currentTarget && fTEView != currentTarget)
	{
		long reason = currentTarget->WillingToResignTarget();

		if (reason)
		{
			currentTarget->TargetValidationFailed(reason);
			valid = false;	
		}
		else
			currentTarget->TargetValidationSucceeded();
	}

	if (valid)
	{
		// Now it's okay to go back in the water. 
		if (!fTEView)
			InstallFloatingTEView(false);

		SetTarget(fTEView);
	}
#endif

	return valid;
}

//----------------------------------------------------------------------------------------
// TEditText::BecameWindowTarget: 
//----------------------------------------------------------------------------------------

void TEditText::BecameWindowTarget()
{
	if (!fTEView)
		InstallFloatingTEView(false);

	TStaticText::BecameWindowTarget();
}

//----------------------------------------------------------------------------------------
// TEditText::BecameTarget: 
//----------------------------------------------------------------------------------------

void TEditText::BecameTarget()
{	
#if !qMSWindows
	// fTEView is always NULL in Windows	
	if (!fTEView)
		InstallFloatingTEView(false);
	SetTarget(fTEView);
#endif

	TStaticText::BecameTarget();
}

//----------------------------------------------------------------------------------------
// TEditText::SetTargetSelection: 
//----------------------------------------------------------------------------------------

void TEditText::SetTargetSelection(bool redraw)
{
	SetSelection(0, SHRT_MAX, redraw);// Select all characters 
	MakeVisible();
}

//----------------------------------------------------------------------------------------
// TEditText::ValidationFailed: 
//----------------------------------------------------------------------------------------

void TEditText::ValidationFailed(long reason)
{
	if (reason != kValidValue)
	{
		if (reason != kErrorHandled)			// go ahead and post an alert 
		{
			::ThrowIfOSErr_AC(MAInteractWithUser());
			if ((reason < 1) || (reason > kNoOfDefaultReasons))
				reason = kInvalidValue;

			CString_AC aString(static_cast<ResNumber>(kInvalidValueReasons),
							   (short)reason);	//!!! Note casting
			ParamText(CStr255_AC(aString), gEmptyString, gEmptyString, gEmptyString);
			StdAlert(phInvalidValue);
		}
		RestartEdit(fString);
	}
}

//----------------------------------------------------------------------------------------
// TEditText::ChangeWrap: 
//----------------------------------------------------------------------------------------

void TEditText::ChangeWrap(bool newAutoWrap, bool redraw)
{
	TStaticText::ChangeWrap(newAutoWrap, redraw);
	if (fTEView)
		fTEView->ChangeWrap(newAutoWrap, redraw);
}

//----------------------------------------------------------------------------------------
// TEditText::Deselect: 
//----------------------------------------------------------------------------------------

bool TEditText::Deselect()
{
	bool returnVal = true;

	//	// Commit the last command to prevent undo from applying to the wrong edit text, and
	//	// to ensure that all changes are made before validating.
	//	if (fTEView)
	//	{
	//		fTEView->GetContext(cNoCommand)->CommitLastCommand();
	//	}
	// ^^^ Previous code replaced with call to DoneTyping in StopEdit ^^^

	long	validateResult = GetValidationError();

	if (validateResult == kValidValue)
		StopEdit();
	else
	{
		ValidationFailed(validateResult);
		returnVal = false;
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TEditText::DoSubstitution: 
//----------------------------------------------------------------------------------------

CString_AC TEditText::DoSubstitution() const
// DoSubstitution bypasses the normal MAReplaceText substitution and simply
// returns our current string.
//
// Call?		As needed.
// Override?	As needed.
{
	return GetText();
}

//----------------------------------------------------------------------------------------
// TEditText::GetText: 
//----------------------------------------------------------------------------------------

CString_AC TEditText::GetText() const
{
	CString_AC returnVal;
	
#if !qMSWindows
	if (!fTEView)
		returnVal = TStaticText::GetText();
	else
	{
		Handle theChars = fTEView->ExtractText();
		short numberOfChars = (short)Min_AC(kStr255Len, GetHandleSize(theChars));
		// delete possible trailing half-character

		if (numberOfChars
			&& MACharacterByteType(*theChars, numberOfChars - 1, fTEView->OffsetToScript(numberOfChars - 1)) == smFirstByte)
			--numberOfChars;

		returnVal = CString_AC(static_cast<char*>(*theChars), numberOfChars);
	}
#else
	HWND window = GetWindowsWindow();
	if (window == NULL)
		returnVal = TStaticText::GetText();
	else
	{
		short	numberOfChars = (short)Min_AC(kStr255Len, GetWindowTextLength(window));
		char	tempText[256];

		GetWindowText(window, tempText, numberOfChars+1); // copy the NULL character too
    	returnVal = tempText;
    	CStr255_AC tempTempText(tempText);
		tempTempText.StripLineFeeds(); // Windows hack to handle line feeds.
		returnVal = CString_AC(tempTempText);
	}
#endif

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TEditText::InstallFloatingTEView: 
//----------------------------------------------------------------------------------------

void TEditText::InstallFloatingTEView(bool selectChars)
{
#if !qMSWindows

	// Install the TDialogTEView if it's not already installed.
	if (!fTEView)
	{
		TDialogTEView * aFloatingTEView = GetTEView();
		if (!aFloatingTEView)
		{
#if qDebug
			::ProgramBreak_AC("TEditText::InstallFloatingTEView: The acquired TEView is nil.");
#endif
		}
		aFloatingTEView->InstallEditText(this, selectChars);
		fTEView = aFloatingTEView;
	}

	if (fHilite)
		DeleteAdorner(&TAdorner::fgHiliteAdorner, kDontRedraw);
#else
	#pragma unused (selectChars)
#endif
}

//----------------------------------------------------------------------------------------
// TEditText::GetTEView: 
//----------------------------------------------------------------------------------------
	
TDialogTEView* TEditText::GetTEView()
{
	return AcquireFloatingTEView();	// Get it from the server
}

//----------------------------------------------------------------------------------------
// TEditText::ReleaseTEView: 
//----------------------------------------------------------------------------------------

void TEditText::ReleaseTEView()
{
	ReleaseFloatingTEView(fTEView);	// Return it to the server for reuse
	fTEView = NULL;
}

//----------------------------------------------------------------------------------------
// TEditText::RemoveFloatingTEView: 
//----------------------------------------------------------------------------------------

void TEditText::RemoveFloatingTEView()
{
#if !qMSWindows
	if (fTEView)
	{
		fTEView->InstallEditText(NULL, false);
		ReleaseTEView();
	}

	if (fHilite)
		AddAdorner(&TAdorner::fgHiliteAdorner, kAdornLast - 5, kDontRedraw);
#endif
}

//----------------------------------------------------------------------------------------
// TEditText::MakeVisible: 
//----------------------------------------------------------------------------------------

void TEditText::MakeVisible()
{
	CViewRect myExtent(GetExtent());
	myExtent.Inset(-10, -10);
	
	RevealRect(myExtent, myExtent.GetSize(), kVisible);
}

//----------------------------------------------------------------------------------------
// TEditText::RestartEdit: 
//----------------------------------------------------------------------------------------

void TEditText::RestartEdit(const CString_AC& restartText)
{
	if (fTEView && fTEView->Focus())			// First, attempt to focus the TEView 
	{
		ClipRect(gZeroRect);					// Prevent TE from mucking up the hilite with
												// a stinking insertion point

		fTEView->SetActive(false);				// Deactivate the selection 
		SetText(restartText, kDontRedraw);		// Set the text to previous value 
		SetSelection(0, SHRT_MAX, kDontRedraw);	// Select all characters 

		fTEView->SetActive(true);				// Activate the selection

		InvalidateFocus();						// Make sure we re-focus 
		fTEView->ForceRedraw();
	}
	else
		SetText(restartText, kDontRedraw);		// Just set the text if we can't focus 

#if qMSWindows
	#pragma unused (restartText)
	#pragma message("TEditText::RestartEdit: Implement.")
#endif
}

//----------------------------------------------------------------------------------------
// TEditText::SetJustification: 
//----------------------------------------------------------------------------------------

void TEditText::SetJustification(short theJust,
								 bool redraw)
{
#if qMSWindows
	DWORD windowStyle = GetWindowsWindowStyle();
	windowStyle &= ~(long)(ES_CENTER|ES_RIGHT|ES_LEFT);
	switch (theJust)
	{
		case teJustLeft:
		case teForceLeft:
 			windowStyle |= ES_LEFT;
			break;

		case teJustCenter:
			windowStyle |= ES_CENTER;
			break;

		default:
			windowStyle |= ES_RIGHT;
			break;
	}
	SetWindowsWindowStyle(windowStyle);
#else
	if (fTEView)
		fTEView->SetJustification(theJust, redraw);
#endif
	TStaticText::SetJustification(theJust, redraw);
}

//----------------------------------------------------------------------------------------
// TEditText::SetSelection: 
//----------------------------------------------------------------------------------------

void TEditText::SetSelection(short selStart, short selEnd, bool redraw)
{
	if (fTEView)
		fTEView->SetSelection(selStart, selEnd, redraw && (fTEView->IsDrawable()) );
}

//----------------------------------------------------------------------------------------
// TEditText::SetText: 
//----------------------------------------------------------------------------------------

void TEditText::SetText(const CString_AC& theText, bool redrawImmediately)
{
	CString_AC localText(theText);
	if (static_cast<long>(localText.size()) > fMaxChars)
	{
#if qDebug
		ProgramReport_AC("Truncating text to fMaxChars");
#endif
		localText.erase(fMaxChars);
	}

#if !qMSWindows
	if (fTEView)
	{
		if (GetText() != localText)
		{
			// Make sure fDataHandle's text is the same as that in fTEView
			fString = localText;

			fTEView->SetText(CStr255_AC(localText));
			fTEView->RecalcText();
			fTEView->SynchView(kDontRedraw);
			if (IsDrawable())
			{
				Invalidate(ControlQDArea());
				
				if (redrawImmediately)
					Update();
			}
		}
	}
	else
		TStaticText::SetText(localText, redrawImmediately);
#else
	HWND windowsWindow = GetWindowsWindow();
	if (windowsWindow)
	{
		//char text[256];
		//localText.CopyTo(text);
		SetWindowText(windowsWindow, localText.c_str());
	}

	TStaticText::SetText(localText, redrawImmediately);
#endif
}

//----------------------------------------------------------------------------------------
// TEditText::StartEdit: 
//----------------------------------------------------------------------------------------

void TEditText::StartEdit(bool selectChars)
{
	BecomeTarget();
	if (selectChars)
		SetTargetSelection(kRedraw);
}

//----------------------------------------------------------------------------------------
// TEditText::StopEdit: 
//----------------------------------------------------------------------------------------

void TEditText::StopEdit()
{
	if (fTEView)
	{
		fTEView->DoneTyping();
		
		fTEView->SetActive(false);				// Hides the selection
		CString_AC	aString(GetText());			// Must get the text before removing
												// the floating TEView 
		RemoveFloatingTEView();
		SetText(aString, kDontRedraw);
	}
#if qMSWindows
	#pragma message("TEditText::StopEdit: Implement.")
#endif
}

//----------------------------------------------------------------------------------------
// TEditText::GetValidationError: 
//----------------------------------------------------------------------------------------

long TEditText::GetValidationError()
{
#if qMSWindows
	#pragma message("TEditText::GetValidationError: Implement.")
#endif

	long validateResult = TStaticText::GetValidationError();
	
	if ((validateResult == kValidValue) && fTEView && (fTEView->GetNumberOfChars() > fMaxChars))
		validateResult = kTooManyCharacters;

	return validateResult;
}

//----------------------------------------------------------------------------------------
// TEditText::WantsToBeTarget: 
//----------------------------------------------------------------------------------------

bool TEditText::WantsToBeTarget()
{
	return fWantsToBeTarget && IsEnabled() && !(fTEView && fTEView->IsTarget());
}

//----------------------------------------------------------------------------------------
// TEditText::GetDefaultCursorRegion: 
//----------------------------------------------------------------------------------------

void TEditText::GetDefaultCursorRegion(const CViewPoint& localPoint,
									   RgnHandle cursorRegion)
{
	#pragma unused (localPoint)
	::RectRgn(cursorRegion, ControlQDArea());
}

#if qDrag

//----------------------------------------------------------------------------------------
// TEditText::DoMakeDragCursorRegion: 
//----------------------------------------------------------------------------------------

RgnHandle TEditText::DoMakeDragCursorRegion()
{
#if qMSWindows
	#pragma message("TEditText::DoMakeDragCursorRegion: Implement.")
#endif

	RgnHandle dragCursorRegion = NULL;
	
	if (fTEView)
		dragCursorRegion = fTEView->DoMakeDragCursorRegion();
	
	return dragCursorRegion;
}

//----------------------------------------------------------------------------------------
// TEditText::WillDrag: 
//----------------------------------------------------------------------------------------

bool TEditText::WillDrag(const CViewPoint& 	theMouse,
						 const RgnHandle	dragCursorRegion)
{
#if qMSWindows
	#pragma message("TEditText::WillDrag: Implement.")
#endif

	bool willDrag = false;
	
	if (fTEView)
	{
		bool savedDraggable = fTEView->GetDraggable();	// temporarily set the TEView's
		fTEView->SetDraggable(fDraggable);				// is draggable member.
		willDrag = fTEView->WillDrag(theMouse, dragCursorRegion);
		fTEView->SetDraggable(savedDraggable);
	}
		
	return willDrag;
}

//----------------------------------------------------------------------------------------
// TEditText::GetWillDragCursorID: 
//----------------------------------------------------------------------------------------

short TEditText::GetWillDragCursorID()
{
	return kNoResource;
}

//----------------------------------------------------------------------------------------
// TEditText::GetIsDraggingCursorID: 
//----------------------------------------------------------------------------------------

short TEditText::GetIsDraggingCursorID()
{
	return kNoResource;
}

//----------------------------------------------------------------------------------------
// TEditText::DoAddDragContent: 
//----------------------------------------------------------------------------------------

void TEditText::DoAddDragContent()
{
#if qMSWindows
	#pragma message("TEditText::DoAddDragContent: Implement.")
#endif

	if (fTEView)
		fTEView->DoAddDragContent();
}

//----------------------------------------------------------------------------------------
// TEditText::WillAcceptDrop: 
//----------------------------------------------------------------------------------------

bool TEditText::WillAcceptDrop(CDragItemIterator& dragItemIterator)
{
#if qMSWindows
	#pragma message("TEditText::WillAcceptDrop: Implement.")
#endif

	bool	acceptsDrops = false;
	InstallFloatingTEView(false);

	if (fTEView)
		acceptsDrops = fTEView->WillAcceptDrop(dragItemIterator);

	return acceptsDrops;
}

//----------------------------------------------------------------------------------------
// TEditText::DoMakeDragTracker:
//----------------------------------------------------------------------------------------

TDragTracker* TEditText::DoMakeDragTracker(CommandNumber itsCommandNumber,
										   const CViewPoint& itsMouse,
										   const TToolboxEvent* event)
{
	InstallFloatingTEView(false);	 // get a TDialogTEView
	if (fTEView)
	{
		fTEView->Focus();
		return TH_new TTEDragTracker(itsCommandNumber, fTEView, this, itsMouse, event);
	}
	else
		return NULL;
}

//----------------------------------------------------------------------------------------
// TEditText::DoMakeDropHiliteRegion: 
//----------------------------------------------------------------------------------------

RgnHandle TEditText::DoMakeDropHiliteRegion()
{
	RgnHandle dropRegion = NULL;
	// Will be focused on the TEView.
	// Focus on the EditText to create the correct drop hilite
	Focus();
	dropRegion = TStaticText::DoMakeDropHiliteRegion();
	InsetRgn(dropRegion, 1, 1);		// inset by one pixel to compensate for the border

	return dropRegion;	
}

#endif // qDrag

//----------------------------------------------------------------------------------------
// TEditText::SetMaxLength: 
//----------------------------------------------------------------------------------------

void TEditText::SetMaxLength(short newMaxLength)
{
	fMaxChars = newMaxLength;
	
	// If we have an attached TTEView then set its max, too.
	if (fTEView)
		fTEView->SetMaxLength(static_cast<unsigned short>(newMaxLength));
}

#if qMSWindows

//----------------------------------------------------------------------------------------
// TEditText::SetWindowsWindow: 
//----------------------------------------------------------------------------------------

void TEditText::SetWindowsWindow(HWND windowsWindow)
{
	CString_AC text = TStaticText::GetText();
	TStaticText::SetWindowsWindow(windowsWindow);
	SetText(text, kRedraw);
}

//----------------------------------------------------------------------------------------
// TEditText::HandleWindowsEvent: 
//----------------------------------------------------------------------------------------

long TEditText::HandleWindowsEvent(HWND hwnd, UINT message, WPARAM wParam, LPARAM lParam)
{
	long result = 0;
	switch (message)
	{
		case WM_PAINT:
		case WM_LBUTTONDOWN:
			result = DefaultWindowProcedure(hwnd, message, wParam, lParam);
			break;

		default:
			result = TStaticText::HandleWindowsEvent(hwnd, message, wParam, lParam);
			break;
	}
	return result;
}

#endif

//----------------------------------------------------------------------------------------
// End of UEditText.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/25/96	[1345531] Added missing (6!) includes for noload buids
		06/21/96	[1117870] (2-BYTE) TTEView and Left&Right Arrow
							[1115111] (2-BYTE) TTEView::GetNumberOfChars returns 0 after 1 character has been typed
							[1353017] (Double-byte) Second Character Lost
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/15/96	In TEditText::MakeVisible when calling RevealRect just pass the
							ViewSpace point for minToSee
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----

*/