//----------------------------------------------------------------------------------------
// UBackgroundAdorner.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/09/00	[PB] Suppress GCC warnings about unused return variables. 
		10/16/00	Do not draw adorner in DoHighlightSelections if Focus fails.
		09/19/00	CGDIterator not used.  Removed duplicated code.
		09/08/00	Call SetBackgroundTheme in TFlatBackgroundAdorner::DoPostCreate and
					TBackgroundAdorner::AddedToView.
		09/01/00	Stripped dead code.  Eliminated Inherited.  Added pragma unused's
					and made other cosmetic changes.
		12/21/99	Use kThemeStateInactive instead of kThemeStateDisabled (kThemeStateDisabled
					is obsolete). 
		08/09/99	Changed MA_REGISTER_CLASS to REGISTER_CLASS_AC.
		07/26/99	Optimize background drawing in DrawBackground.
		03/24/99	Update copyright notice.
		03/23/99	Replace ...Rect_AC calls with standard Toolbox rect calls.
		03/22/99	[W] SetThemeWindowBackground not available.
		10/29/98	[W] Use kThemeStateDisabled instead of kThemeStateInactive. 
		10/28/98	Use InsetRect_AC instead of InsetRect.  Include ImagingUtils_AC.h.
*/

#ifndef __UBACKGROUNDADORNER__
#include "UBackgroundAdorner.h"
#endif

// MacApp

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

//----------------------------------------------------------------------------------------
// InitUBackgroundAdorner:
// Register all of the classes defined here. If you prefer, you can
// selectively register just the classes you will use.
//----------------------------------------------------------------------------------------

void InitUBackgroundAdorner()
{
	REGISTER_CLASS_AC(TBackgroundAdorner);
	REGISTER_CLASS_AC(TModalBackgroundAdorner);
	REGISTER_CLASS_AC(TFlatBackgroundBehavior);
	REGISTER_CLASS_AC(TWhiteBackgroundAdorner);
	REGISTER_CLASS_AC(TNotchedWhiteBackgroundAdorner);
	REGISTER_CLASS_AC(TBorderFrameAdorner);
	REGISTER_CLASS_AC(TNotchedBorderFrameAdorner);
}

//========================================================================================
// CLASS TBackgroundAdorner
//========================================================================================

MA_DEFINE_CLASS(TBackgroundAdorner);

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::TBackgroundAdorner:
//----------------------------------------------------------------------------------------

TBackgroundAdorner::TBackgroundAdorner()
	:	TAdorner( kBackgroundAdorner, true, false),
		fBackgroundKind(kRaisedModelessBackground)
{
}

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::TBackgroundAdorner:
//----------------------------------------------------------------------------------------

TBackgroundAdorner::TBackgroundAdorner(IDType itsID,
									   bool freeOnDeletion,
									   bool isOpaque,
									   AGABackgroundKind kind)
	:	TAdorner( itsID, freeOnDeletion, isOpaque ),
		fBackgroundKind(kind)
{
}

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::~TBackgroundAdorner:
//----------------------------------------------------------------------------------------

TBackgroundAdorner::~TBackgroundAdorner()
{
}

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::DoHighlightSelection: Draw in the specified active/inactive state.
//----------------------------------------------------------------------------------------

void TBackgroundAdorner::DoHighlightSelection(TView*			itsView,
											  const CViewRect&	area,
											  HLState			fromHL,
											  HLState			toHL)
{
	#pragma unused (fromHL)

	DrawBackground(itsView, area, false, (toHL == hlOn));
}

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::Draw: Draw in active state.
//----------------------------------------------------------------------------------------

void TBackgroundAdorner::Draw(TView* itsView, const CViewRect& area)
{
	DrawBackground(itsView, area, true, itsView->IsActive());
}

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::ViewChangedFrame:
//----------------------------------------------------------------------------------------

void TBackgroundAdorner::ViewChangedFrame(TView*			itsView,
										  const CViewRect&	oldFrame,
										  const CViewRect&	newFrame,
										  bool				invalidate)
{
	#pragma unused (invalidate)

	// Make sure we invalidate the edges that will need to be
	// redrawn with the background edge pixel color.
	// Note that oldFrame & newFrame are in global coordinates.

	CViewRect	rectToInvalidate;
	CViewPoint	sizeDelta(newFrame.GetLength(hSel) - oldFrame.GetLength(hSel),
					newFrame.GetLength(vSel) - oldFrame.GetLength(vSel));
	
	if (sizeDelta.h != 0)
	{
		if (sizeDelta.h > 0)
			rectToInvalidate = oldFrame;
		else	// sizeDelta.h < 0
			rectToInvalidate = newFrame;

		rectToInvalidate.left = rectToInvalidate.right - 1;
		itsView->Invalidate(itsView->SuperViewToLocal(rectToInvalidate));
	}
	
	if (sizeDelta.v != 0)
	{
		if (sizeDelta.v > 0)
			rectToInvalidate = oldFrame;
		else	// sizeDelta.v < 0
			rectToInvalidate = newFrame;

		rectToInvalidate.top = rectToInvalidate.bottom - 1;
		itsView->Invalidate(itsView->SuperViewToLocal(rectToInvalidate));
	}
	
	if (HasGrowBox(itsView) && (sizeDelta != gZeroVPt))
	{
		rectToInvalidate = oldFrame;
		rectToInvalidate.left = rectToInvalidate.right - 16;
		rectToInvalidate.top = rectToInvalidate.bottom - 16;
		itsView->Invalidate(itsView->SuperViewToLocal(rectToInvalidate));

		rectToInvalidate = newFrame;
		rectToInvalidate.left = rectToInvalidate.right - 16;
		rectToInvalidate.top = rectToInvalidate.bottom - 16;
		itsView->Invalidate(itsView->SuperViewToLocal(rectToInvalidate));
	}
}

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::AddedToView:
//----------------------------------------------------------------------------------------

void TBackgroundAdorner::AddedToView(TView* itsView)
{
	// Install the background color if we're in a window.

	TWindow*	itsWindow = itsView->GetWindow();

	if (itsWindow != NULL)
	{
#if !qMSWindows
		if (HasAppearanceMgr_AC())
			itsWindow->SetBackgroundTheme(kThemeActiveModelessDialogBackgroundBrush);
		else
#endif
			::ThrowIfOSErr_AC(AGAInstallGrayWCTB(itsWindow->GetWindowRef()));
	}
	// Set the current bg color of the view's port so that any of our
	// AGA adapter views that get instantiated will pick it up.

	//if (itsView->Focus())
	//	kRGBColorRamp[r2].SetBackColor();
}

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::DrawBackground:
//----------------------------------------------------------------------------------------

void TBackgroundAdorner::DrawBackground(TView* itsView, const CViewRect& area,
										bool fill, bool active)
{
	#pragma unused (area)
	
	if (!HasAppearanceMgr_AC())
		AGABackgroundPaint(itsView->GetQDExtent(), fill, fBackgroundKind, active, HasGrowBox(itsView));
	else if (fBackgroundKind == kRaisedModelessBackground)
	{
		CRect_AC frame = itsView->GetQDExtent();
		frame.Inset(-1, -1);
		OSStatus err = ::DrawThemeModelessDialogFrame(frame, active ? kThemeStateActive : kThemeStateInactive);
#if qProjectBuilder
		(void) err;
#endif
	}
}

//----------------------------------------------------------------------------------------
// TBackgroundAdorner::HasGrowBox:
//----------------------------------------------------------------------------------------

bool TBackgroundAdorner::HasGrowBox(TView* itsView)
{
	return dynamic_cast_AC(TWindow*,itsView)
		? dynamic_cast_AC(TWindow*,itsView)->GetIsResizable()
		: false;
}

//========================================================================================
// CLASS TModalBackgroundAdorner
//========================================================================================

MA_DEFINE_CLASS(TModalBackgroundAdorner);

//----------------------------------------------------------------------------------------
// TModalBackgroundAdorner::TModalBackgroundAdorner:
//----------------------------------------------------------------------------------------

TModalBackgroundAdorner::TModalBackgroundAdorner()
	:	TBackgroundAdorner( kModalBackgroundAdorner, true, false,
							kFlatWindowBackground )
{
}

//----------------------------------------------------------------------------------------
// TModalBackgroundAdorner::~TModalBackgroundAdorner:
//----------------------------------------------------------------------------------------

TModalBackgroundAdorner::~TModalBackgroundAdorner()
{
}

//========================================================================================
// CLASS TFlatBackgroundBehavior
//========================================================================================

MA_DEFINE_CLASS(TFlatBackgroundBehavior);

//----------------------------------------------------------------------------------------
// TFlatBackgroundBehavior::TFlatBackgroundBehavior:
//----------------------------------------------------------------------------------------

TFlatBackgroundBehavior::TFlatBackgroundBehavior()
{
}

//----------------------------------------------------------------------------------------
// TFlatBackgroundBehavior::~TFlatBackgroundBehavior:
//----------------------------------------------------------------------------------------

TFlatBackgroundBehavior::~TFlatBackgroundBehavior()
{
}

//----------------------------------------------------------------------------------------
// TFlatBackgroundBehavior::DoPostCreate:
//----------------------------------------------------------------------------------------

void TFlatBackgroundBehavior::DoPostCreate(TDocument* itsDocument)
{
	// Install the background color if we're in a window.

	TBehavior::DoPostCreate(itsDocument);
	
	TWindow*	itsWindow = (dynamic_cast_or_throw_AC(TView*, fOwner))->GetWindow();
	
	if (itsWindow != NULL)
	{
#if !qMSWindows
		if (HasAppearanceMgr_AC())
			itsWindow->SetBackgroundTheme(kThemeActiveModelessDialogBackgroundBrush);
		else
#endif
			::ThrowIfOSErr_AC(AGAInstallGrayWCTB(itsWindow->GetWindowRef()));
	}
}

//========================================================================================
// CLASS TWhiteBackgroundAdorner
//========================================================================================

MA_DEFINE_CLASS(TWhiteBackgroundAdorner);

//----------------------------------------------------------------------------------------
// TWhiteBackgroundAdorner::TWhiteBackgroundAdorner:
//----------------------------------------------------------------------------------------

TWhiteBackgroundAdorner::TWhiteBackgroundAdorner()
	:	TAdorner( kWhiteBackgroundAdorner, true, true )
{
}

//----------------------------------------------------------------------------------------
// TWhiteBackgroundAdorner::~TWhiteBackgroundAdorner:
//----------------------------------------------------------------------------------------

TWhiteBackgroundAdorner::~TWhiteBackgroundAdorner()
{
}

//----------------------------------------------------------------------------------------
// TWhiteBackgroundAdorner::AddedToView:
//----------------------------------------------------------------------------------------

void TWhiteBackgroundAdorner::AddedToView(TView* itsView)
{
	TDrawingEnvironment* drawingEnvironment = itsView->DoMakeNewDrawingEnvironment();
	drawingEnvironment->fForegroundColor = kRGBColorRamp[rB];
	drawingEnvironment->fBackgroundColor = kRGBColorRamp[rW];
	
	itsView->SetDrawingEnvironment(drawingEnvironment, kDontInvalidate);
}

//----------------------------------------------------------------------------------------
// TWhiteBackgroundAdorner::RemovedFromView:
//----------------------------------------------------------------------------------------

void TWhiteBackgroundAdorner::RemovedFromView(TView* itsView)
{
	itsView->SetDrawingEnvironment(NULL, kDontInvalidate);
}

//----------------------------------------------------------------------------------------
// TWhiteBackgroundAdorner::Draw:
//----------------------------------------------------------------------------------------
void TWhiteBackgroundAdorner::Draw(TView* itsView, const CViewRect& area)
{
	#pragma unused (area)

	// Draw the background in white, inset to avoid the border
	// frame pixels.

	CRect_AC	qdArea(itsView->GetQDExtent());
	
	::MacInsetRect(qdArea, 2, 2);
	::EraseRect(qdArea);
}

//========================================================================================
// CLASS TNotchedWhiteBackgroundAdorner
//========================================================================================

MA_DEFINE_CLASS(TNotchedWhiteBackgroundAdorner);

//----------------------------------------------------------------------------------------
// TNotchedWhiteBackgroundAdorner::TNotchedWhiteBackgroundAdorner:
//----------------------------------------------------------------------------------------

TNotchedWhiteBackgroundAdorner::TNotchedWhiteBackgroundAdorner()
	:	TAdorner( kNotchedWhiteBackgroundAdorner, true, true )
{
}

//----------------------------------------------------------------------------------------
// TNotchedWhiteBackgroundAdorner::~TNotchedWhiteBackgroundAdorner:
//----------------------------------------------------------------------------------------

TNotchedWhiteBackgroundAdorner::~TNotchedWhiteBackgroundAdorner()
{
}

//----------------------------------------------------------------------------------------
// TNotchedWhiteBackgroundAdorner::Draw
//----------------------------------------------------------------------------------------

void TNotchedWhiteBackgroundAdorner::Draw(TView* itsView, const CViewRect& area)
{
	#pragma unused (area)

	// Draw the background in white, inset to avoid the border
	// frame pixels.

	CRect_AC	qdArea(itsView->GetQDExtent());
	
	kRGBColorRamp[rW].SetForeColor();
	::MacInsetRect(qdArea, 2, 2);

	qdArea.right -= 15;
	::PaintRect(qdArea);
	qdArea.right += 15;
	
	qdArea.bottom -= 15;
	::PaintRect(qdArea);

	kRGBColorRamp[rB].SetForeColor();
}

//========================================================================================
// CLASS TBorderFrameAdorner
//========================================================================================

MA_DEFINE_CLASS(TBorderFrameAdorner);

//----------------------------------------------------------------------------------------
// TBorderFrameAdorner::TBorderFrameAdorner:
//----------------------------------------------------------------------------------------

TBorderFrameAdorner::TBorderFrameAdorner()
	:	TAdorner( kBorderFrameAdorner, true, false )
{
}

//----------------------------------------------------------------------------------------
// TBorderFrameAdorner::~TBorderFrameAdorner:
//----------------------------------------------------------------------------------------

TBorderFrameAdorner::~TBorderFrameAdorner()
{
}

//----------------------------------------------------------------------------------------
// TBorderFrameAdorner::DoHighlightSelection:
//----------------------------------------------------------------------------------------

void TBorderFrameAdorner::DoHighlightSelection( TView*				itsView,
												const CViewRect&	area,
												HLState				fromHL,
												HLState				toHL)
{
	#pragma unused (area, fromHL)

	// Draw in the specified active/inactive state.
	// If we fail to focus then don't draw the adorner since it will
	// likely draw in the wrong place.
	if (itsView->Focus())
		AGADrawThemeEditTextFrame(itsView->GetQDExtent(), (toHL == hlOn) && itsView->IsActive() ? kThemeStateActive : kThemeStateInactive);

	kRGBColorRamp[rB].SetForeColor();
	kRGBColorRamp[rW].SetBackColor();
}

//----------------------------------------------------------------------------------------
// TBorderFrameAdorner::Draw:
//----------------------------------------------------------------------------------------

void TBorderFrameAdorner::Draw(TView* itsView, const CViewRect& area)
{
	#pragma unused (area)

	// Draw the frame with shading outside.
	AGADrawThemeEditTextFrame(itsView->GetQDExtent(), itsView->IsActive() ? kThemeStateActive : kThemeStateInactive);

	kRGBColorRamp[rB].SetForeColor();
	kRGBColorRamp[rW].SetBackColor();
}

//========================================================================================
// CLASS TNotchedBorderFrameAdorner
//========================================================================================

MA_DEFINE_CLASS(TNotchedBorderFrameAdorner);

//----------------------------------------------------------------------------------------
// TNotchedBorderFrameAdorner::TNotchedBorderFrameAdorner:
//----------------------------------------------------------------------------------------

TNotchedBorderFrameAdorner::TNotchedBorderFrameAdorner()
	:	TAdorner( kNotchedBorderAdorner, true, false )
{
}

//----------------------------------------------------------------------------------------
// TNotchedBorderFrameAdorner::~TNotchedBorderFrameAdorner:
//----------------------------------------------------------------------------------------

TNotchedBorderFrameAdorner::~TNotchedBorderFrameAdorner()
{
}

//----------------------------------------------------------------------------------------
// TNotchedBorderFrameAdorner::DoHighlightSelection:
//----------------------------------------------------------------------------------------

void TNotchedBorderFrameAdorner::DoHighlightSelection(TView*			itsView,
													  const CViewRect&	area,
													  HLState			fromHL,
													  HLState			toHL)
{
	#pragma unused (area, fromHL)

	// Draw in the specified active/inactive state.
	// Do not draw the adornment if Focus fails since it may get
	// drawn in the wrong place.
	if (itsView->Focus())
		AGADrawBorderFrame(itsView->GetQDExtent(), (toHL == hlOn) && itsView->IsEnabled(), true /*isNotched*/, true /*drawFrame*/, kRGBColorRamp[r2]);
	
	kRGBColorRamp[rB].SetForeColor();
	kRGBColorRamp[rW].SetBackColor();
}

//----------------------------------------------------------------------------------------
// TNotchedBorderFrameAdorner::Draw:
//----------------------------------------------------------------------------------------

void TNotchedBorderFrameAdorner::Draw(TView* itsView, const CViewRect& area)
{
	#pragma unused (area)

	// Draw the frame with shading outside.
	AGADrawBorderFrame(itsView->GetQDExtent(), itsView->IsEnabled() && itsView->IsActive(), true /*isNotched*/, true /*drawFrame*/, kRGBColorRamp[r2]);
	
	kRGBColorRamp[rB].SetForeColor();
	kRGBColorRamp[rW].SetBackColor();
}

//----------------------------------------------------------------------------------------
// End of UBackgroundAdorner.cpp
