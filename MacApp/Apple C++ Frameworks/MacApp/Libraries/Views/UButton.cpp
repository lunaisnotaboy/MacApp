//----------------------------------------------------------------------------------------
// UButton.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		09/21/00	Override InvalidateCoordinates. On Carbon, default buttons
					need to update their locations immediately. 
					Add convenience functions SupportsDefaultOutline and IsDefault. 
		07/31/00	Removed Inherited.  [W] SetWindowsWindowStyle in TButton
					ctor.  Added GetWindowsClassName and HandleWindowsEvent.
					Added DoPostCreate.
		06/21/00	Remove unnecessary GetRegion calls.
		12/08/99	Added assertion in SetDefaultOutline.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __UBUTTON__
#include "UButton.h"
#endif

// ACS

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#if qEmulateStandardControls
#	ifndef __CButton_AC__
#	include "CButton_AC.h"
#	endif
#endif // qEmulateStandardControls

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

// MacApp

#ifndef __UCONTROL__
#include "UControl.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

// Toolbox

#ifndef __APPEARANCE__
#include <Appearance.h>
#endif

void InitUButton()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TButton, kStdButton);
	}
}  

#if qAppearance
void InitUIconPushButton()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TIconPushButton, kStdIconPushButton);
	}
}  
#endif

//========================================================================================
// CLASS TButton
//========================================================================================

MA_DEFINE_CLASS(TButton);

//----------------------------------------------------------------------------------------
// TButton constructor
//----------------------------------------------------------------------------------------

TButton::TButton(const CViewPoint& itsLocation,
					  const CViewPoint& itsSize,
					  SizeDeterminer itsHSizeDet,
					  SizeDeterminer itsVSizeDet,
					  const CStr255_AC& itsLabel,
					  bool isDefault) :
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsLabel),

	fStrListID(kNoResource),					// buttons's label:	STR# rsrc id
	fIndex(kNoResource)							//					index into STR#
{
#if qMSWindows
	SetWindowsWindowStyle(WS_CHILD | BS_PUSHBUTTON | WS_TABSTOP);
#endif

	fEventNumber = mButtonHit;
	
	SetDefaultState(isDefault, kDontRedraw); // virtual call 
}

//----------------------------------------------------------------------------------------
// TButton copy constructor
//----------------------------------------------------------------------------------------

TButton::TButton(const TButton& inButton) :
	TCtlMgr(inButton),
	fStrListID(inButton.fStrListID),
	fIndex(inButton.fIndex)
{	
}

//----------------------------------------------------------------------------------------
// TButton destructor
//----------------------------------------------------------------------------------------

TButton::~TButton()
{
}

//----------------------------------------------------------------------------------------
// TButton::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TButton::GetStandardSignature() const
{
	return kStdButton;
}

//----------------------------------------------------------------------------------------
// TButton::ReadFields: 
//----------------------------------------------------------------------------------------

void TButton::ReadFields(CStream_AC* aStream)
{
	TCtlMgr::ReadFields(aStream);

	*aStream >> fStrListID
			 >> fIndex;
			 
	// retrieve the buttons's label from the resource
	SetText(CStr255_AC(fStrListID, fIndex), kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TButton::WriteFields: 
//----------------------------------------------------------------------------------------

void TButton::WriteFields(CStream_AC* aStream) const
{
	TCtlMgr::WriteFields(aStream);

	*aStream << fStrListID
			 << fIndex;
}

//----------------------------------------------------------------------------------------
// TButton::DoEvent: 
//----------------------------------------------------------------------------------------

void TButton::DoEvent(EventNumber eventNumber,
					  TEventHandler* source,
					  TEvent* event)

{
	if ((eventNumber == GetEventNumber()) && (source != this) && IsEnabled())
	{
		if (!IsDimmed())						// if dimmed, do absolutely nothing.
		{
			Flash();
			TCtlMgr::DoEvent(eventNumber, this, event);
		}
	}
	else
		TCtlMgr::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TButton::FindRRectAdorner: 
//----------------------------------------------------------------------------------------

void TButton::CreateControl()
{
	TCtlMgr::CreateControl();
	SetDefaultOutline();
}

//----------------------------------------------------------------------------------------
// TButton::FindRRectAdorner: 
//----------------------------------------------------------------------------------------

TAdorner* TButton::FindRRectAdorner()
{
	// Return the TRRectAdorner, if any, that is attached to
	// this push button.

	TAdorner*	foundAdorner = NULL;

	if (!fAdorners.IsNULL())
	{
		CAdornerIterator	iter(this);

		for (TAdorner* theAdorner = iter.First(); iter.Current(); theAdorner = iter.Next())
		{
			if (dynamic_cast_AC(TRRectAdorner*,theAdorner))
				foundAdorner = theAdorner;
			else if (dynamic_cast_AC(TCompatibilityAdorner*,theAdorner))
			{
				TCompatibilityAdorner* theCompatibilityAdorner = dynamic_cast_or_throw_AC(TCompatibilityAdorner*,theAdorner);
				if (macroIn(theCompatibilityAdorner->fAdornment, adnRRect))
					foundAdorner = theAdorner;
			}
		}
	}

	return foundAdorner;
}

//----------------------------------------------------------------------------------------
// TButton::SupportsDefaultOutline: 
//----------------------------------------------------------------------------------------

bool TButton::SupportsDefaultOutline()
{
	return
#if qEmulateStandardControls
			EmulateControls_AC() ||
#endif // qEmulateStandardControls
			::HasAppearanceMgr_AC();
}

//----------------------------------------------------------------------------------------
// TButton::IsDefault: 
//----------------------------------------------------------------------------------------

bool TButton::IsDefault()
{
	bool isDefault = false;

	if (GetControl() && SupportsDefaultOutline())
	{
		isDefault = GetControl()->GetPushButtonDefault();
	}
	else
	{
		isDefault = (FindRRectAdorner() != NULL);
	}
	
	return isDefault;
}

//----------------------------------------------------------------------------------------
// TButton::SetDefaultOutline: 
//----------------------------------------------------------------------------------------

void TButton::SetDefaultOutline()
{
	// MacApp view editors and SetDefaultState indicate a default button using the TRRectAdorner 
	// to outline the button and by specifying an inset.
	// For controls that support drawing the outline themselves,
	// we check for the presence of the TRRectAdorner by std ID, tossing it, and
	// telling the control that it is a default button.
	
	if (SupportsDefaultOutline())
	{
		TAdorner*	rrectAdorner = FindRRectAdorner();
		if (rrectAdorner != NULL)
		{
			DeleteAdorner(rrectAdorner, kDontInvalidate);
			
			CWhileFocused itsWhileFocused(this, kDontRedraw);
			Assertion_AC(GetControl(), "TButton::SetDefaultOutline: Could not get control ref.");
			GetControl()->SetPushButtonDefault(true);
		}
	}
}

//----------------------------------------------------------------------------------------
// TButton::SetDefault: 
//----------------------------------------------------------------------------------------

void TButton::SetDefaultState(bool isDefault, bool redraw)
{
	// This only sets the default if the control exists.  If the control doesn't exist yet,
	// then it creates or deletes a round rect adorner.
	if (GetControl() && SupportsDefaultOutline())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetPushButtonDefault(isDefault);
	}
	else
	{
		// Either we don't have a control yet or it doesn't support drawing a default outline,
		// so we use a round rect adorner to indicate a default button.
		if (isDefault)
		{
			// Default buttons have a round rect adorner of size 3, 3.
			// This class determines the default state according to whether it has an adorner of this kind.
			// Once the control has been created, use SetDefaultOutline to change the default state.
			
			SetPenSize(CPoint_AC(3, 3));
			SetAdornment(adnRRect, kDontRedraw);
			Inset(CViewPoint(4, 4), kDontRedraw);
		}
		else
		{
			SetPenSize(CPoint_AC(1, 1));
			TAdorner*	rrectAdorner = FindRRectAdorner();
			if (rrectAdorner != NULL)
				DeleteAdorner(rrectAdorner, kDontInvalidate);
		}
	}
}

#if qCarbon
//----------------------------------------------------------------------------------------
// TButton::InvalidateCoordinates:
//----------------------------------------------------------------------------------------

void TButton::InvalidateCoordinates()
{
	TCtlMgr::InvalidateCoordinates();

	CControl_AC* control = GetControl();
	if (control && control->IsVisible() && IsDefault())
	{
		UpdateCoordinates();
		//control->SetVisibility(false);
		control->SetLocation(ControlQDArea()[topLeft]);
		//control->SetVisibility(true);
	}
}
#endif // qCarbon


//----------------------------------------------------------------------------------------
// TButton::DoMakeControl:
//----------------------------------------------------------------------------------------

CControl_AC* TButton::DoMakeControl(WindowRef theWindow, 
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& itsTitle)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CButton_AC(boundsRect, isEnabled, itsTitle, fTextStyle);
	else
#endif // qEmulateStandardControls
		return CreateButton_AC(theWindow, boundsRect, itsTitle, isVisible, isEnabled);
}

//----------------------------------------------------------------------------------------
// TButton::DoPostCreate:
//----------------------------------------------------------------------------------------

void TButton::DoPostCreate(TDocument* itsDocument)
// DoPostCreate will do some creative frame arranging if we are running on Windows
// since there is no highlight rect for default buttons.
//
// itsDocument:		A TDocument* representing the document into which this button
//					is being installed.
//
// Override:		As needed.
// Call:			Only as the inherited DoPostCreate when implementing a custom
//					class deriving from TButton and which has its own DoPostCreate.
{
	TCtlMgr::DoPostCreate(itsDocument);

#if qMSWindows
	// if this is the default button, adjust the inset and the bounds so the
	// button looks right since Windows doesn't want the round rect frame
	bool	isDefault = (FindRRectAdorner() != NULL);

	if (fInset != CViewRect(0,0,0,0))
	{
		fLocation += fInset[topLeft];
		fSize -= fInset[botRight];
		fInset = CViewRect(0,0,0,0);
		SetWindowsWindowStyle(WS_CHILD | BS_DEFPUSHBUTTON | WS_TABSTOP);
	}
	else
		SetWindowsWindowStyle(WS_CHILD | BS_PUSHBUTTON | WS_TABSTOP);
#endif
}

#if qMSWindows

//----------------------------------------------------------------------------------------
// TButton::DoPostCreate:
//----------------------------------------------------------------------------------------

long TButton::HandleWindowsEvent(HWND hwnd, UINT message, WPARAM wParam, LPARAM lParam)
{
	long result = 0;
	switch (message)
	{
    	// Let the controls handle drawing and scrolling themselves.
		case WM_LBUTTONDOWN:
			result = DefaultWindowProcedure(hwnd, message, wParam, lParam);
			break;

		default:
			result = TCtlMgr::HandleWindowsEvent(hwnd, message, wParam, lParam);
			break;
	}
	return result;
}

#endif

#if qAppearance

//========================================================================================
// CLASS TIconPushButton
//========================================================================================

MA_DEFINE_CLASS(TIconPushButton);

//----------------------------------------------------------------------------------------
// TIconPushButton Constructor:
//----------------------------------------------------------------------------------------

TIconPushButton::TIconPushButton(const CViewPoint& itsLocation,
								const CViewPoint& itsSize,
								SizeDeterminer itsHSizeDet,
								SizeDeterminer itsVSizeDet,
								const CStr255_AC& itsTitle,
								bool isDefault,
								ResNumber itsIconID,
								bool positionLeftOfLabel) :
	TButton(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTitle, isDefault),
	fIconID(itsIconID),
	fPositionLeftOfLabel(positionLeftOfLabel)
{
}

//----------------------------------------------------------------------------------------
// TIconPushButton Copy Constructor:
//----------------------------------------------------------------------------------------

TIconPushButton::TIconPushButton(const TIconPushButton& inButton) :
	TButton(inButton),
	fIconID(inButton.fIconID),
	fPositionLeftOfLabel(inButton.fPositionLeftOfLabel)
{
}

//----------------------------------------------------------------------------------------
// TIconPushButton Destructor:
//----------------------------------------------------------------------------------------
TIconPushButton::~TIconPushButton()
{
}
		
//----------------------------------------------------------------------------------------
// TIconPushButton::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TIconPushButton::GetStandardSignature() const
{
	return kStdIconPushButton;
}

//----------------------------------------------------------------------------------------
// TIconPushButton::ReadFields:
//----------------------------------------------------------------------------------------

void TIconPushButton::ReadFields(CStream_AC* aStream)
{
	TButton::ReadFields(aStream);
	
	*aStream 	>> fIconID
				>> fPositionLeftOfLabel;
}
	
//----------------------------------------------------------------------------------------
// TIconPushButton :
//----------------------------------------------------------------------------------------

void TIconPushButton::WriteFields(CStream_AC* aStream) const
{
	TButton::WriteFields(aStream);
	
	*aStream 	<< fIconID
				<< fPositionLeftOfLabel;
}

//----------------------------------------------------------------------------------------
// TIconPushButton::DoMakeControl:
//----------------------------------------------------------------------------------------

CControl_AC* TIconPushButton::DoMakeControl(WindowRef theWindow,
										const CRect_AC& boundsRect, 
										bool isVisible, bool isEnabled, 
										const CStr255_AC& itsTitle)
{
	return CreateIconPushButton_AC(theWindow, boundsRect, itsTitle, isVisible, isEnabled, 
								fIconID, fPositionLeftOfLabel);
}

#endif // qAppearance

//----------------------------------------------------------------------------------------
// End of UButton.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added #include "UStream.h" for noload buids
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitUButton
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
		03/27/96	Switch last remaining Str255s to CStr255s_AC
		03/26/96	Cleanup references to gEmptyString
		03/26/96	CStr255_AC doesn't need to be set to empty.
		03/18/96	Remove compatibility hacks.
		03/11/96	Moved TIcon, TIconSuite and TSmallIcon to UDialog.more.cp
							from UDialog.cp to better balance the quantity of object code in each
		12/08/95	Don't need to include UApplication. 
		----- 3.3 -----
		----- 3.3b1 -----
		03/22/95	Add compatibility hacks for 2.0f1 headers. 
		03/13/95	Change Free methods to destructors. 
*/