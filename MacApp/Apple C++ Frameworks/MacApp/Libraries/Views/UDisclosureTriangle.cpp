//----------------------------------------------------------------------------------------
// UDisclosureTriangle.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __UDISCLOSURETRIANGLE__
#include "UDisclosureTriangle.h"
#endif

#if qAppearance || qEmulateStandardControls

// MacApp

#ifndef __USTREAM__
#include "UStream.h"
#endif

// ACS

#if qEmulateStandardControls

	#ifndef __CDisclosureTriangle_AC__
	#include "CDisclosureTriangle_AC.h"
	#endif

	#ifndef __AGA_AC__
	#include "AGA_AC.h"
	#endif

#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

//========================================================================================
// GLOBAL Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUDisclosureTriangle
//----------------------------------------------------------------------------------------

void InitUDisclosureTriangle()
{
	static bool UDisclosureTrangleInitialized = false;
	if (!UDisclosureTrangleInitialized)
	{
		UDisclosureTrangleInitialized = true;
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TDisclosureTriangle, kStdDisclosureTriangle);
		}
	}
	
}

//----------------------------------------------------------------------------------------
// InitULeftFacingDisclosureTriangle
//----------------------------------------------------------------------------------------

void InitULeftFacingDisclosureTriangle()
{
	static bool ULeftFacingDisclosureTrangleInitialized = false;
	if (!ULeftFacingDisclosureTrangleInitialized)
	{
		ULeftFacingDisclosureTrangleInitialized = true;
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TLeftFacingDisclosureTriangle, kStdLeftFacingDisclosureTriangle);
		}
	}
	
}

//========================================================================================
// CLASS TDisclosureTriangle
//========================================================================================

#undef Inherited
#define Inherited TCtlMgr

MA_DEFINE_CLASS(TDisclosureTriangle);

//----------------------------------------------------------------------------------------
// TDisclosureTriangle constructor
//----------------------------------------------------------------------------------------

TDisclosureTriangle::TDisclosureTriangle(const CViewPoint& itsLocation,
										 const CViewPoint& itsSize,
										 SizeDeterminer itsHSizeDet,
										 SizeDeterminer itsVSizeDet,
										 bool isDisclosed) :
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, gEmptyString),
	
	fInitialDisclosed(isDisclosed)
{
	// For procedural post-initialization, call HandlePostCreate.
}

//----------------------------------------------------------------------------------------
// TDisclosureTriangle copy constructor
//----------------------------------------------------------------------------------------

TDisclosureTriangle::TDisclosureTriangle(const TDisclosureTriangle& inDisclosureTriangle) :
	TCtlMgr(inDisclosureTriangle),
	
	fInitialDisclosed(inDisclosureTriangle.IsDisclosed())
{
}

//----------------------------------------------------------------------------------------
// TDisclosureTriangle destructor
//----------------------------------------------------------------------------------------

TDisclosureTriangle::~TDisclosureTriangle()
{
}

//----------------------------------------------------------------------------------------
// TDisclosureTriangle::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TDisclosureTriangle::GetStandardSignature() const
{
	return kStdDisclosureTriangle;
}

//----------------------------------------------------------------------------------------
// TDisclosureTriangle::ReadFields
//----------------------------------------------------------------------------------------

void TDisclosureTriangle::ReadFields(CStream_AC* aStream)
{
	Inherited::ReadFields(aStream);
	
	*aStream >> fInitialDisclosed;
}

//----------------------------------------------------------------------------------------
// TDisclosureTriangle::WriteFields
//----------------------------------------------------------------------------------------

void TDisclosureTriangle::WriteFields(CStream_AC* aStream) const
{
	Inherited::WriteFields(aStream);
	
	*aStream << IsDisclosed();
}

//----------------------------------------------------------------------------------------
// TDisclosureTriangle::SetDisclosed
//----------------------------------------------------------------------------------------

void TDisclosureTriangle::SetDisclosed(bool isDisclosed, bool redraw)
{
	if (GetControl() && isDisclosed != IsDisclosed())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetValue(isDisclosed);
	}
}

//----------------------------------------------------------------------------------------
// TDisclosureTriangle::IsDisclosed
//----------------------------------------------------------------------------------------

bool TDisclosureTriangle::IsDisclosed() const
{
	return GetControl() ? GetControl()->GetValue() == 1 : false;
}

//----------------------------------------------------------------------------------------
// TDisclosureTriangle::DoMakeControl
//----------------------------------------------------------------------------------------


CControl_AC* TDisclosureTriangle::DoMakeControl(WindowRef theWindow,
										const CRect_AC& boundsRect, 
										bool isVisible, bool isEnabled, 
										const CStr255_AC& /*itsTitle*/)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CDisclosureTriangle_AC(boundsRect, isEnabled, fInitialDisclosed);
	else
#endif // qEmulateStandardControls
		return CreateDisclosureTriangle_AC(theWindow, boundsRect, 
										isVisible, isEnabled, fInitialDisclosed);
}

#if qAppearance

//========================================================================================
// CLASS TLeftFacingDisclosureTriangle
//========================================================================================

#undef Inherited
#define Inherited TDisclosureTriangle

MA_DEFINE_CLASS(TLeftFacingDisclosureTriangle);

TLeftFacingDisclosureTriangle::TLeftFacingDisclosureTriangle(const CViewPoint& itsLocation,
						 const CViewPoint& itsSize,
						 SizeDeterminer itsHSizeDet,
						 SizeDeterminer itsVSizeDet,
					     bool isDisclosed) :
	TDisclosureTriangle(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, isDisclosed)
{
}

//----------------------------------------------------------------------------------------
// TLeftFacingDisclosureTriangle::TLeftFacingDisclosureTriangle
//----------------------------------------------------------------------------------------

TLeftFacingDisclosureTriangle::TLeftFacingDisclosureTriangle(const TLeftFacingDisclosureTriangle& inDisclosureTriangle) :
	TDisclosureTriangle(inDisclosureTriangle)
{
}

//----------------------------------------------------------------------------------------
// TLeftFacingDisclosureTriangle::~TLeftFacingDisclosureTriangle
//----------------------------------------------------------------------------------------

TLeftFacingDisclosureTriangle::~TLeftFacingDisclosureTriangle()
{
}

//----------------------------------------------------------------------------------------
// TLeftFacingDisclosureTriangle::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TLeftFacingDisclosureTriangle::GetStandardSignature() const
{
	return kStdLeftFacingDisclosureTriangle;
}

//----------------------------------------------------------------------------------------
// TLeftFacingDisclosureTriangle::DoMakeControl
//----------------------------------------------------------------------------------------
	
CControl_AC* TLeftFacingDisclosureTriangle::DoMakeControl(WindowRef theWindow,
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
	return CreateDisclosureTriangle_AC(theWindow, boundsRect, 
									isVisible, isEnabled, fInitialDisclosed, true /* left facing */);
}


#endif // qAppearance
#endif // qAppearance || qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of UDisclosureTriangle.cpp