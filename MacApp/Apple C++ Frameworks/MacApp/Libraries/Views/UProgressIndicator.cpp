//----------------------------------------------------------------------------------------
// UProgressIndicator.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __UPROGRESSINDICATOR__
#include "UProgressIndicator.h"
#endif

#if qAppearance || qEmulateStandardControls

// MacApp

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UViewIdler__
#include "UViewIdler.h"
#endif

// ACS

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __CProgressIndicator_AC__
#include "CProgressIndicator_AC.h"
#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

// Toolbox

#ifndef __APPEARANCE__
#include <Appearance.h>
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUProgressIndicator
//----------------------------------------------------------------------------------------


void InitUProgressIndicator()
{
	static bool UProgressIndicatorInitialized;

	if (!UProgressIndicatorInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TProgressIndicator, kStdProgressIndicator);
		}
		UProgressIndicatorInitialized = true;
	}
}

//========================================================================================
// CLASS TProgressIndicator
//========================================================================================

#undef Inherited
#define Inherited TCtlMgr

MA_DEFINE_CLASS(TProgressIndicator);

//----------------------------------------------------------------------------------------
// TProgressIndicator constructor
//----------------------------------------------------------------------------------------


TProgressIndicator::TProgressIndicator(const CViewPoint& itsLocation,
									   const CViewPoint& itsSize,
									   SizeDeterminer itsHSizeDet,
									   SizeDeterminer itsVSizeDet,
									   ViewCoordinate itsVal,
									   ViewCoordinate itsMin,
									   ViewCoordinate itsMax,
									   bool isDeterminate) :
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, gEmptyString), 
	
	fInitialVal(itsVal),
	fInitialMin(itsMin),
	fInitialMax(itsMax),
	fInitialDeterminate(isDeterminate)
{
}

//----------------------------------------------------------------------------------------
// TProgressIndicator copy constructor
//----------------------------------------------------------------------------------------

TProgressIndicator::TProgressIndicator(const TProgressIndicator& inProgressIndicator) :
	TCtlMgr(inProgressIndicator),
	
	fInitialVal(inProgressIndicator.GetValue()),
	fInitialMin(const_cast<TProgressIndicator&> (inProgressIndicator).GetMinimum()),
	fInitialMax(const_cast<TProgressIndicator&> (inProgressIndicator).GetMaximum()),
	fInitialDeterminate(inProgressIndicator.IsDeterminate())
{	
}

//----------------------------------------------------------------------------------------
// TProgressIndicator destructor
//----------------------------------------------------------------------------------------

TProgressIndicator::~TProgressIndicator()
{
	StopAutoAnimate();
}

//----------------------------------------------------------------------------------------
// TProgressIndicator::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TProgressIndicator::GetStandardSignature() const
{
	return kStdProgressIndicator;
}

//----------------------------------------------------------------------------------------
// TProgressIndicator::ReadFields
//----------------------------------------------------------------------------------------


void TProgressIndicator::ReadFields(TStream* aStream)
{
	Inherited::ReadFields(aStream);

	fInitialVal = aStream->ReadLong();
	fInitialMin = aStream->ReadLong();
	fInitialMax = aStream->ReadLong();
	*aStream >> fInitialDeterminate;

}

//----------------------------------------------------------------------------------------
// TProgressIndicator::WriteFields
//----------------------------------------------------------------------------------------


void TProgressIndicator::WriteFields(TStream* aStream) const
{
	Inherited::WriteFields(aStream);

	aStream->WriteLong(GetValue());
	aStream->WriteLong((const_cast<TProgressIndicator*> (this))->GetMinimum());
	aStream->WriteLong((const_cast<TProgressIndicator*> (this))->GetMaximum());

	*aStream << IsDeterminate();
}

//----------------------------------------------------------------------------------------
// TProgressIndicator::CreateControl
//----------------------------------------------------------------------------------------


void TProgressIndicator::CreateControl()
{
	Inherited::CreateControl();

	if (!fInitialDeterminate)
		SetDeterminate(false);
}


//----------------------------------------------------------------------------------------
// TProgressIndicator::DoIdle
//----------------------------------------------------------------------------------------


bool TProgressIndicator::DoIdle(IdlePhase /*phase*/)
{
	IdleControl();
	
	return false;	// did not free self
}

//----------------------------------------------------------------------------------------
// TProgressIndicator::SetDeterminate
//----------------------------------------------------------------------------------------

void TProgressIndicator::SetDeterminate(bool isDeterminate)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, kRedraw);
		GetControl()->SetProgressBarIndeterminate(!isDeterminate);
		
		if (isDeterminate)
		{
			TViewIdler::DeleteIdler(this);
		}
		else
		{
			SetIdleFreq(0);		// idle often
			SetEnable(true);	// we won't get idle time if we're disabled!

			// This creates an idler behavior for the dispatcher, so we always get idle time.
			TH_new TViewIdler(this);
		}
	}
}

//----------------------------------------------------------------------------------------
// TProgressIndicator::IsDeterminate
//----------------------------------------------------------------------------------------

bool TProgressIndicator::IsDeterminate() const
{
	return GetControl() ? !GetControl()->GetProgressBarIndeterminate() : fInitialDeterminate;
}

//----------------------------------------------------------------------------------------
// TProgressIndicator::DoMakeControl:
//----------------------------------------------------------------------------------------

CControl_AC* TProgressIndicator::DoMakeControl(WindowRef theWindow,
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CProgressIndicator_AC(boundsRect, fInitialMin, fInitialMax);
	else

#endif
		return CreateProgressIndicator_AC(theWindow, boundsRect, isVisible, isEnabled, 
										  fInitialVal, fInitialMin, fInitialMax);
}

#endif // qAppearance || qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of UProgressIndicator.cpp