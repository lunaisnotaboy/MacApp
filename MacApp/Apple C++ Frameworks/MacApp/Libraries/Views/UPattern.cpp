//----------------------------------------------------------------------------------------
// UPattern.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/13/00	[PB] Change initialization order to match declaration. 
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Include CMultiLocal.h.
		12/08/99	Fixed file name in banner.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		03/23/99	Replace ...Rect_AC calls with standard Toolbox rect calls.
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					LoadResource_AC, FillRect_AC.  Include ResourceUtils_AC.h,
					ImagingUtils_AC.h.
*/

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UPATTERN__
#include "UPattern.h"
#endif

// ACS

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __ResourceUtils_AC__
#include "ResourceUtils_AC.h"
#endif

// MacApp

#ifndef __UICON__
#include "UIcon.h"
	// for kPreferColor
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

void InitUPattern()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TPattern, kStdPattern);
	}
}  


//========================================================================================
// CLASS TPattern
//========================================================================================
#undef Inherited
#define Inherited TControl


MA_DEFINE_CLASS(TPattern);

//----------------------------------------------------------------------------------------
// TPattern constructor
//----------------------------------------------------------------------------------------


TPattern::TPattern(const CViewPoint& itsLocation,
						const CViewPoint& itsSize,
						SizeDeterminer itsHSizeDet,
						SizeDeterminer itsVSizeDet,
						ResNumber itsRsrcID,
						bool preferColor)
	:	TControl(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
		fDataHandle(NULL),
		fRsrcID(kNoResource),
		fPreferColor(kPreferColor),
		fIsColor(kPreferColor)
{
	fEventNumber = mPatternHit;

	fPreferColor = preferColor;
	fIsColor = preferColor;

	SetPatternRsrcID(itsRsrcID, kDontRedraw);
	SetEnable(false);						// Default is to not enable hit testing 
}

//----------------------------------------------------------------------------------------
// TPattern copy constructor
//----------------------------------------------------------------------------------------


TPattern::TPattern(const TPattern& inPattern)
	:	TControl(inPattern),
		fDataHandle(NULL),
		fRsrcID(kNoResource),
		fPreferColor(inPattern.fPreferColor),
		fIsColor(inPattern.fIsColor)
{
	if (inPattern.fDataHandle)
		SetPatternRsrcID(inPattern.fRsrcID, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TPattern::Free: 
//----------------------------------------------------------------------------------------


TPattern::~TPattern()
{
	ReleasePattern();
}

//----------------------------------------------------------------------------------------
// TPattern::GetStandardSignature: 
//----------------------------------------------------------------------------------------


IDType TPattern::GetStandardSignature() const	// Override 
{
	return kStdPattern;
}

//----------------------------------------------------------------------------------------
// TPattern::ReadFields: 
//----------------------------------------------------------------------------------------


void TPattern::ReadFields(CStream_AC* aStream)				// Override 
{
	Inherited::ReadFields(aStream);

	fPreferColor = aStream->ReadBoolean();

	fIsColor = fPreferColor;

	ResNumber itsRsrcID = aStream->ReadInteger();
	SetPatternRsrcID(itsRsrcID, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TPattern::WriteFields: 
//----------------------------------------------------------------------------------------


void TPattern::WriteFields(CStream_AC* aStream) const				// Override 
{
	Inherited::WriteFields(aStream);

	aStream->WriteBoolean(fPreferColor);

#if qDebugMsg
	if (fRsrcID == kNoResource)
		ProgramReport_AC("Tried to write TPattern with no resource ID.\n");
#endif

	aStream->WriteInteger(fRsrcID);
}

//----------------------------------------------------------------------------------------
// TPattern::Draw: 
//----------------------------------------------------------------------------------------


void TPattern::Draw(const CViewRect& area)	// Override 
{
	if (fDataHandle)
	{
		if (IsAResource_AC(fDataHandle) &&!fIsColor)// Pixpat handles != resource handles 
			::LoadResource_AC(fDataHandle);
		if (*fDataHandle)				// If there's room for the pattern… 
		{
			PenNormal();						// NECESSARY? 
			CRect_AC theQDRect(ControlQDArea());

			CTempHandleLock_AC tempHandleLock(fDataHandle);
			if (fIsColor)
				FillCRect(theQDRect, (PixPatHandle)fDataHandle);
			else
				::MacFillRect(theQDRect, *((PatHandle)fDataHandle));
		}
	}

	Inherited::Draw(area);
}

//----------------------------------------------------------------------------------------
// TPattern::ReleasePattern: 
//----------------------------------------------------------------------------------------


void TPattern::ReleasePattern()
{
	fRsrcID = kNoResource;
	if (fDataHandle)
	{
		if (fIsColor)
			DisposePixPat((PixPatHandle)fDataHandle);
		else
			HPurge(fDataHandle);
		fDataHandle = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TPattern::SetPattern: 
//----------------------------------------------------------------------------------------


void TPattern::SetPattern(Handle thePattern,
						  bool redraw)
{
	ReleasePattern();
	fDataHandle = thePattern;

	// get the rsrc id for non-color patterns (color pattern handles aren't resource handles) 
	if (!fIsColor)
	{
		ResNumber theID;
		ResType theType;
		CStr255_AC name;

		CMultiLocale_AC::GetReverseMappedResInfo(thePattern, &theID, &theType, name);
		if (ResError() == noErr)
			fRsrcID = theID;
	}

	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TPattern::SetPatternRsrcID: 
//----------------------------------------------------------------------------------------


void TPattern::SetPatternRsrcID(ResNumber itsRsrcID, bool redraw)
{
	ReleasePattern();

	fRsrcID = itsRsrcID;
	if (fRsrcID != kNoResource)
	{
		if (fPreferColor)
			fDataHandle = (Handle)GetPixPat(CMultiLocale_AC::GetExistingResourceID('ppat', fRsrcID));	// try to get a 'ppat' resource

		if (fDataHandle)
			fIsColor = kPreferColor;
		else								// try to get a 'PAT ' resource
		{
			fDataHandle = (Handle)CMultiLocale_AC::GetResource('PAT ', fRsrcID);
			if (fDataHandle)
				fIsColor =!kPreferColor;	// Either can't or won't 
		}

		::ThrowIfNULLResource_AC(fDataHandle);		// was ::ThrowIfResError_AC();
	}

	if (redraw)
		ForceRedraw();
}


//----------------------------------------------------------------------------------------
// End of UPattern.cpp


/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitUPattern
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
		
*/