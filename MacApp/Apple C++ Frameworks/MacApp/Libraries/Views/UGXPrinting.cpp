//----------------------------------------------------------------------------------------
// UGXPrinting.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		09/01/00	Stripped dead code.
		08/31/00	Use MStreamable_AC instead of MStreamable.
		04/06/00	Cloned from the original Views:UPrinting.cpp.  All
							things TGXPrint are herein.
*/

#define __INCLUDED_BY_UGXPRINTING__

#ifndef __UGXPrinting__
#include "UGXPrinting.h"
#endif

#undef __INCLUDED_BY_UGXPRINTING__

// MacApp

#ifndef __MacAppRequired__
#include "MacAppRequired.h"
#endif

#if qAppleEventAware
	#ifndef __UAPPLEEVENTS__
	#include "UAppleEvents.h"
	#endif
#endif

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __UCOREERRORMGR__
#include "UCoreErrorMgr.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPATCH__
#include "UPatch.h"
#endif

#ifndef __UPOINTEROBJECT__
#include "UPointerObject.h"
#endif

#if qAppleEventAware
	#ifndef __USCRIPTING__
	#include "UScripting.h"
	#endif
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CDependencies_AC__
#include "CDependencies_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __WindowUtils_AC__
#include "WindowUtils_AC.h"
#endif

// Toolbox

#if qAppleEventAware
	#ifndef __AEREGISTRY__
	#include <AERegistry.h>
	#endif
#endif

#ifndef __BALLOONS__
#include <Balloons.h>
#endif

#ifndef __EDITIONS__
#include <Editions.h>
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __GXENVIRONMENT__
#include <GXEnvironment.h>
#endif

#ifndef __GXGRAPHICS__
#include <GXGraphics.h>
#endif

#ifndef __GXPRINTING__
#include <GXPrinting.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MENUS__
#include <Menus.h>
#endif

#ifndef __PACKAGES__
#include <Packages.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

// ANSI

#ifndef __LIMITS__
#include <limits.h>
#endif


#ifndef __STDLIB__
#include <stdlib.h>
#endif

#ifndef __STRING__
#include <string.h>
#endif

// Handy macros for Fixed point manipulation
#ifndef __GXMATH__
	#ifndef FixedToInt
	#define FixedToInt(a) (static_cast<short>((Fixed)(a) + fixed1/2 >> 16))
	#endif
	
	#ifndef IntToFixed
	#define IntToFixed(a) ((Fixed)(a) << 16)
	#endif
#endif

//========================================================================================
// Globals, static initialization
//========================================================================================

// The following are required when doing GX printing.
static GXPrintingEventUPP		pGXPrintingEventUPP;
static gxShapeSpoolUPP			pgxShapeSpoolUPP;
static gxPrintingFlattenUPP		pgxPrintingFlattenUPP;
static gxPrintingFlattenUPP		pgxPrintingUnflattenUPP;
static gxPrintingFlattenUPP		pgxGetSizeHelperUPP;
bool							gUsingGXPrinting;

const short			kFirstGXFormatIndex = 2;
const ResType		kPrintResType[kFirstGXFormatIndex + 1] = { kAlternatePrintInfoRsrcType, kPrintInfoRsrcType, kGXPrintInfoRsrcType };
const ResNumber		kPrintResNumber[kFirstGXFormatIndex + 1] = { kAlternatePrintInfoRsrcID, kPrintInfoRsrcID, kGXPrintInfoRsrcID };

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitializePrinting: 
//----------------------------------------------------------------------------------------

void InitializePrinting()
{
	static bool GXPrintingInitialized;
	if (!GXPrintingInitialized)
	{
		TPrintHandler::gCouldPrint = true;
	
		if (TView::gGXGraphicsClient && HasQDGXPrinting_AC())
			gUsingGXPrinting = ::GXInitPrinting() == noErr;
	
		if (gUsingGXPrinting)
			gDefaultPrintInfo = TH_new TGXJob;
		else
			gDefaultPrintInfo = TH_new TMacPrintJob;
	
		// Install a StdPrintHandler in global variable gPrintHandler
		TStdPrintHandler* aTStdPrintHandler = TH_new TStdPrintHandler;
		aTStdPrintHandler->fFinderJobDialog = true;
		TPrintHandler::gPrintHandler = aTStdPrintHandler;

		GXPrintingInitialized = true;
	}
}

//========================================================================================
// CLASS TGXJob
//========================================================================================

MA_DEFINE_CLASS(TGXJob);

//----------------------------------------------------------------------------------------
// TGXJob constructor
//----------------------------------------------------------------------------------------


TGXJob::TGXJob(gxJob itsgxJob,
								bool isValid) :
	fgxJob(NULL),
	fPrintViewPort(NULL)
{
	if (itsgxJob)
	{
		fgxJob = itsgxJob;
		AdoptJob(fgxJob);
		fIsValid = isValid;
	}
	else
	{
		::ThrowIfOSErr_AC(::GXNewJob(&fgxJob));
		AdoptJob(fgxJob);
		SetToDefault();
	}

	if (!pgxShapeSpoolUPP)
		::ThrowIfNULL_AC(pgxShapeSpoolUPP = NewgxShapeSpoolProc(MyPrintAShape));

	if (!pGXPrintingEventUPP)
		::ThrowIfNULL_AC(pGXPrintingEventUPP = NewGXPrintingEventProc(PrintingEventOverride));
	
	if (!pgxPrintingFlattenUPP)
		::ThrowIfNULL_AC(pgxPrintingFlattenUPP = NewgxPrintingFlattenProc(MyFlattenFunction));
	
	if (!pgxPrintingUnflattenUPP)
		::ThrowIfNULL_AC(pgxPrintingUnflattenUPP = NewgxPrintingFlattenProc(MyUnflattenFunction));

	if (!pgxGetSizeHelperUPP)
		::ThrowIfNULL_AC(pgxGetSizeHelperUPP = NewgxPrintingFlattenProc(GetSizeHelper));
}

//----------------------------------------------------------------------------------------
// TGXJob destructor
//----------------------------------------------------------------------------------------

TGXJob::~TGXJob()
{
	if (fgxJob)
	{
		::GXDisposeJob(fgxJob);
		fgxJob = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TGXJob::ReadFrom: 
//----------------------------------------------------------------------------------------

void TGXJob::ReadFrom(CStream_AC* aStream)
{
	TPrintInfo::ReadFrom(aStream);

	if (!fgxJob)
	{
		::ThrowIfOSErr_AC(::GXNewJob(&fgxJob));
		AdoptJob(fgxJob);
	}

	::GXUnflattenJob(fgxJob, (gxPrintingFlattenProc)pgxPrintingUnflattenUPP, aStream);
}

//----------------------------------------------------------------------------------------
// TGXJob::ConvertFrom: 
//----------------------------------------------------------------------------------------

void TGXJob::ConvertFrom(CStream_AC* aStream)
{
	TPrintInfo::ReadFrom(aStream);

	THPrint aPrint = (THPrint)NewPermHandleClear(sizeof(TPrint));
	CTempHandle_AC tempHandle((Handle)aPrint);

	TemplateTempHandleLock<THPrint> tempHandleLock(aPrint, eMoveHi);
	aStream->ReadBytes(*aPrint, sizeof(TPrint));

	if (!fgxJob)
	{
		::ThrowIfOSErr_AC(::GXNewJob(&fgxJob));
		AdoptJob(fgxJob);
	}

	::GXConvertPrintRecord(fgxJob, aPrint);
}

//----------------------------------------------------------------------------------------
// TGXJob::WriteTo: 
//----------------------------------------------------------------------------------------

void TGXJob::WriteTo(CStream_AC* aStream) const
{
	MStreamable_AC::WriteTo(aStream);

	if (fgxJob)
	{
		::GXFlattenJob(fgxJob, (gxPrintingFlattenProc)pgxPrintingFlattenUPP, aStream);
	}
}

//----------------------------------------------------------------------------------------
// TGXJob::SetFrom
//----------------------------------------------------------------------------------------

void TGXJob::SetFrom(TPrintInfo* jobToCopy)
{
	TPrintInfo::SetFrom(jobToCopy);

	TGXJob * gxToCopy = dynamic_cast_or_throw_AC(TGXJob*,jobToCopy);

	::GXCopyJob(gxToCopy->GetRawgxJob(), GetRawgxJob());

	if (fIsValid)
		Changed(mPrintInfoChanged, this);
	else
		Invalidate();
}

//----------------------------------------------------------------------------------------
// TGXJob::SetFrom
//----------------------------------------------------------------------------------------

void TGXJob::SetFrom(gxJob jobToCopy, bool isValid,
				bool needsDefault)
{
	::GXCopyJob(jobToCopy, fgxJob);

	fIsValid = isValid;
	fNeedsDefault = needsDefault;

	if (fIsValid)
		Changed(mPrintInfoChanged, this);
	else
		Invalidate();
}

//----------------------------------------------------------------------------------------
// TGXJob::GetSize
//----------------------------------------------------------------------------------------

long TGXJob::GetSize(bool				/* asResource */) const
{
	long returnVal = 0;

	// the helper function will total up the bytes
	if (GetRawgxJob())
		::GXFlattenJob(GetRawgxJob(), (gxPrintingFlattenProc)pgxGetSizeHelperUPP, &returnVal);

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TGXJob::GetSize
//----------------------------------------------------------------------------------------

pascal OSErr TGXJob::GetSizeHelper(long size,
										 void* /* data */,
										 void* refCon)
{
	*static_cast<long*>(refCon) += size;

	return noErr;
}

//----------------------------------------------------------------------------------------
// TGXJob copy constructor
//----------------------------------------------------------------------------------------

TGXJob::TGXJob(const TGXJob& inGXJob)
	:	TPrintInfo(inGXJob),
		fgxJob(inGXJob.GetRawgxJob() ? ::GXCopyJob(inGXJob.fgxJob, NULL) : NULL),
		fPrintViewPort(inGXJob.fPrintViewPort),
		fQDPortRec(inGXJob.fQDPortRec),
		fPrintPort(inGXJob.fPrintPort),
		fSpoolData(inGXJob.fSpoolData)
	{ }

//----------------------------------------------------------------------------------------
// TGXJob::GetPaperRect:
//----------------------------------------------------------------------------------------

CViewRect TGXJob::GetPaperRect()
{
	gxFormat theFormat = ::GXGetJobFormat(GetgxJob(), 1);	//Get the default format for now.

	gxRectangle	pageSize;
	gxRectangle	paperSize;
	::GXGetFormatDimensions( theFormat, &pageSize, &paperSize);
	
	CViewRect thePaper;
	thePaper.top    = FixedTruncate(paperSize.top);
	thePaper.left   = FixedTruncate(paperSize.left);
	thePaper.bottom = FixedTruncate(paperSize.bottom);
	thePaper.right  = FixedTruncate(paperSize.right);

	return thePaper;
}

//----------------------------------------------------------------------------------------
// TGXJob::GetInkRect:
//----------------------------------------------------------------------------------------

CViewRect TGXJob::GetInkRect()
{

	gxFormat theFormat = ::GXGetJobFormat( GetgxJob(), 1);	//Get the default format for now.

	gxRectangle	pageSize;
	gxRectangle	paperSize;
	::GXGetFormatDimensions( theFormat, &pageSize, &paperSize);

	CViewRect ink;
	ink.top    = FixedTruncate(pageSize.top);
	ink.left   = FixedTruncate(pageSize.left);
	ink.bottom = FixedTruncate(pageSize.bottom);
	ink.right  = FixedTruncate(pageSize.right);

	return ink;
}

//----------------------------------------------------------------------------------------
// TGXJob::GetDeviceRes:
//----------------------------------------------------------------------------------------

CPoint_AC TGXJob::GetDeviceRes()
{
	// Get the formatting printer
	gxPrinter formatPrinter = ::GXGetJobFormattingPrinter(GetgxJob());

	// Get the current view device and its mapping
	gxViewDevice printerVDev = ::GXGetPrinterViewDevice(formatPrinter, 0);
	gxMapping vDevMapping;
	::GXGetViewDeviceMapping(printerVDev, &vDevMapping);

	long hRes = vDevMapping.map[0][0];
	long vRes = vDevMapping.map[1][1];

	//	Convert scaling factors (multiples of kClassicQDResolution (72) dpi) into
	//	resolutions.

	hRes = FixedToInt(FixedMultiply(hRes, IntToFixed(kClassicQDResolution)));
	vRes = FixedToInt(FixedMultiply(vRes, IntToFixed(kClassicQDResolution)));
	
	return CViewPoint(hRes, vRes).ToPoint();
}

//----------------------------------------------------------------------------------------
// TGXJob::GetPrintPages:
//----------------------------------------------------------------------------------------

void TGXJob::GetPrintPages(long& fromPage,
							   long& toPage,
							   long& minFromPage,
							   long& maxToPage)
{
// Get the job collection
	Collection jobCollection = GXGetJobCollection(GetgxJob());

	long oldDataSize;
	long index;
	::ThrowIfOSErr_AC(GetCollectionItemInfo(jobCollection,
									gxPageRangeTag,
									gxPrintingTagID,
									&index,
									&oldDataSize,
									dontWantAttributes));

	gxPageRangeInfo pageRangeInfo;
	::ThrowIfOSErr_AC(GetCollectionItem(jobCollection,
							gxPageRangeTag,
							gxPrintingTagID,
							&oldDataSize,
							&pageRangeInfo));


	fromPage = pageRangeInfo.simpleRange.fromPage;
	toPage = pageRangeInfo.simpleRange.toPage;

	minFromPage = pageRangeInfo.minFromPage;
	maxToPage = pageRangeInfo.maxToPage;
}

//----------------------------------------------------------------------------------------
// TGXJob::SetPrintPages:
//----------------------------------------------------------------------------------------

void TGXJob::SetPrintPages(long fromPage,
							   long toPage,
							   long minFromPage,
							   long maxToPage)
{
// Get the job collection
	Collection jobCollection = GXGetJobCollection(GetgxJob());

	long oldDataSize;
	long index;
	::ThrowIfOSErr_AC(GetCollectionItemInfo(jobCollection,
									gxPageRangeTag,
									gxPrintingTagID,
									&index,
									&oldDataSize,
									dontWantAttributes));

	gxPageRangeInfo pageRangeInfo;
	::ThrowIfOSErr_AC(GetCollectionItem(jobCollection,
							gxPageRangeTag,
							gxPrintingTagID,
							&oldDataSize,
							&pageRangeInfo));

	pageRangeInfo.minFromPage = minFromPage;
	pageRangeInfo.maxToPage = maxToPage;

	pageRangeInfo.simpleRange.fromPage = fromPage;
	pageRangeInfo.simpleRange.toPage = toPage;

//	pageRangeInfo.simpleRange.optionChosen = gxDefaultPageRange;
	pageRangeInfo.simpleRange.printAll = (fromPage == minFromPage) && (toPage == maxToPage);

	::ThrowIfOSErr_AC(ReplaceIndexedCollectionItem(jobCollection,
										   index,
										   oldDataSize,
										   &pageRangeInfo));
}

//----------------------------------------------------------------------------------------
// TGXJob::GetPrintCopies:
//----------------------------------------------------------------------------------------

long TGXJob::GetPrintCopies()
{
// Get the job collection
	Collection jobCollection = GXGetJobCollection(GetgxJob());

	long oldDataSize;
	::ThrowIfOSErr_AC(GetCollectionItemInfo(jobCollection,
									gxCopiesTag,
									gxPrintingTagID,
									dontWantIndex,
									&oldDataSize,
									dontWantAttributes));

	gxCopiesInfo copiesInfo;
	::ThrowIfOSErr_AC(GetCollectionItem(jobCollection,
							gxCopiesTag,
							gxPrintingTagID,
							&oldDataSize,
							&copiesInfo));

	return copiesInfo.copies;
}

//----------------------------------------------------------------------------------------
// TGXJob::SetPrintCopies:
//----------------------------------------------------------------------------------------

void TGXJob::SetPrintCopies(long numCopies)
{
// Get the job collection
	Collection jobCollection = GXGetJobCollection(GetgxJob());

	long oldDataSize;
	long index;
	::ThrowIfOSErr_AC(GetCollectionItemInfo(jobCollection,
									gxCopiesTag,
									gxPrintingTagID,
									&index,
									&oldDataSize,
									dontWantAttributes));

	gxCopiesInfo copiesInfo;
	::ThrowIfOSErr_AC(GetCollectionItem(jobCollection,
							gxCopiesTag,
							gxPrintingTagID,
							&oldDataSize,
							&copiesInfo));


	copiesInfo.copies = numCopies;
	::ThrowIfOSErr_AC(ReplaceIndexedCollectionItem(jobCollection,
										   index,
										   oldDataSize,
										   &copiesInfo));
}

//----------------------------------------------------------------------------------------
// TGXJob::SetTargetPrinter:
//----------------------------------------------------------------------------------------

void TGXJob::SetTargetPrinter(const CFSSpec_AC& targetPrinter)
{
	::GXSelectJobOutputPrinter(GetgxJob(), CStr31_AC(targetPrinter.name));
}

//----------------------------------------------------------------------------------------
// TGXJob::SetToDefault:
//----------------------------------------------------------------------------------------

void TGXJob::SetToDefault()
{
	fNeedsDefault = true;

	Invalidate();
}

//----------------------------------------------------------------------------------------
// TGXJob::IsSetToDefault:
//----------------------------------------------------------------------------------------

bool TGXJob::IsSetToDefault()
{
	// we don't really know how to compare the job to see if it's just like the default
	// so let's just assume that if we even have a job it's not default
	return fgxJob ? false : true;
}

//----------------------------------------------------------------------------------------
// TGXJob::AdoptJob: 
//----------------------------------------------------------------------------------------

void TGXJob::AdoptJob(gxJob itsgxJob)
{
	::GXInstallApplicationOverride(itsgxJob, gxPrintingEventMsg, pGXPrintingEventUPP);
}

//----------------------------------------------------------------------------------------
// TGXJob::PrintingEventOverride: 
//----------------------------------------------------------------------------------------

OSErr TGXJob::PrintingEventOverride(EventRecord* anEvent,
										  bool filterEvent)
{
	if (!filterEvent && gDispatcher)
	{
		static TToolboxEvent* bufferableEvent;
	
		try
		{
			bool needsSecondaryEvent = false;
			if (!bufferableEvent)
			{
				CTempObjectAllocation tempObjectAllocation(true);
				bufferableEvent = TH_new TToolboxEvent(gDispatcher, anEvent);
				needsSecondaryEvent = bufferableEvent->IsDoubleEvent();
			}
			else
				bufferableEvent->AddSecondaryKeyEvent(*anEvent);
			
			if (!needsSecondaryEvent)
			{
				gDispatcher->SetEventLevel(gDispatcher->GetEventLevel() + 1);
				gDispatcher->SetSysWindowActive(true);


				InvalidateMenus();
				gDispatcher->SetupTheMenus();
				gDispatcher->InvalidateFocus();
				bufferableEvent->Process();


				gDispatcher->SetSysWindowActive(false);
				gDispatcher->SetEventLevel(gDispatcher->GetEventLevel() - 1);
				bufferableEvent = NULL;
			}
		}
		catch(CException_AC& theException)
		{
			DoCatchMessage_AC(theException);
			delete bufferableEvent;
			bufferableEvent = NULL;
		}
	}
	
	return noErr;
}

//----------------------------------------------------------------------------------------
// TGXJob::GetgxJob:
//----------------------------------------------------------------------------------------

gxJob TGXJob::GetgxJob()
{
	Update();

	return fgxJob;
}

//----------------------------------------------------------------------------------------
// TGXJob::GetError: 
//----------------------------------------------------------------------------------------

OSErr TGXJob::GetError()
{
	return ::GXGetJobError(GetgxJob());
}

//----------------------------------------------------------------------------------------
// TGXJob::SetError: 
//----------------------------------------------------------------------------------------

void TGXJob::SetError(OSErr err)
{
	::GXSetJobError(GetRawgxJob(), err);
}

//----------------------------------------------------------------------------------------
// TGXJob::StartJob: 
//----------------------------------------------------------------------------------------

void TGXJob::StartJob(const CStr255_AC& docTitle,
						long numPages)
{
	::GXStartJob(GetgxJob(), CStr255_AC(docTitle), numPages);

	::ThrowIfOSErr_AC(GetError());
	
	fPrintViewPort = ::GXNewViewPort(gxScreenViewDevices);
	// •••  How do I test this for error?
	
	OpenCPort(&fQDPortRec);
	fPrintPort = &fQDPortRec;

	SetPort(GetJobPort());

	CRect_AC wideopenRect(-32766, -32766, 32767, 32767);
	RectRgn(GetJobPort()->visRgn, &wideopenRect);
	ClipRect(&wideopenRect);
}

//----------------------------------------------------------------------------------------
// TGXJob::GetJobPort: 
//----------------------------------------------------------------------------------------

GrafPtr TGXJob::GetJobPort()
{
	return (GrafPtr)fPrintPort;
}

//----------------------------------------------------------------------------------------
// TGXJob::FinishJob: 
//----------------------------------------------------------------------------------------

void TGXJob::FinishJob()
{
	::GXFinishJob(GetgxJob());
	OSErr err = GetError();
	
	::GXDisposeViewPort(fPrintViewPort);
	fPrintViewPort = NULL;

	SetPortWindowPort(gWorkPort);

	CloseCPort(&fQDPortRec);
	fPrintPort = NULL;	// So we don't accidentally use it

	::ThrowIfOSErr_AC(err);
}

//----------------------------------------------------------------------------------------
// TGXJob::StartPage: 
//----------------------------------------------------------------------------------------

void TGXJob::StartPage(long pageNumber)
{
	//••• Here is where we would call back thru the TPrintHandler to the view
	// to get the specific pages format
	
	gxFormat pageFormat = ::GXGetJobFormat(GetgxJob(), 1);

	::GXStartPage(GetgxJob(), pageNumber, pageFormat, 1, &fPrintViewPort);
	::ThrowIfOSErr_AC(GetError());

	fSpoolData.printViewPort = fPrintViewPort;

	// Install Translators
	::GXGetFormatDimensions(pageFormat, &fSpoolData.pageArea, NULL);

	CRect_AC everywhereRect(0, 0, 32767, 32767);

	::GXInstallQDTranslator(GetJobPort(),
						  gxDefaultOptionsTranslation,
						  &everywhereRect, &everywhereRect,
						  CPoint_AC(1, 1) /* patStretch */, 
						  pgxShapeSpoolUPP,
						  &fSpoolData);
}

//----------------------------------------------------------------------------------------
// TGXJob::FinishPage: 
//----------------------------------------------------------------------------------------

void TGXJob::FinishPage()
{
// Remove Translators
		::GXRemoveQDTranslator(GetJobPort(), NULL);

// Finish the page.
		::GXFinishPage(GetgxJob());
}


//----------------------------------------------------------------------------------------
// TGXJob::PrepareEditRecord: 
//----------------------------------------------------------------------------------------

void TGXJob::PrepareEditRecord(gxEditMenuRecord* editMenuRecord)
{
	short itsItem;
	CommandToMenuItem(cCut, editMenuRecord->editMenuID, itsItem);
	short itsMenu;

	CommandToMenuItem(cCut, itsMenu, editMenuRecord->cutItem);
	CommandToMenuItem(cCopy, itsMenu, editMenuRecord->copyItem);
	CommandToMenuItem(cPaste, itsMenu, editMenuRecord->pasteItem);
	CommandToMenuItem(cClear, itsMenu, editMenuRecord->clearItem);
	CommandToMenuItem(cUndo, itsMenu, editMenuRecord->undoItem);
}


//----------------------------------------------------------------------------------------
// TGXJob::CallJobDialog: 
//----------------------------------------------------------------------------------------

bool TGXJob::CallJobDialog()
{
	::ThrowIfOSErr_AC(MAInteractWithUser());
	PullApplicationToFront();

	::SetCursorToArrow_AC();
	if (gDispatcher)
		gDispatcher->InvalidateMouseRegions();

	gDispatcher->AboutToLoseControl(true);		// so scrap gets converted and floaters get removed

	gxEditMenuRecord editMenuRecord;
	PrepareEditRecord(&editMenuRecord);

	EnableMenuItems_AC(MAGetMenu(editMenuRecord.editMenuID), 0); // ensure the menu is enabled for GX

	HiliteMenu(0);

	// Force the event handler in place
	AdoptJob(GetgxJob());

	gxDialogResult aGXDialogResult = ::GXJobPrintDialog(GetgxJob(), &editMenuRecord);
	bool result = aGXDialogResult == gxOKSelected;

	gDispatcher->RegainControl(true);			// scrap gets converted, printer gets checked, floaters get restored

	return result;
}

//----------------------------------------------------------------------------------------
// TGXJob::CallStyleDialog: 
//----------------------------------------------------------------------------------------

bool TGXJob::CallStyleDialog()
{
	::ThrowIfOSErr_AC(MAInteractWithUser());
	PullApplicationToFront();

	::SetCursorToArrow_AC();
	if (gDispatcher)
		gDispatcher->InvalidateMouseRegions();

	gDispatcher->AboutToLoseControl(true);		// so scrap gets converted and floaters get removed

	gxEditMenuRecord editMenuRecord;
	PrepareEditRecord(&editMenuRecord);

	EnableMenuItems_AC(MAGetMenu(editMenuRecord.editMenuID), 0); // ensure the menu is enabled for GX

	HiliteMenu(0);

	// Force the even handler in place
	AdoptJob(GetgxJob());

	gxDialogResult aGXDialogResult = ::GXJobDefaultFormatDialog(GetgxJob(), &editMenuRecord);
	bool result = aGXDialogResult == gxOKSelected;

	gDispatcher->RegainControl(true);			// scrap gets converted, printer gets checked, floaters get restored

	return result;
}

//----------------------------------------------------------------------------------------
// TGXJob::ValidatePrintJob: 
//----------------------------------------------------------------------------------------

bool TGXJob::ValidatePrintJob()
{
	static const bool kNoChange_AC = false;
	
	return kNoChange_AC;
}


//----------------------------------------------------------------------------------------
// TGXJob::SetPrintJobDefaults: 
//----------------------------------------------------------------------------------------

void TGXJob::SetPrintJobDefaults()
{
	if (fgxJob)
	{
		::GXDisposeJob(fgxJob);
		fgxJob = NULL;
	}

	::ThrowIfOSErr_AC(::GXNewJob(&fgxJob));
}

//----------------------------------------------------------------------------------------
// TGXJob::Update:
//----------------------------------------------------------------------------------------

void TGXJob::Update()
{
	TPrintInfo::Update();
}

//----------------------------------------------------------------------------------------
// TGXJob::DoUpdate:
//----------------------------------------------------------------------------------------

void TGXJob::DoUpdate(ChangeID_AC theChange,
						MDependable_AC* changedObject,
						void* changeData,
						CDependencySpace_AC* dependencySpace)
{
	switch (theChange)
	{
		case mRegainControl:
			TPrintHandler::gCouldPrint = true;			// Could be OK now
			InvalidateMenus();							// so the menus stay in sync.

			Invalidate();
			Changed(mPrinterChanged, this);
			break;

		default:
			TPrintInfo::DoUpdate(theChange, changedObject, changeData, dependencySpace);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TGXJob::JobMerge:
//----------------------------------------------------------------------------------------

void TGXJob::JobMerge(TPrintInfo* /* mergeFrom */)
{
	// •••  Fix this
}

//----------------------------------------------------------------------------------------
// TGXJob::MyPrintAShape:
//----------------------------------------------------------------------------------------

OSErr TGXJob::MyPrintAShape(gxShape currentShape, long refCon)
{
	// Don't waste time spooling the shape if it's being
	// drawn completely off the page.

	MySpoolDataRec* spoolData = (MySpoolDataRec*) refCon;
	gxShapeType theShapeType = ::GXGetShapeType(currentShape);
	
	::GXSetShapeViewPorts(currentShape, 1, &spoolData->printViewPort);
	::GXDrawShape(currentShape);
	
	return (OSErr) ::GXGetGraphicsError(NULL);
}

//----------------------------------------------------------------------------------------
// TGXJob::MyUnflattenFunction:
//----------------------------------------------------------------------------------------

pascal OSErr TGXJob::MyFlattenFunction (long size, void *data, void *refCon)
{
	OSErr returnVal = noErr;

	try
	{
		reinterpret_cast<CStream_AC*>(refCon)->WriteBytes(data, size);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		returnVal = theException.GetError();
	}
		// drop thru
	

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TGXJob::MyUnflattenFunction:
//----------------------------------------------------------------------------------------

pascal OSErr TGXJob::MyUnflattenFunction (long size, void *data, void *refCon)
{
	OSErr returnVal = noErr;

	try
	{
		reinterpret_cast<CStream_AC*>(refCon)->ReadBytes(data, size);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		returnVal = theException.GetError();
	}
		// drop thru
	

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TGXJob::GetMaxSquareResolution:
//----------------------------------------------------------------------------------------

void TGXJob::GetMaxSquareResolution(Fixed& hRes, Fixed& vRes)
{
	hRes = 0;
	vRes = 0;

	// Get the formatting printer and the number of
	// view devices for that printer.

	gxPrinter formatPrinter = ::GXGetJobFormattingPrinter(GetgxJob());
	long numViewDevices = ::GXCountPrinterViewDevices (formatPrinter);

	// Loop through the view devices that this printer supports.
	for (long idx = 1; idx <= numViewDevices; ++idx)
	{
		gxViewDevice printerVDev = ::GXGetPrinterViewDevice(formatPrinter, idx);
		gxMapping vDevMapping;
		::GXGetViewDeviceMapping(printerVDev, &vDevMapping);

		if ((vDevMapping.map[0][0] > hRes) && (vDevMapping.map[1][1] > vRes))
		{
			hRes = vDevMapping.map[0][0];
			vRes = vDevMapping.map[1][1];
		}
	}


	//	Convert scaling factors (multiples of kClassicQDResolution (72) dpi) into
	//	resolutions.

	hRes = FixedMultiply(hRes, IntToFixed(kClassicQDResolution));
	vRes = FixedMultiply(vRes, IntToFixed(kClassicQDResolution));
}

//----------------------------------------------------------------------------------------
// TGXJob::SetResolution:
//----------------------------------------------------------------------------------------

void TGXJob::SetResolution(Fixed hRes, Fixed vRes)
{
	//	Convert scaling factors (multiples of kClassicQDResolution (72) dpi) into
	//	resolutions.

	hRes = FixedDivide(hRes, IntToFixed(kClassicQDResolution));
	vRes = FixedDivide(vRes, IntToFixed(kClassicQDResolution));


	// Get the formatting printer and the number of
	// view devices for that printer.

	gxPrinter formatPrinter = ::GXGetJobFormattingPrinter(GetgxJob());
	long numViewDevices = ::GXCountPrinterViewDevices (formatPrinter);

	// Loop through the view devices that this printer supports.
	for (long idx = 1; idx <= numViewDevices; ++idx)
	{
		gxViewDevice printerVDev = ::GXGetPrinterViewDevice(formatPrinter, idx);
		gxMapping vDevMapping;
		::GXGetViewDeviceMapping(printerVDev, &vDevMapping);

		if ((vDevMapping.map[0][0] == hRes) && (vDevMapping.map[1][1] == vRes))
			::GXSelectPrinterViewDevice(formatPrinter, idx);
	}


	Invalidate();
}

//----------------------------------------------------------------------------------------
// TGXJob::GetScale:
//----------------------------------------------------------------------------------------

short TGXJob::GetScale()
{
	CViewRect printingRect(GetPaperRect());
	VHSelect longerDirection = LongerSide(printingRect);
	ViewCoordinate projectionPaperSize = printingRect.GetSize()[longerDirection];

	gxPaperType aGXPaperType = ::GXGetFormatPaperType(GXGetJobFormat( GetgxJob(), 1));	//Get the default format for now.
	::ThrowIfOSErr_AC(GetError());

	gxRectangle	paperTypePageSize;
	gxRectangle	paperTypepaperSize;
	::GXGetPaperTypeDimensions (aGXPaperType, &paperTypePageSize, &paperTypepaperSize);

	CViewRect paperTypePaperSize;
	paperTypePaperSize.top    = FixedTruncate(paperTypepaperSize.top);
	paperTypePaperSize.left   = FixedTruncate(paperTypepaperSize.left);
	paperTypePaperSize.bottom = FixedTruncate(paperTypepaperSize.bottom);
	paperTypePaperSize.right  = FixedTruncate(paperTypepaperSize.right);

	
	short paperSizeIn_iPrPgFract = paperTypePaperSize.GetSize()[LongerSide(paperTypePaperSize)];
	short paperSizeInDeviceResDPI = paperSizeIn_iPrPgFract;
	
	return (paperSizeInDeviceResDPI * 100) / projectionPaperSize;
}

//----------------------------------------------------------------------------------------
// End of UGXPrinting.cpp
