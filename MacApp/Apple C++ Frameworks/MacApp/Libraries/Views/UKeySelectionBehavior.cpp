//----------------------------------------------------------------------------------------
// UKeySelectionBehavior.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/13/00	[PB] Work around GCC thinks difference between unsigneds is unsigned. 
		11/09/00	[PB] Change initialization order to match declaration. 
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef __UKEYSELECTIONBEHAVIOR__
#include "UKeySelectionBehavior.h"
#endif

// MacApp

#ifndef __UEVENT__
#include "UEvent.h"
#endif

#ifndef __UEVENTHANDLER__
#include "UEventHandler.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

// Toolbox

#ifndef __LOWMEM__
#include <LowMem.h>
#endif


//========================================================================================
// CLASS TKeySelectionBehavior
//========================================================================================
#undef Inherited
#define Inherited TBehavior


MA_DEFINE_CLASS(TKeySelectionBehavior);

//----------------------------------------------------------------------------------------
// TKeySelectionBehavior constructor
//----------------------------------------------------------------------------------------


TKeySelectionBehavior::TKeySelectionBehavior(IDType itsIdentifier) :
	TBehavior(itsIdentifier),
#if !qMSWindows
	fTimeOutInterval(Min_AC(::LMGetKeyThresh(), static_cast<short>(255))),
#else
	fTimeOutInterval(20),
#endif
	// A note on LMGetKeyThresh: the key repeat rate typically ranges
	// from 12 ticks (short) to 40 ticks (long).  However, if key repeat
	// is turned off, LMGetKeyThresh returns SHRT_MAX.  To prevent an
	// fTimeOutInterval that high, we bound it at 255 ticks (about 4 seconds).
	fLastKeyUpTime(0)
{
}

//----------------------------------------------------------------------------------------
// TKeySelectionBehavior destructor
//----------------------------------------------------------------------------------------


TKeySelectionBehavior::~TKeySelectionBehavior()
{
}

//----------------------------------------------------------------------------------------
// TKeySelectionBehavior::DoKeyEvent: 
//----------------------------------------------------------------------------------------


void TKeySelectionBehavior::DoKeyEvent(TToolboxEvent* event)
{
	if (event->IsOptionKeyPressed() || event->IsControlKeyPressed() || 
	   event->GetText() < chSpace || event->GetText() == chFwdDelete)
		Inherited::DoKeyEvent(event);
	else
	{
		if (static_cast<long>(event->GetWhen() - fLastKeyUpTime) >= fTimeOutInterval)
			fKeySequence.Empty();
		fKeySequence += event->GetText();
		DoKeySelection(fKeySequence);
		fLastKeyUpTime = event->GetWhen();
	}
}

//----------------------------------------------------------------------------------------
// TKeySelectionBehavior::DoKeySelection: 
//----------------------------------------------------------------------------------------


void TKeySelectionBehavior::DoKeySelection(const CStr255_AC& keySequence)
{
	if (fOwner)
		fOwner->DoKeySelection(keySequence);
}

//----------------------------------------------------------------------------------------
// TKeySelectionBehavior::DoKeyUp: 
//----------------------------------------------------------------------------------------


void TKeySelectionBehavior::DoKeyUp(TToolboxEvent* event)
{
	if (event->IsOptionKeyPressed() || event->IsControlKeyPressed() || 
	   event->GetText() < chSpace || event->GetText() == chFwdDelete)
		Inherited::DoKeyUp(event);
	else
		fLastKeyUpTime = event->GetWhen();
}

//----------------------------------------------------------------------------------------
// TKeySelectionBehavior::SetTimeOutInterval: 
//----------------------------------------------------------------------------------------


void TKeySelectionBehavior::SetTimeOutInterval(long timeOutInterval)
{
	fTimeOutInterval = timeOutInterval;
}

//----------------------------------------------------------------------------------------
// End of UKeySelectionBehavior.cpp



/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		----- R10 -----
		03/26/96	Cleanup references to gEmptyString and ""
		03/25/96	TToolboxEvent::fCharacter is obsolete
							Made empty UAdorners constructors inline
		03/23/96	[1136794] (2-BYTE) (Prgomet) TKeySelectionBehavior.DoKeyUp() and DoKeyEvent() and é
		02/20/96	1326037 Removed unnecessary CStr255_AC construction from
							call to DoKeySelection in DoKeyEvent.
		----- 3.3 -----
		----- 3.3b1 -----
		 3/13/95	Change Free methods to destructors. 
*/