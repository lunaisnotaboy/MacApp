//----------------------------------------------------------------------------------------
// UMenuView.cpp
// Copyright � 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/04/01	Clean up string casting. 
		01/02/01	Update copyright.
		12/21/00	[W] Needed special case for Windows in TMenuView::Init. 
		11/27/00	Back out casting of gEmptyString--no longer needed.
		11/21/00	[PB] mChooseMsg not available in Mac OS X headers. 
		11/20/00	kMenuDrawItemsMsg isn't in the interfaces before 3.3.5. 
		11/16/00	Add support for theme-savvy menus and draw items message. 
		11/15/00	Provide a specific hook for tear off menus. 
					Use Carbon menu definition registration mechanism. 
		11/09/00	[PB] Change initialization order to match declaration. 
					Ticks are unsigned. 
					Use ImagingUtils instead of conditionalizing on qCarbon. 
					Remove unused variables in Focus. 
					Move pDebugMenuView into the function where it is used. 
					Remove unused WaitTickChange. 
		11/04/00	Cast gEmptyString for NewCWindow.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		10/16/00	View needs to get and cache the clip region for Carbon. 
		10/04/00	Return the possibly updated menuRect and simplify
					implementation of TMenuView::HandleDefproc.
		09/01/00	Changed pragma warning to pragma message.  Added some
					pragma unused's.  Cosmetic cleanup.  Removed Inherited.
		02/22/00	[W] Do not call MAGetMenu in TMenuView::TMenuView.
		10/21/99	Use IsMenuItemEnabled_AC() instead of #if qCarbon stuff.
		03/29/99	Rename Patterns_AC to CPattern_AC to avoid confusion with the
					include file. 
		03/24/99	Update copyright notice.
		03/22/99	[W] GetMCEntry not available.
		03/18/99	Removed '&' on parms to a variety of Toolbox calls.
		01/23/99	[C] Replace GetMenuItemEnabled with IsMenuItemEnabled.
		11/05/98	Carbon - use GetQDGlobalsScreenBits and SetPenPatToGray_AC
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					SetPort_AC, CTempGrafPort_AC.  Include ImagingUtils_AC.h and
					CTempGrafPort_AC.h.
		10/27/98	Carbonize
*/

#ifndef __UMENUVIEW__
#include "UMenuView.h"
#endif

// MacApp

#ifndef __UCOMMAND__
#include "UCommand.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UEVENT__
#include "UEvent.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPATCH__
#include "UPatch.h"
#endif

#ifndef __UPOINTEROBJECT__
#include "UPointerObject.h"
#endif

#ifndef PLATFORMMEMORY_H
#include "PlatformMemory.h"
#endif

// ACS

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __MenuUtils_AC__
#include "MenuUtils_AC.h"
#endif

// Toolbox

#ifndef __DIALOGS__
#include <Dialogs.h>
#endif

#if !qCarbon
	#ifndef __EDITIONS__
	#include <Editions.h>
	#endif
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

// ANSI

#if qDebugMsg
#endif

//----------------------------------------------------------------------------------------

bool TMenuView::CTrackingInMenu::fgTrackingInMenu;

//----------------------------------------------------------------------------------------
static WindowPtr pMenuCPort;
//���static CGrafPort pMenuCPort;				// Color port for compatibility. Private
                                            // grafPort used to focus the menu w/ o messing
                                            // up the Window Manager port.

static CList_AC* pMenuArray;				// Used to map a MenuRef to the TMenuView

#if qCarbon
enum { kViewMenuProc = 2000 };
static MenuDefUPP pMenuDefUPP;
#elif !qMSWindows
static Handle pCustDefproc;					// Replaces the menu's menuProc field 
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

static unsigned long Future(long delta);

//----------------------------------------------------------------------------------------
// Future: Returns the TickCount some time in the future. 
//----------------------------------------------------------------------------------------

unsigned long Future(long delta)
{
	return TickCount() + delta;
}

//----------------------------------------------------------------------------------------
// InitUMenuView: 
//----------------------------------------------------------------------------------------

void InitUMenuView()
{
	TMenuView::Init();
}

#if qCarbon
//========================================================================================
// struct CMNUHeader
//========================================================================================

#if PRAGMA_STRUCT_ALIGN
#pragma options align=mac68k
#endif

struct CMNUHeader
{
	short							menuID;
	short							menuWidth;
	short							menuHeight;
	short							menuProcID;
	short							filler;
	long							enableFlags;
	CStr255_AC						menuData;	// this is variable length and the array of menu items follows it directly
};

struct CMNUItemAttributes
{
	char							icon;
	char							keyEquivalent;
	char							mark;
	char							style;
};

#if PRAGMA_STRUCT_ALIGN
#pragma options align=reset
#endif

typedef CMNUHeader *CMNUHeaderPtr, **CMNUHeaderHandle;

static MenuRef CustomGetAndConvertCMNU(ResNumber menuResID);
static MenuRef CustomConvertToMenu(Handle CMNUHandle, bool addCommandsToCommandTable);
static MenuRef CustomNewIconMenu(short menuID, short menuProcID, ConstStr255Param menuTitle);
static MenuRef CustomNewMenu(short menuID, short menuProcID, ConstStr255Param menuTitle);

//----------------------------------------------------------------------------------------
// CustomGetMenu
//----------------------------------------------------------------------------------------

static MenuRef CustomGetMenu(MenuID menuID)
{
	// Check to see if already installed in the menubar
	MenuRef theMenuRef = TMenuBarManager::GetMenuHandle(menuID);
		// do this first ... the menu is likely to
		// be in the menubar and more likely of
		// success, hence, faster

	if (!theMenuRef)
	{
//		// OK... is it in the list?
//		ArrayIndex_AC index = kEmptyIndex_AC;
//		theMenuRef = DoSearch(TestID, reinterpret_cast<void*>(menuID), index);

//		// wasn't there. Try to load MENU and failing that, a CMNU
//		if (!theMenuRef)
		{
			//theMenuRef = TMenuIDList::GetAndConvertMENU(menuID);
			theMenuRef = ::MacGetMenu(CMultiLocale_AC::GetExistingResourceID('MENU', menuID));

			if (!theMenuRef)
				theMenuRef = CustomGetAndConvertCMNU(menuID);

			if (theMenuRef && (GetMenuID_AC(theMenuRef) > 0))
				TMenuIDList::InsertInMenuTable(theMenuRef, GetMenuID_AC(theMenuRef));
		}
	}

	return theMenuRef;
}

//----------------------------------------------------------------------------------------
// CustomGetAndConvertCMNU:
//----------------------------------------------------------------------------------------

static MenuRef CustomGetAndConvertCMNU(ResNumber menuResID)
{
	MenuRef newMenu = NULL;

	if (menuResID != kNoResource_AC)
	{
		Handle aCMNUHandle = CMultiLocale_AC::GetResource('CMNU', menuResID);
		if (aCMNUHandle)
		{
			HNoPurge(aCMNUHandle);					// If it was purgeable it might squirt away

			short menuID = (*(CMNUHeaderHandle)aCMNUHandle)->menuID;
			if (menuID > 0)// not in reserved range
			{
				// load the menudef and store its reference in the menu
				newMenu = CustomConvertToMenu(aCMNUHandle, true);

				// Since only GetMenu automatically loads the appropriate color information,
				// and (sigh) since we can only call GetMenu once, and if you call DeleteMenu
				// all the good color stuff goes away (double sigh) we'll have to help out
				// the Menu Manager by doing its job for it

				// n.b. This is using the menuID of the menu as a resource ID, which is incorrect
				MenuCRsrcHandle theColorRsrc = (MenuCRsrcHandle)CMultiLocale_AC::GetResource('mctb', menuResID);
				if (theColorRsrc)
				{
					{ // Extra block to destroy handlelocker before releasersrc
						CTempHandleLock_AC tempHandleLock((Handle)theColorRsrc);
						SetMCEntries((*theColorRsrc)->numEntries, &((*theColorRsrc)->mcEntryRecs[0]));
					}
					ReleaseResource((Handle)theColorRsrc);
				}
			}
			::ReleaseResource(aCMNUHandle);		// won't be needing this since it's we have a MENU now (if we're using it)
		}
	}
	return newMenu;
}

//----------------------------------------------------------------------------------------
// CustomConvertToMenu
//----------------------------------------------------------------------------------------

static MenuRef CustomConvertToMenu(Handle CMNUHandle, bool addCommandsToCommandTable)
{
	MenuRef theMenuRef = NULL;

	CTempHandleLock_AC tempHandleLock(CMNUHandle);
	CMNUHeader* theCMNUHeader = reinterpret_cast<CMNUHeaderPtr>(StripLong(*CMNUHandle));

	MenuID menuID = theCMNUHeader->menuID;

	theMenuRef = CustomNewIconMenu(menuID, theCMNUHeader->menuProcID, theCMNUHeader->menuData);

//	if (theCMNUHeader->enableFlags != kEnablingManagedByMacApp) // it is specialized
//		(*theMenuRef)->enableFlags = theCMNUHeader->enableFlags;

	StringPtr theCMNUPtr = reinterpret_cast<StringPtr>(&theCMNUHeader->menuData) + theCMNUHeader->menuData.Length() + 1;

	short itemNo = 0;

	StringPtr endPtr = reinterpret_cast<StringPtr>(theCMNUHeader) + GetHandleSize(CMNUHandle);
	while (theCMNUPtr < endPtr && *theCMNUPtr) // non empty string
	{
		++itemNo;
		//const CStr2_AC aBlank = " "; // Must be at least non-empty
		::MacAppendMenu(theMenuRef, "\p ");

		// Set the text this way to defeat metacharacter processing
		SetMenuItemText(theMenuRef, itemNo, theCMNUPtr);
		theCMNUPtr += theCMNUPtr[0] + 1;

		CMNUItemAttributes& theCMNUAttributes = *(CMNUItemAttributes*)theCMNUPtr;
		if (theCMNUAttributes.icon)
			SetItemIcon(theMenuRef, itemNo, theCMNUAttributes.icon);

		if (theCMNUAttributes.keyEquivalent)
			SetItemCmd(theMenuRef, itemNo, theCMNUAttributes.keyEquivalent);

		if (theCMNUAttributes.mark)
			SetItemMark(theMenuRef, itemNo, theCMNUAttributes.mark);

		if (theCMNUAttributes.style)
			SetItemStyle(theMenuRef, itemNo, theCMNUAttributes.style);

		theCMNUPtr += sizeof(CMNUItemAttributes);

		if (::Odd_AC(theCMNUPtr))// word align
			++theCMNUPtr;

		if (addCommandsToCommandTable)
			AddCommand(*reinterpret_cast<CommandNumber*>(theCMNUPtr), menuID, itemNo);

		theCMNUPtr += sizeof(CommandNumber);
	}

	return theMenuRef;
}

//----------------------------------------------------------------------------------------
// CustomNewIconMenu
//----------------------------------------------------------------------------------------

static MenuRef CustomNewIconMenu(short menuID, short menuProcID, ConstStr255Param menuTitle)
{
	/*
		Looks for a menu title of "#nnn" where nnn is the id of an icon suite,
		represented in text form so it is easy to enter in a resource editor.
		If the icon suite can be loaded, the menu is created with the icon for
		its title. Otherwise, the menu is created with a normal title string.
	*/

	MenuRef theMenuRef = NULL;

	// Could be an icon suite resource id
	if ((menuTitle[0] > 1) && (menuTitle[1] == '#'))
	{
		// Convert to a number
		Str15 iconMenuTitle;
		iconMenuTitle[0] = menuTitle[0] - 1;
		if (iconMenuTitle[0] > 15)
			iconMenuTitle[0] = 15;
		BlockMove_AC(&menuTitle[2], &iconMenuTitle[1], iconMenuTitle[0]);
		long iconID = 0;
		StringToNum(iconMenuTitle, &iconID);

#if !qMSWindows
		// Load the icon suite
		Handle iconSuite = NULL;
		::GetIconSuite(&iconSuite, iconID, svAllSmallData);
		if (iconSuite)
		{
			// Create the menu with an icon title
			iconMenuTitle[0] = 5;
			iconMenuTitle[1] = 0x01;
			*(long *)&iconMenuTitle[2] = (long)iconSuite;
			theMenuRef = CustomNewMenu(menuID, menuProcID, iconMenuTitle);
		}
#endif
	}

	// Create the menu with a text title
	if (!theMenuRef)
		theMenuRef = CustomNewMenu(menuID, menuProcID, menuTitle);

	return theMenuRef;
}

//----------------------------------------------------------------------------------------
// CustomNewMenu
//----------------------------------------------------------------------------------------

static MenuRef CustomNewMenu(short menuID, short menuProcID, ConstStr255Param menuTitle)
{
	MenuRef theMenuRef = NULL;

#if qCarbon
	if (menuProcID == kViewMenuProc)
	{
		if (!pMenuDefUPP)
			pMenuDefUPP = NewMenuDefUPP(TMenuView::MenuDefproc);

		MenuDefSpec spec;
		spec.defType = kMenuDefProcPtr;
		spec.u.defProc = pMenuDefUPP;

		ThrowIfOSErr_AC(CreateCustomMenu(&spec, menuID, 0, &theMenuRef));
		SetMenuTitle(theMenuRef, menuTitle);
	}
	else
#endif
	{
		theMenuRef = NewMenu(menuID, menuTitle);
		ThrowIfNULL_AC(theMenuRef);
	}

	return theMenuRef;
}

#endif // qCarbon


//========================================================================================
// CLASS TMenuView
//========================================================================================

MA_DEFINE_CLASS(TMenuView);

//----------------------------------------------------------------------------------------
// TMenuView::FindTMenuView: 
//----------------------------------------------------------------------------------------

TMenuView* TMenuView::FindTMenuView(MenuRef theMenu)
{
	TMenuView* returnVal = NULL;

	if (pMenuArray)
	{
		for (TemplateIterator_AC<TMenuView*> iter(pMenuArray); iter; ++iter)
		{
			if ((*iter).fMenuRef == theMenu)
			{
				returnVal = iter;
				break;
			}
		}
	}

	return returnVal;
}

#if !qMSWindows

//----------------------------------------------------------------------------------------
// MenuDefproc: Called by the MDEF resource. 
//----------------------------------------------------------------------------------------

pascal void TMenuView::MenuDefproc(short message,
								   MenuHandle theMenu,
								   Rect *menuRect,
								   Point hitPt,
								   short *whichItem)
{
#if !qCarbon
	long OldA5 = SetCurrentA5();				// ***** Called from trap patches *****
#endif
	
	try
	{
		TMenuView* menuObj = FindTMenuView(theMenu);
		if (menuObj)
		{
			CPoint_AC fixedHitPt(hitPt);
			if (message == mPopUpMsg)
			{	// The hitPt is not a point; its coordinates are switched (see TN#172).
				fixedHitPt.h = hitPt.v;
				fixedHitPt.v = hitPt.h;
			}
		
			// Dispatch to the TMenuView object 
			menuObj->HandleDefproc(message, theMenu, menuRect, fixedHitPt, whichItem);
		}
#if qDebug
#if qCarbon
		else if (message == kMenuInitMsg)
		{
		}
		else if (message == kMenuDisposeMsg)
		{
		}
#endif
		else
			ProgramBreak_AC("MenuDefproc called with no TMenuView object");
#endif
	}
	catch (...)
	{
		// Catch all exceptions and prevent them from propagating through the callback. 
	}
	
#if !qCarbon
	SetA5(OldA5);
#endif
}

#endif // !qMSWindows

//----------------------------------------------------------------------------------------
// TMenuView::Init: 
//----------------------------------------------------------------------------------------

void TMenuView::Init()
{
	CRect_AC boundsRect = ScreenBounds_AC();
	pMenuCPort = NewCWindow(NULL, &boundsRect, gEmptyString,
							false, documentProc, NULL, false, 0);
	::ThrowIfNULL_AC(pMenuCPort);
	
#if qCarbon
	if (!pMenuDefUPP)
		pMenuDefUPP = NewMenuDefUPP(MenuDefproc);

	MenuDefSpec spec;
	spec.defType = kMenuDefProcPtr;
	spec.u.defProc = pMenuDefUPP;

	ThrowIfOSErr_AC(RegisterMenuDefinition(kViewMenuProc, &spec));
#elif qPowerPC
	RoutineDescriptorHandle h =
		(RoutineDescriptorHandle)NewPermHandle(sizeof(RoutineDescriptor));
	
	RoutineDescriptor aMDEFUPP = BUILD_ROUTINE_DESCRIPTOR(uppMenuDefProcInfo, MenuDefproc);
	
	BlockMove(&aMDEFUPP, *h, sizeof(RoutineDescriptor)); // leave BlockMove so cache flushes
	
	pCustDefproc = (Handle) h;
#elif q68K
	JmpInstructionTemplate** h =
		(JmpInstructionTemplate**) NewPermHandle(sizeof(JmpInstructionTemplate));
	PatchJmpInstruction(*h, reinterpret_cast<void*>(StripLong(MenuDefproc)));
	
	pCustDefproc = (Handle) h;
#else
	#pragma message("TMenuView::Init: need support for this platform")
#endif
}

//----------------------------------------------------------------------------------------
// TMenuView constructor
//----------------------------------------------------------------------------------------

TMenuView::TMenuView(ResNumber rsrcID,
					 short menuWidth,
					 short menuHeight)
	:	TView(gZeroVPt, CViewPoint(menuWidth, menuHeight), sizeVariable, sizeVariable),
		fNextFlash(0),
		fMenuRef(NULL),
		fFlashInterval(-1),
		fHighlighted(false)
{
	fNextHandler = gDispatcher;				// so postcommand flows to the app 

#if qMSWindows
	#pragma message("TMenuView::TMenuView: wants to call MAGetMenu, which currently isn't available under Windows.")
#else
	if (rsrcID != kNoResource)
	{
#if qCarbon
		// Read in menu
		fMenuRef = CustomGetMenu(rsrcID);
		ThrowIfNULLResource_AC((Handle)fMenuRef);
#else
		// Read in menu and set its defproc 
		MenuRef m = MAGetMenu(rsrcID);
		ThrowIfNULLResource_AC((Handle)m);

		(*m)->menuProc = pCustDefproc;
		fMenuRef = m;
#endif // qCarbon

		if (!pMenuArray)
			pMenuArray = NewList_AC();

		pMenuArray->Insert(this);

		short item = 0;
		CRect_AC itsRect;
		MenuDefproc(mSizeMsg, fMenuRef, itsRect, gZeroPt, &item);// recompute the menu size 
	}
#endif // qMSWindows
}

//----------------------------------------------------------------------------------------
// TMenuView destructor
//----------------------------------------------------------------------------------------

TMenuView::~TMenuView()
{
	if (pMenuArray)
		pMenuArray->Delete(this);
}

//----------------------------------------------------------------------------------------
// TMenuView::FindItem: 
//----------------------------------------------------------------------------------------

short TMenuView::FindItem(CPoint_AC hitPt)
{
#pragma unused (hitPt)

	return 0;
}

//----------------------------------------------------------------------------------------
// TMenuView::HandleDefproc: 
//----------------------------------------------------------------------------------------

void TMenuView::HandleDefproc(short			message,
							  MenuHandle	theMenu,
							  Rect*			menuRectPtr,
							  Point			hitPt,
							  short*		whichItem)
{
#if qDebugMsg
	static bool pDebugMenuView;
#endif

//	ThrowIfNULL_AC(menuRectPtr);	// The assumption is that we have a valid pointer to a
//									// rect here since the original implementation of this function
//									// was inconsistent in checking the validity of this pointer
//									// before dereferencing it.

	// Save the wmgr port && set our private port 
	CTempGrafPort_AC	savePort(pMenuCPort);
	CRect_AC aMenuRect;
	if (menuRectPtr)
		aMenuRect = *menuRectPtr;
	else
		aMenuRect = GetExtent().AsRect();

	// Match the location and size that the menu mgr gives us 
	if ((message == mDrawMsg) ||
#if qCarbon
		(message == kMenuFindItemMsg) || (message == kMenuHiliteItemMsg))
#else
		(message == mChooseMsg))
#endif
	{
		MovePortTo(aMenuRect.left, aMenuRect.top);
		PortSize(aMenuRect.Width(), aMenuRect.Height());
		fLocation.v = aMenuRect.top;
		fLocation.h = aMenuRect.left;
	}

	fShown = true;	// menu is pulled down
	InvalidateCoordinates();

	if (Focus())
	{
		::GlobalToLocal(&hitPt);
		::GlobalToLocal(aMenuRect[topLeft]);
		::GlobalToLocal(aMenuRect[botRight]);

#if qCarbon
		SetEnable(IsMenuItemEnabled(theMenu, 0));
#else
		SetEnable((((*theMenu)->enableFlags) & 1) != 0);
#endif
		switch (message)
		{
			case mDrawMsg:
#if qDebugMsg
				if (pDebugMenuView)
					ProgramReport_AC("TMenuView mDrawMsg(0x%0x, %s)", (unsigned long)theMenu, aMenuRect.AsText().c_str());
#endif
				HandleDrawMessage(theMenu, aMenuRect);
				break;
					
#if qCarbon
#if UNIVERSAL_INTERFACES_VERSION >= 0x0335
			case kMenuDrawItemsMsg:
				{
#if qDebugMsg
					if (pDebugMenuView)
						ProgramReport_AC("TMenuView kMenuDrawItemsMsg(0x%0x, %s)", (unsigned long)theMenu, aMenuRect.AsText().c_str());
#endif
					MDEFDrawItemsData* drawItemsData = reinterpret_cast<MDEFDrawItemsData*>(whichItem);
					HandleDrawMessage(theMenu, aMenuRect);
				}
				break;
#endif // UNIVERSAL_INTERFACES_VERSION >= 0x0335
					
			case kMenuFindItemMsg:
#if qDebugMsg
				if (pDebugMenuView)
					ProgramReport_AC("TMenuView kMenuFindItemMsg(0x%0x, %s, %s, MenuTrackingData)", (unsigned long)theMenu, aMenuRect.AsText().c_str(), CPoint_AC(hitPt).AsText().c_str());
#endif
				HandleFindItemMessage(theMenu, aMenuRect, hitPt, *reinterpret_cast<MenuTrackingData*>(whichItem));
				break;

			case kMenuHiliteItemMsg:
#if qDebugMsg
				if (pDebugMenuView)
					ProgramReport_AC("TMenuView kMenuHiliteItemMsg(0x%0x, %s, %s, HiliteMenuItemData)", (unsigned long)theMenu, aMenuRect.AsText().c_str(), CPoint_AC(hitPt).AsText().c_str());
#endif
				HandleHiliteItemMessage(theMenu, aMenuRect, hitPt, *reinterpret_cast<HiliteMenuItemData*>(whichItem));
				break;
#else
			case mChooseMsg:
#if qDebugMsg
				if (pDebugMenuView)
					ProgramReport_AC("TMenuView mChooseMsg(0x%0x, %s, %s, %d)", (unsigned long)theMenu, aMenuRect.AsText().c_str(), CPoint_AC(hitPt).AsText().c_str(), *whichItem);
#endif
				HandleChooseMessage(theMenu, aMenuRect, hitPt, *whichItem);
				break;
#endif // !qCarbon
					
			case mSizeMsg:
#if qDebugMsg
				if (pDebugMenuView)
					ProgramReport_AC("TMenuView mSizeMsg(0x%0x)", (unsigned long)theMenu);
#endif
				HandleSizeMessage(theMenu);
				break;
					
			case mPopUpMsg:
#if qDebugMsg
				if (pDebugMenuView)
					ProgramReport_AC("TMenuView mPopUpMsg(0x%0x, %s, %s)", (unsigned long)theMenu, aMenuRect.AsText().c_str(), CPoint_AC(hitPt).AsText().c_str());
#endif
				HandlePopUpMessage(theMenu, aMenuRect, hitPt);
				break;

			case kMenuThemeSavvyMsg:
#if qDebugMsg
				if (pDebugMenuView)
					ProgramReport_AC("TMenuView kMenuThemeSavvyMsg");
#endif
				*whichItem = kThemeSavvyMenuResponse;
				break;

#if qDebugMsg
			default:
				if (pDebugMenuView)
					ProgramReport_AC("TMenuView Unknown message %d", message);
				break;
#endif
		}

		if (menuRectPtr)
			*menuRectPtr = LocalToGlobal(aMenuRect.AsRect()).AsRect();

		InvalidateFocus();
	}

	fShown = false;	// menu is no longer pulled down
}

//----------------------------------------------------------------------------------------
// TMenuView::HandleTracking
//----------------------------------------------------------------------------------------

short TMenuView::HandleTracking(MenuRef theMenu, CRect_AC& menuRect, CPoint_AC hitPt)
{
	short newItem = kNoMenuItem;

	// so that trackers get a chance to know that they're tracking in menus 
	CTrackingInMenu saveTrackingInMenu;

	if (IsEnabled())							// menu enabled 
	{
		// see if CPoint_AC is within hit area 
		CRect_AC hitRect = GetQDExtent() + fBorder;

		if (hitRect.Contains(hitPt))			// in menu (not border) 
		{
			// NOTE: Either your subclass of TTearOffMenu should override DoMouseCommand
            // or one of TTearOffMenu's view's subview's should override DoMouseCommand so
            // that it creates and posts a TTracker. TTearOffMenu's override of
            // PostCommand will ensure that the tracker is tracked immediately. The
            // tracker, having been posted and tracked, will then get executed next time
            // PerformCommand is called. So, when we're done with HandleMouseDown below,
            // we simply tell the menu manager that no menu item was selected, ie
            // newItem == kNoMenuItem.

			EventRecord theEventRecord;
			theEventRecord.what = mouseDown;
			theEventRecord.message = 0;
			theEventRecord.when = TickCount();
			theEventRecord.where = hitPt;
			theEventRecord.modifiers = 0;
			
			if (Button())
				theEventRecord.modifiers |= btnState;
				
			if (IsCommandKeyDown())
				theEventRecord.modifiers |= cmdKey;
				
			if (IsOptionKeyDown())
				theEventRecord.modifiers |= optionKey;
				
			TToolboxEvent event(NULL, &theEventRecord);
			event.SetClickCount(gDispatcher->GetClickCount());
			event.SetAffectsMenus(false);

			if (!HandleMouseDown(hitPt, &event, GetStdHysteresis()))
			{
				// NOTE: for backwards compatibility with MacApp 2.0 - override your
				// TMenuView subclass' HandleMouseDown method to return false, and all
				// should work as before
				newItem = FindItem(hitPt);
			}
		}
		else
			HandleTearOff(theMenu, menuRect, hitPt);
	}

	// Tell MenuManager about new item 
	return newItem;
}

//----------------------------------------------------------------------------------------
// TMenuView::HandleTearOff
//----------------------------------------------------------------------------------------

void TMenuView::HandleTearOff(MenuRef theMenu, CRect_AC& menuRect, CPoint_AC hitPt)
// HandleTearOff is provided as a hook for subclasses to override if they want to handle
// tracking outside the menu. 
{
#pragma unused (theMenu, menuRect, hitPt)
}

#if qCarbon
//----------------------------------------------------------------------------------------
// TMenuView::HandleFindItemMessage: 
//----------------------------------------------------------------------------------------

void TMenuView::HandleFindItemMessage(MenuRef theMenu,
									  CRect_AC& menuRect,
									  CPoint_AC hitPt,
									  MenuTrackingData& trackingData)
{
	trackingData.itemSelected = HandleTracking(theMenu, menuRect, hitPt);
}

//----------------------------------------------------------------------------------------
// TMenuView::HandleHiliteItemMessage: 
//----------------------------------------------------------------------------------------

void TMenuView::HandleHiliteItemMessage(MenuRef theMenu,
										CRect_AC& menuRect,
										CPoint_AC hitPt,
										HiliteMenuItemData& hiliteData)
{
	#pragma unused (theMenu, menuRect, hitPt)

	UpdateHighlight(hiliteData.previousItem, hiliteData.newItem);
}

#else
//----------------------------------------------------------------------------------------
// TMenuView::HandleChooseMessage: 
//----------------------------------------------------------------------------------------

void TMenuView::HandleChooseMessage(MenuRef		theMenu,
									CRect_AC&	menuRect,
									CPoint_AC	hitPt,
									short&		whichItem)
{
	short newItem = HandleTracking(theMenu, menuRect, hitPt);

	UpdateHighlight(whichItem, newItem);	// Update highlighting 

	// Tell MenuManager about new item 
	whichItem = newItem;
}

#endif // qCarbon

//----------------------------------------------------------------------------------------
// TMenuView::HandleDrawMessage: 
//----------------------------------------------------------------------------------------

void TMenuView::HandleDrawMessage(MenuRef	theMenu,
								  CRect_AC&	menuRect)
{
	#pragma unused (theMenu, menuRect)

	DrawContents();
	fHighlighted = false;
	if (!IsEnabled())
	{
		CPattern_AC::SetPenPatToGray();
		::PenMode(notSrcBic);
		::PaintRect(GetQDExtent());
	}
}

//----------------------------------------------------------------------------------------
// TMenuView::HandleSizeMessage: 
//----------------------------------------------------------------------------------------

void TMenuView::HandleSizeMessage(MenuRef theMenu)
{
	CViewRect vr(GetFrame());
	ComputeFrame(vr);
#if !qCarbon
	(*theMenu)->menuWidth = static_cast<short>(vr.GetLength(hSel));
	(*theMenu)->menuHeight = static_cast<short>(vr.GetLength(vSel));
#else
	::SetMenuWidth(theMenu, static_cast<short>(vr.GetLength(hSel)));
	::SetMenuHeight(theMenu, static_cast<short>(vr.GetLength(vSel)));
#endif
}

//----------------------------------------------------------------------------------------
// TMenuView::HandlePopUpMessage: 
//----------------------------------------------------------------------------------------

void TMenuView::HandlePopUpMessage(MenuRef		theMenu,
								   CRect_AC&	menuRect,
								   CPoint_AC	hitPt)
{
	#pragma unused (theMenu)

	CViewRect vr(GetExtent());
	ComputeFrame(vr);
	menuRect = ViewToQD(vr) + hitPt;
}

//----------------------------------------------------------------------------------------
// TMenuView::Highlight: 
//----------------------------------------------------------------------------------------

void TMenuView::Highlight(short, bool)
{
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TMenuView::IsItemEnabled: 
//----------------------------------------------------------------------------------------

bool TMenuView::IsItemEnabled(short item)
{
	return IsMenuItemEnabled_AC(fMenuRef, item);
}

//----------------------------------------------------------------------------------------
// TMenuView::GetMenuViewColors: 
//----------------------------------------------------------------------------------------

void TMenuView::GetMenuViewColors(ResNumber theMenu,
								  short theItem,
								  MenuColors& theMenuColors)
{
#if qMSWindows
	#pragma unused (theMenu, theItem, theMenuColors)
	#pragma message ("TMenuView::GetMenuViewColors: Not implemented in Windows.")
#else
	enum TypeOfMenuInfo { aMenuItem, aMenuTitle, aMenuBar, noType };


	MCEntryPtr aMCEntryPtr;
	TypeOfMenuInfo typeOfRequest;
	TypeOfMenuInfo typeOfEntryFound;
	ResNumber theEntryMenu = theMenu;
	short theEntryItem = theItem;

	if (theItem)
		typeOfRequest = aMenuItem;
	else if (theMenu)
		typeOfRequest = aMenuTitle;
	else
		typeOfRequest = aMenuBar;

	aMCEntryPtr = GetMCEntry(theEntryMenu, theEntryItem);
	if (!aMCEntryPtr)				// not found, try as title 
	{
		theEntryItem = 0;
		aMCEntryPtr = GetMCEntry(theEntryMenu, theEntryItem);
		if (!aMCEntryPtr)			// not found, try as menubar 
		{
			theEntryMenu = 0;
			aMCEntryPtr = GetMCEntry(theEntryMenu, theEntryItem);
		}
	}

	if (!aMCEntryPtr)
		typeOfEntryFound = noType;
	else
	{
		if (theEntryItem)
			typeOfEntryFound = aMenuItem;
		else if (theEntryMenu)
			typeOfEntryFound = aMenuTitle;
		else
			typeOfEntryFound = aMenuBar;
	}

	switch (typeOfEntryFound)
	{
		case aMenuItem:
			theMenuColors.itemColor = (*aMCEntryPtr).mctRGB1;
			theMenuColors.backgroundColor = (*aMCEntryPtr).mctRGB4;
			theMenuColors.markColor = (*aMCEntryPtr).mctRGB1;
			theMenuColors.commandColor = (*aMCEntryPtr).mctRGB1;
			break;
				
		case aMenuTitle:
			switch (typeOfRequest)
			{
				case aMenuItem:
					{
						theMenuColors.itemColor = (*aMCEntryPtr).mctRGB3;
						theMenuColors.backgroundColor = (*aMCEntryPtr).mctRGB4;
						theMenuColors.markColor = (*aMCEntryPtr).mctRGB3;
						theMenuColors.commandColor = (*aMCEntryPtr).mctRGB3;
						break;
					}
				case aMenuTitle:
					{
						theMenuColors.itemColor = (*aMCEntryPtr).mctRGB1;
						theMenuColors.backgroundColor = (*aMCEntryPtr).mctRGB2;
						theMenuColors.markColor = (*aMCEntryPtr).mctRGB1;
						theMenuColors.commandColor = (*aMCEntryPtr).mctRGB1;
						break;
					}
			}
			break;
			
		case aMenuBar:
			switch (typeOfRequest)
			{
				case aMenuItem:
					theMenuColors.itemColor = (*aMCEntryPtr).mctRGB3;
					theMenuColors.backgroundColor = (*aMCEntryPtr).mctRGB2;
					theMenuColors.markColor = (*aMCEntryPtr).mctRGB3;
					theMenuColors.commandColor = (*aMCEntryPtr).mctRGB3;
					break;
					
				case aMenuTitle:
					theMenuColors.itemColor = (*aMCEntryPtr).mctRGB1;
					theMenuColors.backgroundColor = (*aMCEntryPtr).mctRGB4;
					theMenuColors.markColor = (*aMCEntryPtr).mctRGB1;
					theMenuColors.commandColor = (*aMCEntryPtr).mctRGB1;
					break;
					
				case aMenuBar:
					theMenuColors.itemColor = (*aMCEntryPtr).mctRGB1;
					theMenuColors.backgroundColor = (*aMCEntryPtr).mctRGB4;
					theMenuColors.markColor = (*aMCEntryPtr).mctRGB1;
					theMenuColors.commandColor = (*aMCEntryPtr).mctRGB1;
					break;

				case noType:
					break;
			}
			break;
			
		case noType:
			theMenuColors.itemColor = gRGBBlack;
			theMenuColors.backgroundColor = gRGBWhite;
			theMenuColors.markColor = gRGBBlack;
			theMenuColors.commandColor = gRGBBlack;
			break;
	}
#endif
}

//----------------------------------------------------------------------------------------
// TMenuView::UpdateHighlight: 
//----------------------------------------------------------------------------------------

void TMenuView::UpdateHighlight(short oldItem, short newItem)
{
	// Update highlighting 
	if (newItem == oldItem)
	{
		if (fFlashInterval >= 0)
			if (TickCount() > fNextFlash)
			{
				fHighlighted =!fHighlighted;
				Highlight(oldItem, fHighlighted);
				fNextFlash = Future(fFlashInterval);
			}
	}
	else
	{
		if (fHighlighted)
			if (oldItem != kNoMenuItem)
				Highlight(oldItem, false);

		fHighlighted = (newItem != kNoMenuItem);
		if (fHighlighted)
			Highlight(newItem, true);

		if (fFlashInterval >= 0)
			fNextFlash = Future(fFlashInterval);
	}
}

//----------------------------------------------------------------------------------------
// TMenuView::Focus: 
//----------------------------------------------------------------------------------------

bool TMenuView::Focus()
{
	bool returnVal = false;

	if (TView::Focus())
	{
		// Try to make the best match for the menu colors without requiring programmer
        // intervention. by setting the color environment to be for items.

		MenuColors theMenuColors;
		GetMenuViewColors(GetMenuID_AC(fMenuRef), 1, theMenuColors);	// Carbonized
		SetIfColor(theMenuColors.itemColor);
		SetIfBkColor(theMenuColors.backgroundColor);
		returnVal = true;
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TMenuView::IsShown: 
//----------------------------------------------------------------------------------------

bool TMenuView::IsShown() const
{
	// Menu views do not always have superviews...
	return fSuperView ? TView::IsShown() : fShown;
}

//----------------------------------------------------------------------------------------
// TMenuView::IsActive: 
//----------------------------------------------------------------------------------------

bool TMenuView::IsActive() const
{
	return true;							// if we are asking then we are active
}

//----------------------------------------------------------------------------------------
// TMenuView::FocusOnSuperView: 
//----------------------------------------------------------------------------------------

bool TMenuView::FocusOnSuperView()
{
	if (!IsShown())							// don't focus if the menuView isn't pulled down
		return false;

	::SetPort_AC(pMenuCPort);
	
	CPoint_AC qdOrigin(GetQDOrigin());
	SetOrigin(qdOrigin.h, qdOrigin.v);

#if !qCarbon
	ClipRect(&(pMenuCPort->portRect));
	(*pMenuCPort->visRgn)->rgnBBox = pMenuCPort->portRect;
#else
	CGrafPtr menuCPort = ::GetWindowPort(pMenuCPort);
	CRect_AC menuCPortRect(GetPortRect_AC(menuCPort));
	::ClipRect(menuCPortRect);
	RgnHandle menuCPortRgn = ::NewRgn();	// Can't use temporary region
	::RectRgn(menuCPortRgn, menuCPortRect);
	::SetPortVisibleRegion(menuCPort, menuCPortRgn);
#endif

	return true;
}

//----------------------------------------------------------------------------------------
// TMenuView::GetGrafPort: 
//----------------------------------------------------------------------------------------

GrafPtr TMenuView::GetGrafPort() const
{
#if !qCarbon
	return pMenuCPort;
#else
	return ::GetWindowPort(pMenuCPort);	// pMenuCPort is a WindowPtr; need a CGrafPtr
#endif
}

#if qCarbon
//----------------------------------------------------------------------------------------
// TMenuView::GetClipRegion: 
//----------------------------------------------------------------------------------------

RgnHandle TMenuView::GetClipRegion()
{
	// Use our special Carbon region handle
	if (!fCarbonClipRegion)
		fCarbonClipRegion = ::NewRgn();

	return ::GetPortClipRegion(GetGrafPort(), fCarbonClipRegion);
}
#endif

//----------------------------------------------------------------------------------------
// End of UMenuView.cpp



/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		----- R10 -----
		 3/18/96	Made better use of TView calls that return CRect_AC/CViewPoint/CViewRect
		  3/4/96	Remove obsolete #pragma push/trace off/pop 
		 12/8/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		----- 3.3b1 -----
		 7/31/95	Don't need to specify kDragOrClick for HandleMouseDown. 
		 7/31/95	ClickThrough: HandleMouseDown takes EMouseDownType param.
		 7/28/95	Add configuration functions to use instead of gConfiguration. 
		 5/16/95	MenuRef
		03/27/95	CW 5.5 thinks address of CPoint_AC is being passed.
		 3/18/95	Corrected typo in volatile statement. 
		 3/17/95	MAVolatile. UpdateCoordinates. 
		 3/13/95	Change Free methods to destructors. 
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		02/13/95	make "p" (private) globals static 
		02/13/95	Remove unnecessary initialization of static variables. See ARM �8.4 
		02/07/95	Create missing prototypes for static functions used internally. 
*/