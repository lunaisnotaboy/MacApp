//----------------------------------------------------------------------------------------
// UBeveledTargetBorderView.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		10/16/00	Only draw focus highlight in DoHighlightSelection if we focus.
		09/22/00	Improved graphics device iterator. 
		09/01/00	Stripped dead code.  Removed Inherited.  Other cosmetic.
		07/12/00	Correct notch calculation in TTargetBorderFrameView.
		12/27/99	Minor cosmetic cleanup.
		12/08/99	GetExtentRegion is now const.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		03/23/99	Go back to native Toolbox region and rect calls.
		03/22/99	[W] Can't call DrawThemeFocusRect/Region.
		10/29/98	[W] Use kThemeStateDisabled instead of kThemeStateInactive. 
					Use PaintRgn_AC.
		10/28/98	Use InsetRect_AC instead of InsetRect.  Include ImagingUtils_AC.h.
*/

#ifndef __UBEVELEDTARGETBORDERVIEW__
#include "UBeveledTargetBorderView.h"
#endif

// ACS

#ifndef __CCustomControl_AC__
#include "CCustomControl_AC.h"
#endif

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __AGA_AC__
#include "AGA_AC.h" // for EmulateControls_AC
#endif

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

// MacApp

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUBeveledTargetBorderView
//----------------------------------------------------------------------------------------

void InitUBeveledTargetBorderView()
{
	//
	// Register all of the classes defined here. If you prefer, you can
	// selectively register just the classes you will use.
	//
	static bool UBeveledTargetBorderViewInitialized;

	if (!UBeveledTargetBorderViewInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TBeveledTargetBorderView, kStdBeveledTargetBorderView);
			REGISTER_SIGNATURE_AC(TNotchedTargetBorderView, kStdNotchedTargetBorderView);
			REGISTER_SIGNATURE_AC(TTargetBorderFrameView, kStdTargetBorderFrameView);
			REGISTER_SIGNATURE_AC(TNotchedTargetBorderFrameView, kStdNotchedTargetBorderFrameView);
			REGISTER_SIGNATURE_AC(TNotchedView, kStdNotchedView);
			REGISTER_SIGNATURE_AC(TControlFocusAdorner, kStdControlFocusAdorner);
		}
		UBeveledTargetBorderViewInitialized = true;
	}
}

//========================================================================================
// CLASS TControlFocusAdorner
//========================================================================================

MA_DEFINE_CLASS(TControlFocusAdorner);

//----------------------------------------------------------------------------------------
// TControlFocusAdorner::TControlFocusAdorner
//----------------------------------------------------------------------------------------

TControlFocusAdorner::TControlFocusAdorner()
	:	TAdorner(kStdControlFocusAdorner, kFreeOnDeletion, false)
{
}

//----------------------------------------------------------------------------------------
// TControlFocusAdorner::~TControlFocusAdorner
//----------------------------------------------------------------------------------------

TControlFocusAdorner::~TControlFocusAdorner()
{
}

//----------------------------------------------------------------------------------------
// TControlFocusAdorner::DoHighlightSelection
//----------------------------------------------------------------------------------------

void TControlFocusAdorner::DoHighlightSelection(TView*				itsView,
												const CViewRect&	area,
												HLState				fromHL,
												HLState				toHL)
{
	#pragma unused (area, fromHL, toHL)

	// Focus, and then if we succeed draw the focus selection.
	if (itsView->Focus())
		DrawFocus(itsView);
}

//----------------------------------------------------------------------------------------
// TControlFocusAdorner::Draw
//----------------------------------------------------------------------------------------

void TControlFocusAdorner::Draw(TView* itsView, const CViewRect& area)
{
	#pragma unused (area)

	DrawFocus(itsView);
}

//----------------------------------------------------------------------------------------
// TControlFocusAdorner::DrawFocus
//----------------------------------------------------------------------------------------

void TControlFocusAdorner::DrawFocus(TView* itsView)
{
#if qMSWindows
	#pragma unused (itsView)
	#pragma message ("TControlFocusAdorner::DrawFocus: Needs implementation.")
#else
	CRect_AC controlArea(itsView->GetQDExtent());
	controlArea.Inset(1, 1); // AGADrawThemeEditTextFrame draws inside this.

	AGADrawThemeEditTextFrame(controlArea, itsView->IsActive() ? kThemeStateActive : kThemeStateInactive);

	if (AppearanceMgrVersion_AC() >= 0x101)
	{
		bool isTarget = ContainsTarget(itsView, itsView->GetTarget()) && itsView->IsActive();
		if (isTarget) 
		{
			controlArea.Inset(2, 2); // DrawThemeFocusRect draws outside this.
			DrawThemeFocusRect(controlArea, isTarget);
		}
	}
#endif
}

//----------------------------------------------------------------------------------------
// TControlFocusAdorner::ContainsTarget
//----------------------------------------------------------------------------------------

bool TControlFocusAdorner::ContainsTarget(TView* itsView, TEventHandler *target)
{
	TEventHandler 	*localTarget = target;
	bool			containsTarget = false;
	
	while (localTarget && !containsTarget)
	{
		if (localTarget == itsView)
			containsTarget = true;
		localTarget = localTarget->GetNextHandler();
	}
	return containsTarget;
}

//========================================================================================
// CLASS TBeveledTargetBorderView
//========================================================================================

MA_DEFINE_CLASS(TBeveledTargetBorderView);

//----------------------------------------------------------------------------------------
//TBeveledTargetBorderView::TBeveledTargetBorderView
//----------------------------------------------------------------------------------------

TBeveledTargetBorderView::TBeveledTargetBorderView(	const CViewPoint& itsLocation,
													const CViewPoint& itsSize,
													SizeDeterminer itsHSizeDet,
													SizeDeterminer itsVSizeDet,
													IDType itsTargetView)
	:	TTargetBorderView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTargetView),
		fIsNotched(false)
{
}

//----------------------------------------------------------------------------------------
//TBeveledTargetBorderView::DoPostCreate
//----------------------------------------------------------------------------------------

void TBeveledTargetBorderView::DoPostCreate(TDocument* itsDocument)
{
	// Save the background colors we will need to erase.

	TTargetBorderView::DoPostCreate(itsDocument);
	
	Focus();
	if (! MControlBackground_AC::DetermineBackgroundColors(fEnabledBackgroundColor, fDisabledBackgroundColor))
	{
		fEnabledBackgroundColor = kRGBColorRamp[r2];
		fDisabledBackgroundColor = kRGBColorRamp[r2];
	}
}

//----------------------------------------------------------------------------------------
// TBeveledTargetBorderView::Draw
//----------------------------------------------------------------------------------------

void TBeveledTargetBorderView::Draw(const CViewRect& area)
{
	#pragma unused (area)

	// Set the color, always draw. TTargetBorderView leaves
	// background unerased in 1-bit.

	CTempDrawingEnvironment_AC	env;

	bool			isTarget = ContainsTarget(GetTarget());
	bool			enabled = IsActive();

	CTempRegion_AC borderRegion;
	
	for (CGDIterator_AC iter; iter; ++iter)
	{
#if !qMSWindows
		if (!EmulateControls_AC() && AppearanceMgrVersion_AC() >= 0x101)
		{
			TView*		viewToBorder = FirstSubView();
			if (viewToBorder)
			{
				// !!! We ought not use GetExtentRegion if it's not the same as ComputeBorderRegion,
				// but this looks a lot better.
				viewToBorder->GetExtentRegion(borderRegion);
				borderRegion.Offset(ViewToQD(viewToBorder->GetLocation()));
				//::EraseRgn(borderRegion);
				InsetRgn(borderRegion, 1, 1); // !!! Needs to be overlapping subview's frame adorner, but back-to-front drawing gets in the way
				DrawThemeFocusRegion(borderRegion, isTarget && enabled);
			}
		}
		else
#endif
		{
			ComputeBorderRegion(borderRegion);
			if (iter->IsDeep())
			{
				if (isTarget && enabled)
					kRGBColorRamp[r8].SetForeColor();
				else if (enabled)
					fEnabledBackgroundColor.SetForeColor();
				else
					fDisabledBackgroundColor.SetForeColor();
			}
			else
			{
				if (isTarget && enabled)
					kRGBColorRamp[rB].SetForeColor();
				else
					kRGBColorRamp[rW].SetForeColor();
			}
			::MacPaintRgn(borderRegion);
		}
	}
}

//----------------------------------------------------------------------------------------
// TBeveledTargetBorderView::ComputeBorderRegion:
//----------------------------------------------------------------------------------------

void TBeveledTargetBorderView::ComputeBorderRegion(RgnHandle borderRegion)
{
	// Return the border region to be painted or invalidated.
	TView*		viewToBorder = FirstSubView();
	if (viewToBorder)
	{
		CViewRect	viewRect = viewToBorder->GetFrame();
		// viewRect = LocalToGlobal(viewRect);
		CRect_AC	rectToBorder = ViewToQD(viewRect);
		::MacInsetRect(rectToBorder, -2, -2);
		AGAComputeTargetBorderRegion(borderRegion, rectToBorder, fIsNotched);
	}
}

//----------------------------------------------------------------------------------------
// TBeveledTargetBorderView::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TBeveledTargetBorderView::GetStandardSignature() const
{
	return kStdBeveledTargetBorderView;
}

//========================================================================================
// CLASS TNotchedTargetBorderView
//========================================================================================

MA_DEFINE_CLASS(TNotchedTargetBorderView);

//----------------------------------------------------------------------------------------
// TNotchedTargetBorderView::TNotchedTargetBorderView:
//----------------------------------------------------------------------------------------

TNotchedTargetBorderView::TNotchedTargetBorderView(const CViewPoint& itsLocation, const CViewPoint& itsSize, SizeDeterminer itsHSizeDet, SizeDeterminer itsVSizeDet, IDType itsTargetView) :
	TBeveledTargetBorderView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTargetView)
{
	fIsNotched = true;
}

//----------------------------------------------------------------------------------------
// TNotchedTargetBorderView::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TNotchedTargetBorderView::GetStandardSignature() const
{
	return kStdNotchedTargetBorderView;
}

//========================================================================================
// CLASS TTargetBorderFrameView
//========================================================================================

MA_DEFINE_CLASS(TTargetBorderFrameView);

//----------------------------------------------------------------------------------------
// TTargetBorderFrameView::TTargetBorderFrameView:
//----------------------------------------------------------------------------------------

TTargetBorderFrameView::TTargetBorderFrameView(	const CViewPoint& itsLocation,
												const CViewPoint& itsSize,
												SizeDeterminer itsHSizeDet,
												SizeDeterminer itsVSizeDet,
												IDType itsTargetView)
	:	TBeveledTargetBorderView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTargetView)
{
}

//----------------------------------------------------------------------------------------
// TTargetBorderFrameView::Draw:
//----------------------------------------------------------------------------------------

void TTargetBorderFrameView::Draw(const CViewRect& area)
{
	// Let the TBeveledTargetBorderView draw the target border,
	// then draw the "3D" sunken frame portion..
	TView*		viewToBorder = FirstSubView();
	if (viewToBorder)
	{
		CViewRect	viewRect = viewToBorder->GetFrame();
		// viewRect = LocalToGlobal(viewRect);
		CRect_AC	rectToBorder = ViewToQD(viewRect);
		::MacInsetRect(rectToBorder, -2, -2);
		AGADrawBorderFrame(rectToBorder, IsActive(), fIsNotched, true /*drawFrame*/, kRGBColorRamp[r2]);
	}

	TBeveledTargetBorderView::Draw(area);

	kRGBColorRamp[rB].SetForeColor();
	kRGBColorRamp[rW].SetBackColor();
}

//----------------------------------------------------------------------------------------
// TTargetBorderFrameView::Dim
//----------------------------------------------------------------------------------------

void TTargetBorderFrameView::Dim()
{
	// Suppress patBic painting over our frame.
}

//----------------------------------------------------------------------------------------
// TTargetBorderFrameView::Activate:
//----------------------------------------------------------------------------------------

void TTargetBorderFrameView::Activate(bool entering)
{
	if (Focus() && IsVisible())
	{
		CRect_AC	qdArea(GetQDExtent());
		::MacInsetRect(qdArea, 3, 3);
		AGADrawBorderFrame(qdArea, entering, fIsNotched, true /*drawFrame*/, kRGBColorRamp[r2]);
	}
}

//----------------------------------------------------------------------------------------
// TTargetBorderFrameView::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TTargetBorderFrameView::GetStandardSignature() const
{
	return kStdTargetBorderFrameView;
}

//========================================================================================
// CLASS TNotchedTargetBorderFrameView
//========================================================================================

MA_DEFINE_CLASS(TNotchedTargetBorderFrameView);

//----------------------------------------------------------------------------------------
// TNotchedTargetBorderFrameView::TNotchedTargetBorderFrameView:
//----------------------------------------------------------------------------------------

TNotchedTargetBorderFrameView::TNotchedTargetBorderFrameView(const CViewPoint& itsLocation,
															 const CViewPoint& itsSize,
															 SizeDeterminer itsHSizeDet,
															 SizeDeterminer itsVSizeDet,
															 IDType itsTargetView)
	:	TTargetBorderFrameView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTargetView)
{
	fIsNotched = true;	
}

//----------------------------------------------------------------------------------------
// TNotchedTargetBorderFrameView::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TNotchedTargetBorderFrameView::GetStandardSignature() const
{
	return kStdNotchedTargetBorderFrameView;
}

//========================================================================================
// CLASS TNotchedView
//========================================================================================

MA_DEFINE_CLASS(TNotchedView);

//----------------------------------------------------------------------------------------
// TNotchedView::GetExtentRegion:
//----------------------------------------------------------------------------------------

void TNotchedView::GetExtentRegion(RgnHandle itsExtentRgn) const
{
	// The notched view extent region subtracts out the notch.
	CRect_AC		ourExtentRect(GetQDExtent());
	CRect_AC		ourNotchRect(ourExtentRect);
	ourNotchRect.left = ourNotchRect.right - 15;
	ourNotchRect.top = ourNotchRect.bottom - 15;
	
	CTempRegion_AC	ourNotchRgn(ourNotchRect);
	::RectRgn(itsExtentRgn, ourExtentRect);
	::DiffRgn(itsExtentRgn, ourNotchRgn, itsExtentRgn);
}

//----------------------------------------------------------------------------------------
// End of UBeveledTargetBorderView.cpp