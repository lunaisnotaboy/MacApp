//----------------------------------------------------------------------------------------
// UDateTime.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		11/02/98	Include CStream_AC.h.
*/


#ifndef __UDATETIME__
#include "UDateTime.h"
#endif

#if qAppearance

// ACS

#ifndef __CStream_AC__
#include "CStream_AC.h"
#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

//========================================================================================
// Global Initialization Procedure
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------

void InitDateControl()
{
	static bool DateControlInitialized;

	if (!DateControlInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TDateControl, kStdDateControl);
		}
		DateControlInitialized = true;
	}
}

//----------------------------------------------------------------------------------------

void InitTimeControl()
{
	static bool TimeControlInitialized;

	if (!TimeControlInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TTimeControl, kStdTimeControl);
		}
		TimeControlInitialized = true;
	}
}


//========================================================================================
// CLASS TDateControl
//========================================================================================
#undef Inherited
#define Inherited TCtlMgr


MA_DEFINE_CLASS(TDateControl);

//----------------------------------------------------------------------------------------
// TDateControl constructor 
//----------------------------------------------------------------------------------------


TDateControl::TDateControl(const CViewPoint& itsLocation,
			 const CViewPoint& itsSize,
			 SizeDeterminer itsHSizeDet,
			 SizeDeterminer itsVSizeDet,
			 const CTextStyle_AC& itsTextStyle,
			 const CLongDate_AC& longDate,
			 bool showDays,
			 short clockFlags) : 
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, gEmptyString, itsTextStyle),

	fStrListID(kNoResource),					// date as string:	STR# rsrc id
	fIndex(kNoResource),						//					index into STR#
	fDate(longDate),
	fShowDays(showDays),
	fClockFlags(clockFlags)
{
}

//----------------------------------------------------------------------------------------
// TDateControl copy constructor 
//----------------------------------------------------------------------------------------


TDateControl::TDateControl(const TDateControl& inDateControl) : 
	TCtlMgr(inDateControl),

	fStrListID(inDateControl.fStrListID),
	fIndex(inDateControl.fIndex),
	fDate(inDateControl.GetDate()),
	fShowDays(inDateControl.fShowDays),
	fClockFlags(inDateControl.fClockFlags)
{
}

//----------------------------------------------------------------------------------------
// TDateControl destructor
//----------------------------------------------------------------------------------------


TDateControl::~TDateControl()
{
}
	
//----------------------------------------------------------------------------------------
// TDateControl::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TDateControl::GetStandardSignature() const
{
	return kStdDateControl;
}

//----------------------------------------------------------------------------------------
// TDateControl::ReadFields: 
//----------------------------------------------------------------------------------------

void TDateControl::ReadFields(CStream_AC* aStream)		// Override 
{
	Inherited::ReadFields(aStream);
	
	*aStream >> fStrListID
			 >> fIndex
			 >> fShowDays
			 >> fClockFlags;
			 
	if (fStrListID != kNoResource)
	{
		CStr255_AC dateAsString;
		GetIndString(dateAsString, fStrListID, fIndex);
		fDate.SetDate(dateAsString);
	}
}

//----------------------------------------------------------------------------------------
// TDateControl::WriteFields: 
//----------------------------------------------------------------------------------------

void TDateControl::WriteFields(CStream_AC* aStream) const		// Override 
{
	Inherited::WriteFields(aStream);

	*aStream << fStrListID
			 << fIndex
			 << fShowDays
			 << fClockFlags;
}

//----------------------------------------------------------------------------------------
// TDateControl::DoMakeControl: 
//----------------------------------------------------------------------------------------

CControl_AC* TDateControl::DoMakeControl(WindowRef theWindow, 
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
	return CreateClockDate_AC(theWindow, boundsRect, isVisible, isEnabled, 
							fDate, fShowDays, fClockFlags, this);
}

//----------------------------------------------------------------------------------------
// TDateControl::SetDate: 
//----------------------------------------------------------------------------------------

void TDateControl::SetDate(const CLongDate_AC& longDate, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
#if defined(__SC__) || defined(__MRC__)
		GetControl()->SetClockLongDate(static_cast<const LongDateRec&>(longDate));
#else
		GetControl()->SetClockLongDate(longDate);
#endif

	}
}

//----------------------------------------------------------------------------------------
// TDateControl::GetDate: 
//----------------------------------------------------------------------------------------

CLongDate_AC TDateControl::GetDate() const
{
	CLongDate_AC longDate;
	if (GetControl())
	{
		longDate = GetControl()->GetClockLongDate();
	}
	return longDate;
}

//========================================================================================
// CLASS TTimeControl
//========================================================================================
#undef Inherited
#define Inherited TCtlMgr


MA_DEFINE_CLASS(TTimeControl);

//----------------------------------------------------------------------------------------
// TTimeControl constructor 
//----------------------------------------------------------------------------------------


TTimeControl::TTimeControl(const CViewPoint& itsLocation,
			 const CViewPoint& itsSize,
			 SizeDeterminer itsHSizeDet,
			 SizeDeterminer itsVSizeDet,
			 const CTextStyle_AC& itsTextStyle,
			 const CLongDate_AC& longDate,
			 bool showSeconds, 
			 short clockFlags) : 
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, gEmptyString, itsTextStyle),

	fStrListID(kNoResource),					// time as string:	STR# rsrc id
	fIndex(kNoResource),						//					index into STR#
	fDate(longDate),
	fShowSeconds(showSeconds),
	fClockFlags(clockFlags)
{
}

//----------------------------------------------------------------------------------------
// TTimeControl copy constructor 
//----------------------------------------------------------------------------------------


TTimeControl::TTimeControl(const TTimeControl& inTimeControl) : 
	TCtlMgr(inTimeControl),

	fStrListID(inTimeControl.fStrListID),
	fIndex(inTimeControl.fIndex),
	fDate(inTimeControl.GetTime()),
	fShowSeconds(inTimeControl.fShowSeconds),
	fClockFlags(inTimeControl.fClockFlags)
{
}

//----------------------------------------------------------------------------------------
// TTimeControl destructor
//----------------------------------------------------------------------------------------


TTimeControl::~TTimeControl()
{
}
	
//----------------------------------------------------------------------------------------
// TTimeControl::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TTimeControl::GetStandardSignature() const
{
	return kStdTimeControl;
}

//----------------------------------------------------------------------------------------
// TTimeControl::ReadFields: 
//----------------------------------------------------------------------------------------

void TTimeControl::ReadFields(CStream_AC* aStream)		// Override 
{
	Inherited::ReadFields(aStream);
	
	*aStream >> fStrListID
			 >> fIndex
			 >> fShowSeconds
			 >> fClockFlags;
			 
	if (fStrListID != kNoResource)
	{
		CStr255_AC timeAsString;
		GetIndString(timeAsString, fStrListID, fIndex);
		fDate.SetTime(timeAsString);
	}
}

//----------------------------------------------------------------------------------------
// TTimeControl::WriteFields: 
//----------------------------------------------------------------------------------------

void TTimeControl::WriteFields(CStream_AC* aStream) const		// Override 
{
	Inherited::WriteFields(aStream);

	*aStream << fStrListID
			 << fIndex
			 << fShowSeconds
			 << fClockFlags;
}

//----------------------------------------------------------------------------------------
// TTimeControl::DoMakeControl: 
//----------------------------------------------------------------------------------------

CControl_AC* TTimeControl::DoMakeControl(WindowRef theWindow, 
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
	return CreateClockTime_AC(theWindow, boundsRect, isVisible, isEnabled, 
								fDate, fShowSeconds, fClockFlags, this);
}

//----------------------------------------------------------------------------------------
// TTimeControl::SetTime: 
//----------------------------------------------------------------------------------------

void TTimeControl::SetTime(const CLongDate_AC& longDate, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
#if defined(__SC__) || defined(__MRC__)
		GetControl()->SetClockLongDate(static_cast<const LongDateRec&>(longDate));
#else
		GetControl()->SetClockLongDate(longDate);
#endif
	}
}

//----------------------------------------------------------------------------------------
// TTimeControl::GetTime: 
//----------------------------------------------------------------------------------------

CLongDate_AC TTimeControl::GetTime() const
{
	CLongDate_AC longDate;
	if (GetControl())
	{
		longDate = GetControl()->GetClockLongDate();
	}
	return longDate;
}

#endif // qAppearance


//----------------------------------------------------------------------------------------
// End of UDateTime.cpp
