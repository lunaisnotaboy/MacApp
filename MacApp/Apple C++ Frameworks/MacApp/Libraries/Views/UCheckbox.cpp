//----------------------------------------------------------------------------------------
// UCheckbox.cpp
// Copyright � 1988-2001 by Apple Computer, Inc. All rights reserved.
// Portions Copyright �1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/16/00	Use WriteBool in WriteFields.
		07/31/00	[W] SetWindowsWindowStyle in TCheckBox ctor.  Added DoPostCreate,
					CreateWindowsWindow and HandleWindowsEvent.
		06/21/00	Remove unnecessary GetRegion calls.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		11/04/98	Moved InitUCheckbox to bottom of file to get rid of Mach-0 Linker errors
*/

#ifndef __UCHECKBOX__
#include "UCheckbox.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#if qEmulateStandardControls

	#ifndef __CCheckBox_AC__
	#include "CCheckBox_AC.h"
	#endif

	#ifndef __AGA_AC__
	#include "AGA_AC.h"
	#endif

#endif // qEmulateStandardControls

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

// Compatibility Hacks

#if UNIVERSAL_INTERFACES_VERSION < 0x0300
enum {
	kControlCheckBoxMixedValue	= kControlCheckboxMixedValue
};
#endif // UNIVERSAL_INTERFACES_VERSION < 0x0300

//========================================================================================
// CLASS TCheckBox
//========================================================================================
#undef Inherited
#define Inherited TCtlMgr

MA_DEFINE_CLASS(TCheckBox);

//----------------------------------------------------------------------------------------
// TCheckBox constructor
//----------------------------------------------------------------------------------------

TCheckBox::TCheckBox(	const CViewPoint&	itsLocation,
						const CViewPoint&	itsSize,
						SizeDeterminer		itsHSizeDet,
						SizeDeterminer		itsVSizeDet,
						const CStr255_AC&	itsTitle,
						SInt16				isTurnedOn)
	:	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTitle),
		fStrListID(kNoResource),					// buttons's label:	STR# rsrc id
		fIndex(kNoResource),						//					index into STR#
		fInitialState(isTurnedOn)
{
	fEventNumber = mCheckBoxHit;

#if qMSWindows
	SetWindowsWindowStyle(WS_CHILD | BS_AUTOCHECKBOX | WS_TABSTOP);
#endif

// This method would do nothing now, and isn't overrideable, so punt.
//	SetState(isTurnedOn, kDontRedraw); // ���  (virtual call)
}

//----------------------------------------------------------------------------------------
// TCheckBox copy constructor
//----------------------------------------------------------------------------------------

TCheckBox::TCheckBox(const TCheckBox& inCheckBox)
	:	TCtlMgr(inCheckBox),
		fStrListID(inCheckBox.fStrListID),
		fIndex(inCheckBox.fIndex),
		fInitialState(inCheckBox.GetState())
{	
}


//----------------------------------------------------------------------------------------
// TCheckBox destructor
//----------------------------------------------------------------------------------------

TCheckBox::~TCheckBox()
{
}

//----------------------------------------------------------------------------------------
// TCheckBox::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TCheckBox::GetStandardSignature() const
{
	return kStdCheckBox;
}

//----------------------------------------------------------------------------------------
// TCheckBox::ReadFields: 
//----------------------------------------------------------------------------------------

void TCheckBox::ReadFields(CStream_AC* aStream)
{
	Inherited::ReadFields(aStream);

	fInitialState = aStream->ReadBoolean();

	*aStream >> fStrListID
			 >> fIndex;

	// retrieve the buttons's label from the resource

	SetText(CStr255_AC(fStrListID, fIndex), kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TCheckBox::WriteFields: 
//----------------------------------------------------------------------------------------

void TCheckBox::WriteFields(CStream_AC* aStream) const
{
	Inherited::WriteFields(aStream);

	aStream->WriteBool(IsOn());

	aStream->WriteInteger(fStrListID);
	aStream->WriteInteger(fIndex);
}

//----------------------------------------------------------------------------------------
// TCheckBox::DoEvent: 
//----------------------------------------------------------------------------------------

void TCheckBox::DoEvent(EventNumber eventNumber,
						TEventHandler* source,
						TEvent* event)

{
	if (eventNumber == mCheckBoxHit)
		Toggle(kRedraw);
	Inherited::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TCheckBox::IsOn: 
//----------------------------------------------------------------------------------------

bool TCheckBox::IsOn() const
{
#if qMSWindows
	HWND windowsWindow = GetWindowsWindow();

	if (windowsWindow != NULL)
		return ::SendMessage(windowsWindow, BM_GETCHECK, 0, 0L) == BST_CHECKED;
	else
		return fInitialState;
#else
	return GetValue() == kControlCheckBoxCheckedValue;
#endif
}

//----------------------------------------------------------------------------------------
// TCheckBox::SetState: 
//----------------------------------------------------------------------------------------

void TCheckBox::SetState(SInt16 state,
						 bool redraw)
{
#if qMSWindows
	HWND windowsWindow = GetWindowsWindow();

	if (windowsWindow != NULL)
		::SendMessage(windowsWindow, BM_SETCHECK, (WPARAM)state, 0L);
	else
		fInitialState = state;
#else
	SetValue((long)state, redraw);
#endif
}

//----------------------------------------------------------------------------------------
// TCheckBox::Toggle: 
//----------------------------------------------------------------------------------------

void TCheckBox::Toggle(bool redraw)

{
	SetValue((long)(!IsOn()), redraw);
}

//----------------------------------------------------------------------------------------
// TCheckBox::ToggleIf: 
//----------------------------------------------------------------------------------------

void TCheckBox::ToggleIf(bool matchState,
						 bool redraw)
{
	bool isOn = IsOn();
	if (isOn == matchState)
		SetValue((long)(!isOn), redraw);
}

//----------------------------------------------------------------------------------------
// TCheckBox::DoMakeControl: 
//----------------------------------------------------------------------------------------

CControl_AC* TCheckBox::DoMakeControl(WindowRef theWindow,
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& itsTitle)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CCheckBox_AC(boundsRect, isEnabled, itsTitle, fTextStyle, fInitialState);
	else
#endif // qEmulateStandardControls
		return CreateCheckBox_AC(theWindow, boundsRect, itsTitle, isVisible, isEnabled, fInitialState);
}

//----------------------------------------------------------------------------------------
// TCheckBox::DoPostCreate:
//----------------------------------------------------------------------------------------

void TCheckBox::DoPostCreate(TDocument* itsDocument)
// DoPostCreate is used to set the Windows-related control style.
//
// itsDocument:		A TDocument* which points to the document into which this control
//					is being installed.
//
// Override:		As needed.
// Call:			Only as the inherited DoPostCreate when implementing a custom
//					class deriving from TCheckBox and which has its own DoPostCreate.
{
	TCtlMgr::DoPostCreate(itsDocument);

#if qMSWindows
	SetWindowsWindowStyle(WS_CHILD | BS_AUTOCHECKBOX | WS_TABSTOP);
#endif
}

#if qMSWindows

//----------------------------------------------------------------------------------------
// TCheckBox::CreateWindowsWindow: 
//----------------------------------------------------------------------------------------

void TCheckBox::CreateWindowsWindow()
{
	if (GetWindowsWindow() == NULL)
	{
		TCtlMgr::CreateWindowsWindow();
		::SendMessage(GetWindowsWindow(), BM_SETCHECK, (WPARAM)fInitialState, 0L);
	}
}

//----------------------------------------------------------------------------------------
// TCheckBox::HandleWindowsEvent: 
//----------------------------------------------------------------------------------------

long TCheckBox::HandleWindowsEvent(HWND hwnd, UINT message, WPARAM wParam, LPARAM lParam)
{
	long result = 0;
	switch (message)
	{
    	// let the controls handle drawing and scrolling themselves
		case WM_LBUTTONDOWN:
			result = DefaultWindowProcedure(hwnd, message, wParam, lParam);
			break;

		default:
			result = TCtlMgr::HandleWindowsEvent(hwnd, message, wParam, lParam);
			break;
	}
	return result;
}

#endif

//========================================================================================
// GLOBAL Functions
//========================================================================================
#undef Inherited

void InitUCheckbox()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TCheckBox, kStdCheckBox);
	}
}

//----------------------------------------------------------------------------------------
// End of UCheckbox.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added #include "UStream.h" for noload buids
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitUCheckbox
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
		03/27/96	Switch last remaining Str255s to CStr255s_AC
		03/26/96	Cleanup references to gEmptyString
		03/26/96	CStr255_AC doesn't need to be set to empty.
		03/18/96	Remove compatibility hacks.
		03/11/96	Moved TIcon, TIconSuite and TSmallIcon to UDialog.more.cp
							from UDialog.cp to better balance the quantity of object code in each
		 12/8/95	Don't need to include UApplication. 
		----- 3.3 -----
		----- 3.3b1 -----
		 3/22/95	Add compatibility hacks for 2.0f1 headers. 
		 3/13/95	Change Free methods to destructors. 
*/