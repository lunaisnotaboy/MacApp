//----------------------------------------------------------------------------------------
// UQD3DCommon.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		03/01/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef  __UQD3DCOMMON__
#include "UQD3DCommon.h"
#endif

// ACS

#ifndef __Types_AC__
#include "Types_AC.h"
#endif

// QuickDraw3D

#ifndef __QD3D__
#include "QD3D.h"
#endif

#ifndef __QD3DERRORS__
#include "QD3DErrors.h" 
#endif

#if !q68K

// This file only contains Fail3DErr right now, but it will contain group iterators and other
// code shared by the viewer, views, and 3D classes.

const TQ3ColorRGB  zeroedQ3Color = {0,0,0};
const TQ3Point3D  zeroedOrigin = {0,0,0};
const TQ3Vector3D zeroedVector = {0,0,0};

//----------------------------------------------------------------------------------------
// Fail3DErr: 
//----------------------------------------------------------------------------------------


void Fail3DErr(TQ3Status theStatus)
{
	if (theStatus != kQ3Success)
	{
		TQ3Error theError = Q3Error_Get(NULL);
		if(theError == kQ3ErrorMacintoshError)
			::ThrowIfOSErr_AC(Q3MacintoshError_Get(NULL));
		else if (theError != kQ3ErrorNone)
			::ThrowException_AC(theError,0);	
	}
} 

#endif

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		06/16/96	First Checkin.
		----- R10 -----
*/