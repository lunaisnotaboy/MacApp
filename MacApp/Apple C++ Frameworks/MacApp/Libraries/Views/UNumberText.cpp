//----------------------------------------------------------------------------------------
// UNumberText.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/15/01	Use CString_AC instead of CStr255_AC.
		01/02/01	Update copyright.
		11/13/00	[PB] Change initialization order to match declaration. 
		12/27/99	Stripped out unused code.
		12/08/99	Fixed file name in banner.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/


#ifndef __UNUMBERTEXT__
#include "UNumberText.h"
#endif

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

// ACS

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// ANSI

#ifndef __cstdlib__
#include <cstdlib>
#endif

//----------------------------------------------------------------------------------------
// Function prototype
bool IsValidDecimalString(const CString_AC& theString, bool allowDecimalPoint, bool allowSign);

//----------------------------------------------------------------------------------------
// Unit initialization
//----------------------------------------------------------------------------------------
void InitUNumberText()
{
	static bool UNumberTextInitialized;
	if (!UNumberTextInitialized)
	{	
		if (qTemplateViews)
		{
			InitUEditText();
	
			REGISTER_SIGNATURE_AC(TNumberText, kStdNumberText);
		}

		UNumberTextInitialized = true;
	}
}

//----------------------------------------------------------------------------------------
// IsValidDecimalString - Utility routine to validate a string of digits.
//		This code was adapted from ODF!
//----------------------------------------------------------------------------------------
bool IsValidDecimalString(const CString_AC& theString, bool allowDecimalPoint, bool allowSign)
{
	// ••• The following is a poor-man's implementation to speed conversion to CString_AC.
	CStr255_AC		theStr255(theString);
	const char*		pString = CChar255_AC(theStr255);
	const char*		pLast = pString + theStr255.Length();
	bool			isValid = true;
	bool			foundDecimal = false;	// make sure there's only one
	short			count = 0;
	short			maxDigits = 10;

	const char		kZero = '0';
	const char		kNine = '9';
	const char		kPoint = '.';
	const char		kMinus = '-';
	const char		kPlus = '+';

	if (allowDecimalPoint)
		maxDigits = 16;

	if (allowSign)	// check the first character for a sign
	{
		if (*pString == kMinus)
			++pString;
		else if ((*pString == kPlus) && allowDecimalPoint)	// plus-sign only works with reals
			++pString;
	}

	while (pString < pLast)
	{
		if ((*pString >= kZero) && (*pString <= kNine))		// valid decimal digit
		{
			count++;
			if ((count > maxDigits) && !foundDecimal)
			{
				isValid = false;
				break;
			}
		}
		else
		{
			if (allowDecimalPoint && (*pString == kPoint) && !foundDecimal)
				foundDecimal = true;
			else
			{
				isValid = false;
				break;
			}
		}
		++pString;
	}

	return isValid;
}

//========================================================================================
// CLASS TNumberText
//========================================================================================
#undef Inherited
#define Inherited TEditText

MA_DEFINE_CLASS(TNumberText);

//----------------------------------------------------------------------------------------
// TNumberText constructor
//----------------------------------------------------------------------------------------

TNumberText::TNumberText(const CViewPoint& itsLocation,
						 const CViewPoint& itsSize,
						 long itsValue,
						 long itsMinimum,
						 long itsMaximum):
	TEditText(itsLocation, itsSize, 255),
	fMinimum(0),
	fMaximum(LONG_MAX)
{

#if qDebugMsg
	if (itsMinimum > itsMaximum)
		ProgramReport_AC("Minimum value specified is greater than maximum for TNumberText.\n");
#endif

	fMinimum = itsMinimum;
	fMaximum = itsMaximum;

	SetValue(itsValue, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TNumberText destructor
//----------------------------------------------------------------------------------------

TNumberText::~TNumberText()
{
}

//----------------------------------------------------------------------------------------
// TNumberText::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TNumberText::GetStandardSignature() const	// Override 
{
	return kStdNumberText;
}

//----------------------------------------------------------------------------------------
// TNumberText::ReadFields: 
//----------------------------------------------------------------------------------------

void TNumberText::ReadFields(CStream_AC* aStream)				// Override 
{
	Inherited::ReadFields(aStream);

	long initialValue = aStream->ReadLong();
	fMinimum = aStream->ReadLong();
	fMaximum = aStream->ReadLong();

#if qDebugMsg
	if (fMinimum > fMaximum)
		ProgramReport_AC("Minimum value specified is greater than maximum for TNumberText.\n");
#endif

	SetValue(initialValue, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TNumberText::WriteFields: 
//----------------------------------------------------------------------------------------

void TNumberText::WriteFields(CStream_AC* aStream) const				// Override 
{
	Inherited::WriteFields(aStream);

	aStream->WriteLong(GetValue());
	aStream->WriteLong(fMinimum);
	aStream->WriteLong(fMaximum);
}

//----------------------------------------------------------------------------------------
// TNumberText::GetValue: 
//----------------------------------------------------------------------------------------

long TNumberText::GetValue() const
{
	return std::atol(GetText().c_str());
}

//----------------------------------------------------------------------------------------
// TNumberText::SetValue: 
//----------------------------------------------------------------------------------------

void TNumberText::SetValue(long newValue, bool redraw)
{
	CString_AC aString;
	stringprintf(aString, "%d", MinMax_AC(fMinimum, newValue, fMaximum));
	SetText(aString, redraw);
}

//----------------------------------------------------------------------------------------
// TNumberText::GetValidationError: 
//----------------------------------------------------------------------------------------

long TNumberText::GetValidationError()
{
	// Empty CStrings are not validated; if a value is desired, override this method
	
	long theErrorCode = TEditText::GetValidationError();
	if (theErrorCode == kValidValue)
	{ 
		CString_AC theString(GetText());

		if (!theString.empty())
		{
			if (IsValidDecimalString(theString, false, true))	// no decimal point, sign OK
			{
				long value = std::atol(theString.c_str());
				if (value < fMinimum)
					theErrorCode = kValueTooSmall;
				else if (value > fMaximum)
					theErrorCode = kValueTooLarge;
			}
			else
				theErrorCode = kNonNumericCharacters;
		}
	}
		
	return theErrorCode;
}


//----------------------------------------------------------------------------------------
// End of UNumberText.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		05/30/96	[1353325] Changed GetValidationError to be single exit
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitUNumberText
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
	
*/
