//----------------------------------------------------------------------------------------
// UStaticText.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/09/01	[PB] Put member initializers in declaration order. 
		01/05/01	Change to use CString_AC instead of std::string.
		01/02/01	Update copyright.
		12/26/00	[W] Initialize SetTransparentView in ctor.
		12/15/00	Change parm in SetText from CStr255_AC to string.  Changed
					fDataHandle to fString and all associated code to handle a string.
		12/15/00	Initialize fDataHandle in TStaticText’s copy ctor.
		11/27/00	Use nil instead of NULL in call to TextBox_AC in ImageText.
		11/11/00	Cosmetic.  Removed Inherited.
		09/22/00	Improved graphics device iterator.
		09/06/00	Added embedded documentation - TStaticText::ChangeWrap.
		06/21/00	Eliminate unnecessary GetRegionCode calls.
		06/01/00	[2477888] Call AGASetThemeTextColor in ImageText only if black.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		11/04/98	Moved InitUStaticText to bottom of file to get rid of Mach-0 Linker errors
*/

#ifndef __USTATICTEXT__
#include "UStaticText.h"
#endif

#ifndef __TextBox_AC__
#include "TextBox_AC.h"
#endif

//temp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __USUBSTITUTION__
#include "USubstitution.h"
#endif

#if qDrag
	#ifndef __UDRAGDROP__
	#include "UDragDrop.h"
	#endif
#endif

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

//========================================================================================
// CLASS TStaticText
//========================================================================================

MA_DEFINE_CLASS(TStaticText);

//----------------------------------------------------------------------------------------
// TStaticText constructor
//----------------------------------------------------------------------------------------

TStaticText::TStaticText(const CViewPoint&	itsLocation,
						 const CViewPoint&	itsSize,
						 SizeDeterminer		itsHSizeDet,
						 SizeDeterminer		itsVSizeDet,
						 ResNumber			itsRsrcID,
						 short				itsIndex)
	:	TControl(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
		fStrListID(itsRsrcID),
		fIndex(itsIndex),
		fJust(teFlushDefault),
		fAutoWrap(true),
		fEraseFirst(kNoEraseFirst),
		fWasActive(false)
{
	fEventNumber = mStaticTextHit;

	if (fStrListID != kNoResource)
	{
		CString_AC aString(fStrListID, fIndex);
		::ThrowIfResError_AC();
		SetText(aString, kDontRedraw);
	}
	SetEnable(false);						// Default is to not enable hit testing
#if qMSWindows
	SetTransparentView(false);
#endif
}

//----------------------------------------------------------------------------------------
// TStaticText copy constructor
//----------------------------------------------------------------------------------------

TStaticText::TStaticText(const TStaticText& inStaticText)
	:	TControl(inStaticText),
		fString(inStaticText.fString),
		fStrListID(inStaticText.fStrListID),
		fIndex(inStaticText.fIndex),
		fJust(inStaticText.fJust),
		fAutoWrap(inStaticText.fAutoWrap),
		fEraseFirst(inStaticText.fEraseFirst),
		fWasActive(false)
{
#if 0
	fDataHandle = reinterpret_cast<StringHandle>
			(PermCopyHandle(reinterpret_cast<Handle>(inStaticText.fDataHandle)));
#endif
}

//----------------------------------------------------------------------------------------
// TStaticText::Free:
//----------------------------------------------------------------------------------------

TStaticText::~TStaticText()
{
	ReleaseText();
}

//----------------------------------------------------------------------------------------
// TStaticText::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TStaticText::GetStandardSignature() const
{
	return kStdStaticText;
}

//----------------------------------------------------------------------------------------
// TStaticText::ReadFields:
//----------------------------------------------------------------------------------------

void TStaticText::ReadFields(CStream_AC* aStream)
{
	TControl::ReadFields(aStream);

	fAutoWrap = aStream->ReadBoolean();
	fEraseFirst = aStream->ReadBoolean();

	fJust = aStream->ReadInteger();

	*aStream >> fStrListID
			 >> fIndex;

	// retrieve the static text from the resource
	SetText(CString_AC(fStrListID, fIndex), kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TStaticText::WriteFields:
//----------------------------------------------------------------------------------------

void TStaticText::WriteFields(CStream_AC* aStream) const
{
	TControl::WriteFields(aStream);

	aStream->WriteBoolean(fAutoWrap);
	aStream->WriteBoolean(fEraseFirst);
	aStream->WriteInteger(fJust);
	aStream->WriteInteger(fStrListID);
	aStream->WriteInteger(fIndex);
}

//----------------------------------------------------------------------------------------
// TStaticText::ChangeWrap:
//----------------------------------------------------------------------------------------

void TStaticText::ChangeWrap(bool newAutoWrap, bool redraw)
// ChangeWrap sets the wrapping behavior of the TStaticText object according
// to the specified value.
//
// newAutoWrap:		If TRUE, the TStaticText object subsequently wraps a line of text to
// 					the next line(if necessary) to prevent the line from extending beyond
// 					the right edge of the view. If newAutoWrap is FALSE, the TStaticText
// 					object subsequently permits text lines to be longer than the width of
// 					the view, wrapping to a new line only at carriage returns.
// redraw:			If TRUE, the object is redrawn. When you set redraw to FALSE, the
// 					object is not redrawn even though its appearance may be affected by
// 					the change. You can set redraw to false when you know that the static
// 					text will be redrawn eventually and you wish to avoid drawing it twice,
// 					which makes the screen appear to flicker or flash.
//
// Call?		As needed.
// Override?	Seldom.
{
	fAutoWrap = newAutoWrap;
	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TStaticText::DoSubstitution:
//----------------------------------------------------------------------------------------

CString_AC TStaticText::DoSubstitution() const
// DoSubstitution replaces any key substrings found in our text using MAReplaceText
// and returns a string with those replacements.
//
// Call?		As needed.
// Override?	As needed.  TEditText, for example, has an override that bypasses
//				the substitution.
{
	CString_AC	theText(GetText());
	MAReplaceText(theText);
	return theText;
}

//----------------------------------------------------------------------------------------
// TStaticText::Draw:
//----------------------------------------------------------------------------------------

void TStaticText::Draw(const CViewRect& area)
{
	CString_AC		theText = DoSubstitution();	// Make the substitution if desired
	ImageText(theText, ControlArea(), fJust);
	TControl::Draw(area);
}

//----------------------------------------------------------------------------------------
// TStaticText::GetText:
//----------------------------------------------------------------------------------------

CString_AC TStaticText::GetText() const
{
	return fString;
}

//----------------------------------------------------------------------------------------
// TStaticText::ImageText:
//----------------------------------------------------------------------------------------

void TStaticText::ImageText(CString_AC			text,
							const CViewRect&	box,
							short				just)
{
	for (CGDIterator_AC iter; iter; ++iter)
	{
		fTextStyle.SetPortTextStyle();

		// Assume that black means that we draw in the current theme's text
		// color, otherwise we have overridden the theme and want our own color.
		if (CRGBColor_AC::kRGBBlack == fTextStyle.tsColor)
			AGASetThemeTextColor(IsActive() ? kThemeActiveDialogTextColor
											:  kThemeInactiveDialogTextColor,
								 iter->Depth(),
								 iter->IsColor());

		TextBox_AC(text.c_str(),
					static_cast<short>(text.size()),
					ViewToQD(box),
					just,
					fAutoWrap,					// no auto wrap
					nil,						// no wordBreak function
					fEraseFirst,				// no erase first
					kSpaceForCaret,				// space for caret
					kDontPreferOutlineFonts);	// no outline fonts
	}
}

//----------------------------------------------------------------------------------------
// TStaticText::ReleaseText:
//----------------------------------------------------------------------------------------

void TStaticText::ReleaseText()
{
#if 0
	fDataHandle = (StringHandle)::DisposeIfHandle_AC((Handle)fDataHandle);
#endif
}

//----------------------------------------------------------------------------------------
// TStaticText::SetJustification:
//----------------------------------------------------------------------------------------

void TStaticText::SetJustification(short theJust, bool redraw)
{
	fJust = theJust;
	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TStaticText::SetText:
//----------------------------------------------------------------------------------------

void TStaticText::SetText(const CString_AC& theText, bool redrawImmediately)
{
	fString = theText;
	if (IsDrawable())
	{
		Invalidate(ControlQDArea());

		if (redrawImmediately)
			Update();
	}
}

//----------------------------------------------------------------------------------------
// TStaticText::SetTextWithStrListID:
//----------------------------------------------------------------------------------------

void TStaticText::SetTextWithStrListID(ResNumber theStrListID, short theIndex, bool redraw)
{
	CString_AC		aString;
	fStrListID = theStrListID;
	fIndex = theIndex;
	if (fStrListID != kNoResource)
	{
		aString = CString_AC(fStrListID, fIndex);
		::ThrowIfResError_AC();
	}
	SetText(aString, redraw);
}

#if qDrag

//----------------------------------------------------------------------------------------
// TStaticText::DoAddDragContent:
//----------------------------------------------------------------------------------------

void TStaticText::DoAddDragContent()
{
	TDragItem 		*dragItem = TDragDropSession::fgDragDropSession->AddDragItem(1);
	CFlavorFlags	flags;

	CString_AC theText = DoSubstitution();

	dragItem->AddFlavor(kTextType_AC, flags, const_cast<char*>(theText.c_str()), theText.size());
}

#endif // qDrag

//----------------------------------------------------------------------------------------
// TStaticText::Activate:
//----------------------------------------------------------------------------------------

void TStaticText::Activate(bool entering)
{
	if (fWasActive != entering && Focus() && IsVisible())
	{
		fWasActive = entering;
		ForceRedraw();
	}
}

//----------------------------------------------------------------------------------------
// TStaticText::InstallColor:
//----------------------------------------------------------------------------------------

void TStaticText::InstallColor(const CRGBColor_AC& theColor, bool redraw)
{
	fTextStyle.tsColor = theColor;
	InstallTextStyle(fTextStyle, redraw);
}

//========================================================================================
// GLOBALS
//========================================================================================

void InitUStaticText()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TStaticText, kStdStaticText);
	}
}

//----------------------------------------------------------------------------------------
// End of UStaticText.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		 5/09/96	Added CopyHandle_AC: a better HandToHand replacement. And created
		 					PermCopyHandle a better PermHandToHand.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/26/96	Made TControl::ControlArea/ControlQDArea non virtual. Made TView/TControl::GetAdornExtent
							return their CViewRect as function results
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitUStaticText
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
*/