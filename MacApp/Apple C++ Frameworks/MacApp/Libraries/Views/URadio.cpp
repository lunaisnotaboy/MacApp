//----------------------------------------------------------------------------------------
// URadio.cpp
// Copyright � 1988-2001 by Apple Computer, Inc. All rights reserved.
// Portions Copyright �1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/17/00	WriteBool instead of WriteBoolean in WriteFields.
		08/01/00	[W] Do SetWindowsWindowStyle in ctor.  SetWindowsWindowStyle
					in DoPostCreate.  Added GetWindowsClassName and CreateWindowsWindow.
					Removed Inherited.
		06/21/00	Eliminate unnecessary GetRegionCode calls.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __URADIO__
#include "URadio.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#if qEmulateStandardControls

	#ifndef __CRadioButton_AC__
	#include "CRadioButton_AC.h"
	#endif

	#ifndef __AGA_AC__
	#include "AGA_AC.h"
	#endif

#endif // qEmulateStandardControls

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

void InitURadio()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TRadio, kStdRadio);
	}
}  

//========================================================================================
// CLASS TRadio
//========================================================================================

MA_DEFINE_CLASS(TRadio);

//----------------------------------------------------------------------------------------
// TRadio constructor
//----------------------------------------------------------------------------------------

TRadio::TRadio(const CViewPoint& itsLocation,
			   const CViewPoint& itsSize,
			   SizeDeterminer itsHSizeDet,
			   SizeDeterminer itsVSizeDet,
			   const CStr255_AC& itsLabel,
			   SInt16 isTurnedOn) :
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsLabel),

	fStrListID(kNoResource),					// buttons's label:	STR# rsrc id
	fIndex(kNoResource),							//					index into STR#
	fInitialState(isTurnedOn)
{
	fEventNumber = mRadioHit;

#if qMSWindows
	SetWindowsWindowStyle(WS_CHILD | BS_AUTORADIOBUTTON | WS_TABSTOP);
#endif

	// Don't want to do these anyway yet.
	//SetState(isTurnedOn, kDontRedraw); // ���  (virtual call)

	//if (IsOn()) // ���  (virtual call)
	//	HandleEvent(fEventNumber, this, NULL); // ���  (virtual call)
}

//----------------------------------------------------------------------------------------
// TRadio copy constructor
//----------------------------------------------------------------------------------------

TRadio::TRadio(const TRadio& inRadio) :
	TCtlMgr(inRadio),
	fStrListID(inRadio.fStrListID),
	fIndex(inRadio.fIndex),
	fInitialState(inRadio.GetState())
{	
}

//----------------------------------------------------------------------------------------
// TRadio destructor
//----------------------------------------------------------------------------------------

TRadio::~TRadio()
{
}

//----------------------------------------------------------------------------------------
// TRadio::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TRadio::GetStandardSignature() const
{
	return kStdRadio;
}

//----------------------------------------------------------------------------------------
// TRadio::ReadFields: 
//----------------------------------------------------------------------------------------

void TRadio::ReadFields(CStream_AC* aStream)
{
	TCtlMgr::ReadFields(aStream);

	fInitialState = aStream->ReadBoolean();

	*aStream >> fStrListID
			 >> fIndex;

	// retrieve the buttons's label from the resource
	SetText(CStr255_AC(fStrListID, fIndex), kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TRadio::WriteFields: 
//----------------------------------------------------------------------------------------

void TRadio::WriteFields(CStream_AC* aStream) const
{
	TCtlMgr::WriteFields(aStream);

	aStream->WriteBool(IsOn());

	aStream->WriteInteger(fStrListID);
	aStream->WriteInteger(fIndex);
}

//----------------------------------------------------------------------------------------
// TRadio::DoPostCreate: 
//----------------------------------------------------------------------------------------

void TRadio::DoPostCreate(TDocument* itsDocument)
{
	TCtlMgr::DoPostCreate(itsDocument);

#if qMSWindows
	SetWindowsWindowStyle(WS_CHILD | BS_AUTORADIOBUTTON | WS_TABSTOP);
#endif

	if (IsOn())
		HandleEvent(fEventNumber, this, NULL);
}

//----------------------------------------------------------------------------------------
// TRadio::DoEvent: 
//----------------------------------------------------------------------------------------

void TRadio::DoEvent(EventNumber eventNumber,
					 TEventHandler* source,
					 TEvent* event)

{
	switch (eventNumber)
	{
		case mTurnOn:
		case mTurnOff:
			SetState(eventNumber == mTurnOn, kRedraw);
			break;

		case mRadioHit:
			if (!IsOn())
				Toggle(kRedraw);
			// no break - drop through

		default:
			TCtlMgr::DoEvent(eventNumber, source, event);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TRadio::IsOn: 
//----------------------------------------------------------------------------------------

bool TRadio::IsOn() const
{
	return GetValue() == kControlRadioButtonCheckedValue; // was: != 0
}

//----------------------------------------------------------------------------------------
// TRadio::SetState: 
//----------------------------------------------------------------------------------------

void TRadio::SetState(SInt16 state,
					  bool redraw)
{
	SetValue((long)(state), redraw);
}

//----------------------------------------------------------------------------------------
// TRadio::Toggle: 
//----------------------------------------------------------------------------------------

void TRadio::Toggle(bool redraw)
{
	SetValue((long)(!IsOn()), redraw);
}

//----------------------------------------------------------------------------------------
// TRadio::ToggleIf: 
//----------------------------------------------------------------------------------------

void TRadio::ToggleIf(bool matchState,
					  bool redraw)
{
	bool isOn = IsOn();
	if (isOn == matchState)
		SetValue((long)(!isOn), redraw);
}

//----------------------------------------------------------------------------------------
// TRadio::DoMakeControl: 
//----------------------------------------------------------------------------------------

CControl_AC* TRadio::DoMakeControl(WindowRef theWindow, 
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& itsTitle)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CRadioButton_AC(boundsRect, isEnabled, itsTitle, fTextStyle, 
						fInitialState,
						MExclusiveObject_AC::kNoGroupID, MExclusiveObject_AC::kNoGroupID,
						CCustomControl_AC::kNoAutomaticState);
	else
#endif // qEmulateStandardControls
		return CreateRadio_AC(theWindow, boundsRect, itsTitle, isVisible, isEnabled, fInitialState);
}

#if qMSWindows

//----------------------------------------------------------------------------------------
// TRadio::HandleWindowsEvent: 
//----------------------------------------------------------------------------------------

long TRadio::HandleWindowsEvent(HWND hwnd, UINT message, WPARAM wParam, LPARAM lParam)
{
	long result = 0;
	switch (message)
	{
    	// let the controls handle drawing and scrolling themselves
		case WM_LBUTTONDOWN:
			result = DefaultWindowProcedure(hwnd, message, wParam, lParam);
			break;

		default:
			result = TCtlMgr::HandleWindowsEvent(hwnd, message, wParam, lParam);
			break;
	}
	return result;
}

//----------------------------------------------------------------------------------------
// TRadio::CreateWindowsWindow: 
//----------------------------------------------------------------------------------------

void TRadio::CreateWindowsWindow()
{
	if (GetWindowsWindow() == NULL)
	{
		TCtlMgr::CreateWindowsWindow();
		::SendMessage(GetWindowsWindow(), BM_SETCHECK, (WPARAM)fInitialState, 0L);
	}
}

#endif

//----------------------------------------------------------------------------------------
// End of URadio.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitURadio
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
		03/27/96	Switch last remaining Str255s to CStr255s_AC
		03/26/96	Cleanup references to gEmptyString
		03/26/96	CStr255_AC doesn't need to be set to empty.
		03/18/96	Remove compatibility hacks.
		03/11/96	Moved TIcon, TIconSuite and TSmallIcon to UDialog.more.cp
							from UDialog.cp to better balance the quantity of object code in each
		 12/8/95	Don't need to include UApplication. 
		----- 3.3 -----
		----- 3.3b1 -----
		 3/22/95	Add compatibility hacks for 2.0f1 headers. 
		 3/13/95	Change Free methods to destructors. 
*/