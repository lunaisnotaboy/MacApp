//----------------------------------------------------------------------------------------
// UScrollBarProportional.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		09/01/00	Stripped dead code.  Cosmetic.
		08/01/00	Removed UpdateScrollAmounts since it is identical to
					the inherited function.  Removed Inherited.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __USCROLLBARPROPORTIONAL__
#include "UScrollBarProportional.h"
#endif

// ACS

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

// MacApp

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUScrollBarProportional
//----------------------------------------------------------------------------------------

void InitUScrollBarProportional()
{
	static bool UScrollBarProportionalInitialized;

	if (!UScrollBarProportionalInitialized)
	{	
		if (qTemplateViews)
		{
			// Register all of the classes defined here. If you prefer, you can
			// selectively register just the classes you will use.
			REGISTER_SIGNATURE_AC(TScrollBarProportional, kStdScrollBarProportional);
			REGISTER_SIGNATURE_AC(TScrollerScrollBarProportional, kStdScrollerScrollBarProportional);
		}
		UScrollBarProportionalInitialized = true;
	}
}

//========================================================================================
// CLASS TScrollBarProportional
//========================================================================================

MA_DEFINE_CLASS(TScrollBarProportional);

//----------------------------------------------------------------------------------------
// TScrollBarProportional constructor
//----------------------------------------------------------------------------------------

TScrollBarProportional::TScrollBarProportional(const CViewPoint& itsLocation, const CViewPoint& itsSize, SizeDeterminer itsHSizeDet, SizeDeterminer itsVSizeDet, VHSelect itsDirection, long itsVal, long itsMin, long itsMax) :
	TScrollBar(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsDirection, itsVal, itsMin, itsMax)
{
	// For procedural post-initialization, call HandlePostCreate.
}

//----------------------------------------------------------------------------------------
// TScrollBarProportional copy constructor
//----------------------------------------------------------------------------------------

TScrollBarProportional::TScrollBarProportional(const TScrollBarProportional& inScrollBarProportional) :
	TScrollBar(inScrollBarProportional)
{
}

//----------------------------------------------------------------------------------------
// TScrollBarProportional destructor
//----------------------------------------------------------------------------------------

TScrollBarProportional::~TScrollBarProportional()
{
}

//----------------------------------------------------------------------------------------
// TScrollBarProportional::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TScrollBarProportional::GetStandardSignature() const
{
	return kStdScrollBarProportional;
}

//----------------------------------------------------------------------------------------
// TScrollBarProportional::SetViewSize
//----------------------------------------------------------------------------------------

void TScrollBarProportional::SetViewSize(SInt32 newViewSize, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetViewSize(newViewSize);
	}
}

//----------------------------------------------------------------------------------------
// TScrollBarProportional::GetViewSize
//----------------------------------------------------------------------------------------

SInt32 TScrollBarProportional::GetViewSize() const
{
	return GetControl() ? GetControl()->GetViewSize() : 0;
}

//----------------------------------------------------------------------------------------
// TScrollBarProportional::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TScrollBarProportional::DoMakeControl(WindowRef theWindow,
										const CRect_AC& boundsRect, 
										bool isVisible, bool isEnabled, 
										const CStr255_AC& itsTitle)
{
	// You should never emulate proportional scroll bars.  If you really want to do this,
	// subclass TScrollBarProportional, override this method, and use the full contents
	// of this function without the #if and #endif.
	return TScrollBar::DoMakeControl(theWindow, boundsRect, isVisible, isEnabled, itsTitle);
}

//========================================================================================
// CLASS TScrollerScrollBarProportional
//========================================================================================

MA_DEFINE_CLASS(TScrollerScrollBarProportional);

//----------------------------------------------------------------------------------------
// TScrollerScrollBarProportional constructor
//----------------------------------------------------------------------------------------

TScrollerScrollBarProportional::TScrollerScrollBarProportional(const CViewPoint& itsLocation, const CViewPoint& itsSize, SizeDeterminer itsHSizeDet, SizeDeterminer itsVSizeDet, VHSelect itsDirection, long itsMax, TScroller* itsScroller) :
	TScrollerScrollBar(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsDirection, itsMax, itsScroller)
{
	// For procedural instantiation also call HandlePostCreate().
}

//----------------------------------------------------------------------------------------
// TScrollBarProportional copy constructor
//----------------------------------------------------------------------------------------

TScrollerScrollBarProportional::TScrollerScrollBarProportional(const TScrollerScrollBarProportional& inScrollerScrollBarProportional) :
	TScrollerScrollBar(inScrollerScrollBarProportional)
{
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBarProportional::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TScrollerScrollBarProportional::GetStandardSignature() const
{
	return kStdScrollerScrollBarProportional;
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBarProportional destructor
//----------------------------------------------------------------------------------------

TScrollerScrollBarProportional::~TScrollerScrollBarProportional()
{
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBarProportional::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TScrollerScrollBarProportional::DoMakeControl(WindowRef theWindow,
										const CRect_AC& boundsRect, 
										bool isVisible, bool isEnabled, 
										const CStr255_AC& itsTitle)
{
	// You should never emulate proportional scroll bars.  If you really want to do this,
	// subclass TScrollBarProportional, override this method, and use the full contents
	// of this function without the #if and #endif.
	return TScrollerScrollBar::DoMakeControl(theWindow, boundsRect, isVisible, isEnabled, itsTitle);
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBarProportional::SetViewSize
//----------------------------------------------------------------------------------------

void TScrollerScrollBarProportional::SetViewSize(SInt32 newViewSize, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetViewSize(newViewSize);
	}
}

//----------------------------------------------------------------------------------------
// TScrollerScrollBarProportional::GetViewSize
//----------------------------------------------------------------------------------------

SInt32 TScrollerScrollBarProportional::GetViewSize() const
{
	return GetControl() ? GetControl()->GetViewSize() : 0;
}

//----------------------------------------------------------------------------------------
// End of UScrollBarProportional.cpp
