//----------------------------------------------------------------------------------------
// UClassicPrinting.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		08/15/01	Changed errNoPrintDrvr to kPMNoDefaultPrinter.  Include PMDefinitions.h.
		05/14/01	Update sfPrintShopOpens every time StartPrintJob and 
							StopPrintJob are called. 
		01/11/01	Change from CStr255_AC to CString_AC.
		01/02/01	Update copyright.
		09/01/00	Stripped dead code.  Cosmetic.
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Include CMultiLocal.h.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		04/24/00	SetPrintIdleProc no longer takes an argument.
		04/21/00	Renamed fPrintPort, fPrintShopOpens, fgLastPrinterName and
							fgPrinterChangeLevel to sfPrintPort, sfPrintShopOpens,
							sfLastPrinterName and sfPrinterChangeLevel.
							Incorporated Open into StartPrintJob and Close into
							StopPrintJob, eliminating Open and Close. GetPrintPages
							and SetPrintPages now use unsigned longs.
							GetPrintCopies returns and SetPrintCopies takes an unsigned long.
		04/20/00	Use TRefCntPrintInfo instead of CRefCountingPtr_AC<TPrintInfo>.
							Move Make implementation into header.  Specifically initialize
							fPrintShopOpens and sfPrinterChangeLevel.  Moved instantiation
							of idleproc from NewPrintIDLEProc into SetPrintIdleProc and
							eliminated NewPrintIDLEProc.
		04/14/00	Reworked includes.
		04/11/00	TClassicPrintJob::WriteTo has been changed so that it now
							writes a length and print record type.
		04/06/00	Cloned from the original Views:UPrinting.cpp.  All things
							TMacPrint are herein. Renamed TMacPrintJob to TClassicPrintJob
							and CInMacPrint to CInClassicPrint.
*/

#define __INCLUDED_BY_UCLASSICPRINTING__

#ifndef __UClassicPrinting__
#include "UClassicPrinting.h"
#endif

#undef __INCLUDED_BY_UCLASSICPRINTING__

// MacApp

#ifndef __MacAppRequired__
#include "MacAppRequired.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CDependencies_AC__
#include "CDependencies_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CStdReporter_AC__
#include "CStdReporter_AC.h"
#endif


#if qDebug
	#ifndef __StdStringUtils_AC__
	#include "StdStringUtils_AC.h"
	#endif
#endif

// Toolbox

#ifndef __PRINTING__
#include <Printing.h>
#endif

#ifndef __PMDEFINITIONS__
#include <PMDefinitions.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

// ANSI

#ifndef __LIMITS__
#include <limits.h>
#endif

#ifndef __STDLIB__
#include <stdlib.h>
#endif

#ifndef __STRING__
#include <string.h>
#endif

//========================================================================================

// Handy macros for Fixed point manipulation
#ifndef __GXMATH__
	#ifndef IntToFixed
	#define IntToFixed(a) ((Fixed)(a) << 16)
	#endif
#endif

//========================================================================================
// CLASS TClassicPrintJob
//========================================================================================

//----------------------------------------------------------------------------------------
// TClassicPrintJob statics
//----------------------------------------------------------------------------------------

TPPrPort 		TClassicPrintJob::sfPrintPort;
short			TClassicPrintJob::sfPrintShopOpens = 0;
CString_AC		TClassicPrintJob::sfLastPrinterName;
unsigned long	TClassicPrintJob::sfPrinterChangeLevel = 0;

//----------------------------------------------------------------------------------------
// TClassicPrintJob::InitializePrinting
//----------------------------------------------------------------------------------------

void TClassicPrintJob::InitializePrinting(TPrintInfo* defaultPrintInfo)
{
	static bool		classicPrintingInitialized = false;
	TPrintInfo*		newPrintInfo = NULL;
	
	if (!classicPrintingInitialized)
	{
		// If no one else has already initialized
		// printing (such as GX) then we should.
		if (defaultPrintInfo == NULL)
			defaultPrintInfo = TH_new TClassicPrintJob;

		TPrintHandler::gCouldPrint = true;
		classicPrintingInitialized = true;
	}

	// Create a StdPrintHandler to install in global variable gPrintHandler
	TStdPrintHandler* aTStdPrintHandler = TH_new TStdPrintHandler;
	aTStdPrintHandler->fFinderJobDialog = true;
		
	TPrintInfo::InitUPrintMgr(TRefCntPrintInfo(defaultPrintInfo),
							  aTStdPrintHandler);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob constructor
//----------------------------------------------------------------------------------------

TClassicPrintJob::TClassicPrintJob(THPrint itsHPrint, bool isValid)
	:	fPrintDialog(NULL),
		fIsActive(false)
{
	if (itsHPrint)
	{
		fHPrint = itsHPrint;
		fIsValid = isValid;
	}
	else
	{
		fHPrint = (THPrint)NewPermHandleClear(sizeof(TPrint));
		SetToDefault();
	}

	if (!sfPrinterChangeLevel)
		CheckPrinterChangeLevel();
	fPrinterChangeLevel = sfPrinterChangeLevel;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob copy constructor
//----------------------------------------------------------------------------------------

TClassicPrintJob::TClassicPrintJob(const TClassicPrintJob& inClassicPrintJob)
	:	TPrintInfo(inClassicPrintJob),
		fPrintDialog(NULL),		// Sorry, but this just can't be cloned
		fHPrint(inClassicPrintJob.fHPrint ? ((THPrint)PermCopyHandle(reinterpret_cast<Handle>(inClassicPrintJob.fHPrint.get()))) : NULL),
		fMinFromPage(inClassicPrintJob.fMinFromPage),
		fMaxToPage(inClassicPrintJob.fMaxToPage),
		fPrinterChangeLevel(inClassicPrintJob.fPrinterChangeLevel),
		fIsActive(false)
	{ }

//----------------------------------------------------------------------------------------
// TClassicPrintJob::ReadFrom: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::ReadFrom(CStream_AC* aStream)
{
	TPrintInfo::ReadFrom(aStream);

	if (!fHPrint)
		fHPrint = (THPrint)NewPermHandleClear(sizeof(TPrint));

	TemplateTempHandleLock<THPrint> tempHandleLock(fHPrint, eMoveHi);
	aStream->ReadBytes(*fHPrint, GetSize());

	Invalidate();
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::WriteTo: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::WriteTo(CStream_AC* aStream) const
{
	MStreamable::WriteTo(aStream);

	if (fHPrint)
	{
		// Don't need to validate it before saving it b/c it will be
		// validated before USE when loaded again in the future.
		// Also, if a document is opened, modified and saved without modifying
		// the printinfo (via page setup or printing or something; then the printshop
		// never even needs to be opened at all (Saving lots & lots of time)

		TemplateTempHandleLock<THPrint> tempHandleLock(fHPrint, eMoveHi);
		aStream->WriteBytes(*fHPrint, GetSize());
	}
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::OpenPrintShop: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::OpenPrintShop()
{
	::PrOpen();								// Open the print shop
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::ClosePrintShop: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::ClosePrintShop()
{
	::PrClose();							// Close the print shop
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::PrintGetGeneral: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::PrintGetGeneral(TGetRslBlk* aGetRslData)
{
	::PrGeneral((Ptr)aGetRslData);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::PrintSetGeneral: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::PrintSetGeneral(TSetRslBlk* aSetRslData)
{
	::PrGeneral((Ptr)aSetRslData);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetFrom
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetFrom(const TRefCntPrintInfo jobToCopy)
{
	TPrintInfo::SetFrom(jobToCopy);

	const TClassicPrintJob* classicPrintToCopy = dynamic_cast_or_throw_AC(const TClassicPrintJob*, jobToCopy.get());

	BlockMove_AC(*classicPrintToCopy->GetRawHPrint(), *GetRawHPrint(), GetHandleSize((Handle)GetRawHPrint()));

	if (fIsValid)
		Changed(mPrintInfoChanged, this);
	else
		Invalidate();
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetFrom
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetFrom(	THPrint		hPrintToCopy,
								bool		isValid,
								bool		needsDefault)
{
	BlockMove_AC(*hPrintToCopy, *fHPrint, GetHandleSize((Handle)hPrintToCopy));

	fIsValid = isValid;
	fNeedsDefault = needsDefault;

	if (fIsValid)
		Changed(mPrintInfoChanged, this);
	else
		Invalidate();
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetSize
//----------------------------------------------------------------------------------------

long TClassicPrintJob::GetSize(bool asResource) const
{
	#pragma unused (asResource)
	long returnVal = 0;
	if (fHPrint)
		returnVal = GetHandleSize(reinterpret_cast<Handle>(fHPrint.get()));

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::IsMatch
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::IsMatch(const TRefCntPrintInfo thePrintInfo) const
{
	return fIsValid
			&& EqualBlocks(*GetRawHPrint(),
						   *dynamic_cast_or_throw_AC(const TClassicPrintJob*, thePrintInfo.get())->GetRawHPrint(),
						   thePrintInfo->GetSize());
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetToDefault:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetToDefault()
{
	fNeedsDefault = true;

	// Print Manager code could be unavailable, but we would want some plausible things
	// anyway - set up for Portrait Tall Adj.
	TPrint& anHPrint = **fHPrint;
	anHPrint.iPrVersion = 0;					// something invalid 

	anHPrint.prInfo.iHRes = scClassicQDResolution;
	anHPrint.prInfo.iVRes = scClassicQDResolution;
	anHPrint.prInfo.rPage = CRect_AC(0, 0, 576, 752);// must have its top left & (0,0)

	anHPrint.rPaper = CRect_AC(-18, -36, 594, 756);
	anHPrint.prStl.iPageV = 1320;				// 11 inches in 120th of an inch 
	anHPrint.prStl.iPageH = 1020;				// 8.5 inches in 120th of an inch 

	Invalidate();
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::IsSetToDefault:
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::IsSetToDefault() const
{
	return fNeedsDefault || IsMatch(GetDefaultPrintInfo());
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetPrintPages:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::GetPrintPages(unsigned long& fromPage,
									 unsigned long& toPage,
									 unsigned long& minFromPage,
									 unsigned long& maxToPage) const
{
	fromPage = (*GetHPrint())->prJob.iFstPage;
	toPage = (*GetHPrint())->prJob.iLstPage;

	minFromPage = fMaxToPage;
	maxToPage = fMaxToPage;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetPrintPages:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetPrintPages(unsigned long fromPage,
									unsigned long toPage,
									unsigned long minFromPage,
									unsigned long maxToPage)
{
	// ClassicPrint can only take shorts for the page range and we always tell it we're
	// printing from page 1, otherwise we have to do PrOpenPage/ClosePage up to the 
	// desired page range before we will start printing.

	short shortFromPage = fromPage ? 1 : 0;

	short shortToPage = 0;
	if (toPage)
	{
		shortToPage = static_cast<short>((toPage - fromPage + 1) % SHRT_MAX);
		shortToPage = shortToPage ? shortToPage : SHRT_MAX;
	}

	TPrint& print = **GetHPrint();
	print.prJob.iFstPage = shortFromPage;
	print.prJob.iLstPage = shortToPage;
	
	fMinFromPage = minFromPage;
	fMaxToPage = maxToPage;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetPrintCopies:
//----------------------------------------------------------------------------------------

unsigned long TClassicPrintJob::GetPrintCopies() const
{
	return (*GetHPrint())->prJob.iCopies;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetNumCopies:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetPrintCopies(unsigned long numCopies)
{
	(*GetHPrint())->prJob.iCopies = numCopies;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetSpoolFile:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetSpoolFile(CFSSpec_AC& spoolFile)
{
	*((CStr31_AC*)((*GetHPrint())->prJob.pFileName)) = spoolFile.name;
	((*GetHPrint())->prJob.iFileVol = spoolFile.vRefNum);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::IsSpooling:
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::IsSpooling() const
{
	return (*GetHPrint())->prJob.bJDocLoop == bSpoolLoop;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetPaperRect:
//----------------------------------------------------------------------------------------

CViewRect TClassicPrintJob::GetPaperRect() const
{
	return (*GetHPrint())->rPaper;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetInkRect:
//----------------------------------------------------------------------------------------

CViewRect TClassicPrintJob::GetInkRect() const
{
	return (*GetHPrint())->prInfo.rPage;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetDeviceRes:
//----------------------------------------------------------------------------------------

CPoint_AC TClassicPrintJob::GetDeviceRes() const
{
	return *(CPoint_AC*)&(*GetHPrint())->prInfo.iVRes;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetHPrint:
//----------------------------------------------------------------------------------------

const THPrint TClassicPrintJob::GetHPrint() const
{
	Update();

	return fHPrint;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::CheckPrinterChangeLevel: 
//----------------------------------------------------------------------------------------

unsigned long TClassicPrintJob::CheckPrinterChangeLevel()
{
	bool returnVal = false;

	CString_AC driverName(GetDriverName());

	if (!EqualString(CStr255_AC(driverName), CStr255_AC(sfLastPrinterName), false, true))
		returnVal = true;

	if (returnVal)
	{
		sfLastPrinterName = driverName;				// Save it for later
		++sfPrinterChangeLevel;						// bump the change level

		TPrintHandler::gCouldPrint = true;			// Could be OK now
		TMenuBarManager::InvalidateMenus();			// so the menus stay in sync.
	}

	return sfPrinterChangeLevel;
}

//----------------------------------------------------------------------------------------
// void TClassicPrintJob::StartPrintJob: 
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::StartPrintJob(CPrintJobStarterStopper* starterStopper)
// StartPrintJob is called to start up a print job and returns a true if the job
// was actually started.  If the print job has already been started then a false is
// returned.
//
// starterStopper:	A CPrintJobStarterStopper* which made the call.
//
// Call:		Seldom.  StartPrintJob is usally called by an instance of CPrintJobStarterStopper
//				in response to a call to some other TClassicPrintJob or TPrintInfo routine.
// Override:	Never.
{
	#pragma unused (starterStopper)
	
	bool	jobStarted = false;
	
	if (!fIsActive)
	{
		fResFile = CurResFile_AC();
		ClearError();					// Clear printer-error flag 

		if (sfPrintShopOpens <= 0)
		{
			OpenPrintShop();
									 
			// The Universal Headers as of 10/17/95 don't provide the following constant!!!
			static const OSErr kPAPNoPrinter = -4101;
		
			OSErr err = GetError();					// Get code 
			if (err != noErr)
			{
				if ((err == fnfErr) || (err == resFNotFound) || (err == resNotFound) || (err == dirNFErr) || (err == kPAPNoPrinter))
					err = kPMNoDefaultPrinter;
				else if ((err == fBsyErr) || (err == opWrErr))
					err = errPrintDriverBusy;
				::ThrowException_AC(err, 0);
			}
	
			fIsActive = true;
			jobStarted = true;
		}
	}

	++sfPrintShopOpens;

	if (jobStarted)
		Changed(mPrinterOpened, starterStopper);
	
	return jobStarted;
}

//----------------------------------------------------------------------------------------
// void TClassicPrintJob::StopPrintJob: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::StopPrintJob(CPrintJobStarterStopper*	starterStopper,
									bool						wasStarted)
// StopPrintJob is called to shut down a print job.  Since multiple overlapping start
// job requests may be made only that oldest request to shut down the print job will
// be honored.
//
// starterStopper:	A CPrintJobStarterStopper* which made this call.  This can be compared
//					to the starterStopper which last called StartPrintJob if necessary
//					(though that information is not saved by this implementation).
// wasStarted:		A bool indicating if this instance of starterStopper was the one which
//					caused the job to be opened.
//
// Call:		Seldom.  StopPrintJob is usally called by the destructor of an instance of
//				CPrintJobStarterStopper. 
// Override:	Rarely.  Override only if you have a custom print job which must restore
//				additional job related information.
{
	#pragma unused (starterStopper)
	
	--sfPrintShopOpens;

	if (wasStarted)
	{
		if (GetError() == kPMNoDefaultPrinter)
		{
			TPrintHandler::gCouldPrint = false;		// well, we didn't make it. don't bother to try again
			TMenuBarManager::InvalidateMenus();		// so the menus stay in sync.
		}

		bool didClose = false;

		if (sfPrintShopOpens == 0)
		{
			ClosePrintShop();
#if qDebugMsg
			OSErr err = GetError();
			// Now check for fresh error from Print Manager --
			// only for debugging, since WasPrintError
			// checks afresh in the real world
			if (err != noErr)
				ProgramReport_AC("TClassicPrintJob::StopPrintJob: Error closing print shop: %1d\n", err);
#endif

			didClose = true;
		}
	
		if (didClose)
			Changed(mPrinterClosed, starterStopper);

		UseResFile_AC(fResFile);
		SetPortWindowPort(gWorkPort);			// Might be left looking at a dead port 
		gDispatcher->InvalidateFocus();

		fIsActive = false;
	}
#if qDebug
	else if (sfPrintShopOpens == 0)
	{
		// This should have probably been the call which shut down the print shop
		// but whoever called us doesn't seem to think so.
		ProgramReport_AC("TClassicPrintJob::StopPrintJob: Our caller does not think we should shut down but our count indicates we should.");
	}
#endif

	if (sfPrintShopOpens < 0)
	{
#if qDebug
		ProgramReport_AC("TClassicPrintJob::StopPrintJob: Too many calls to shut down print job.");
#endif
		sfPrintShopOpens = 0;
	}
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetError: 
//----------------------------------------------------------------------------------------

OSErr TClassicPrintJob::GetError() const
{
	return ::PrError();
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::WasPrintError: 
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::WasPrintError(OSErr& error, bool& ranOutOfSpace) const
{
	bool proceed = true;			// Default is "No error so proceed!"
	error = GetError();
	if (error != noErr)
	{
#if qDebugMsg
		if (gDebugPrinting)
			ProgramReport_AC("TClassicPrintJob::WasPrintError: Error from PrError is %d\n", error);
#endif
		proceed = false;
		if (error == iPrSavPFil || error == dskFulErr)
			ranOutOfSpace = true;
	}

	return proceed;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetError: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetError(OSErr err)
{
	::PrSetError(err);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::StartJob: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::StartJob(const CString_AC& docTitle, long numPages)
{
	#pragma unused (numPages)

	CPrintJobStarterStopper		jobStarterStopper(this);

	fCurrentDocTitle = docTitle;
	sfPrintPort = ::PrOpenDoc(GetHPrint(), NULL, NULL);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::FinishJob: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::FinishJob()
{
	::PrCloseDoc((TPPrPort)GetJobPort());			// This will close the port!
	sfPrintPort = NULL;
	::SetPortWindowPort(gWorkPort);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::StartPage: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::StartPage(long pageNumber)
{
	#pragma unused (pageNumber)
	::PrOpenPage((TPPrPort)GetJobPort(), NULL);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::FinishPage: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::FinishPage()
{
	::PrClosePage((TPPrPort)GetJobPort());
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::CallJobDialog: 
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::CallJobDialog()
{
	::ThrowIfOSErr_AC(MAInteractWithUser());
	PullApplicationToFront();

	::SetCursorToArrow_AC();
	if (gDispatcher)
		gDispatcher->InvalidateMouseRegions();

	CPrintJobStarterStopper		jobStarterStopper(this);

	gDispatcher->AboutToLoseControl(true);		// so scrap gets converted and floaters get removed
	bool result = ShowPrintDialog();
	gDispatcher->RegainControl(true);			// scrap gets converted, printer gets checked, floaters get restored

	return result;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::CallStyleDialog: 
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::CallStyleDialog()
{
	::ThrowIfOSErr_AC(MAInteractWithUser());
	PullApplicationToFront();

	::SetCursorToArrow_AC();
	if (gDispatcher)
		gDispatcher->InvalidateMouseRegions();

	CPrintJobStarterStopper		jobStarterStopper(this);

	gDispatcher->AboutToLoseControl(true);		// so scrap gets converted and floaters get removed
	bool result = ShowSetupDialog();
	
	gDispatcher->RegainControl(true);			// scrap gets converted, printer gets checked, floaters get restored

	return result;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::ShowPrintDialog:
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::ShowPrintDialog()
{
	return ::PrJobDialog(GetHPrint());
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::ValidatePrintJob: 
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::ValidatePrintJob()
{
	CPrintJobStarterStopper		jobStarterStopper(this);
	bool						result = ::PrValidate(GetRawHPrint());

	return result;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetPrintJobDefaults: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetPrintJobDefaults()
{
	CPrintJobStarterStopper		jobStarterStopper(this);

	PrintDefault(GetRawHPrint());
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::CallPrPicFile: 
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::CallPrPicFile(OSErr& err)
{
	CPrintJobStarterStopper		jobStarterStopper(this);

	bool returnVal = true;

	TPrStatus prStatus;
	::PrPicFile(GetRawHPrint(), NULL, NULL, NULL, &prStatus);

	bool b;

	if (returnVal)
		returnVal = WasPrintError(err, b);

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetDriverName: 
//----------------------------------------------------------------------------------------

CString_AC TClassicPrintJob::GetDriverName()
{
	return CString_AC(static_cast<ResNumber>(kPrintDriverName));	// Get current driver 
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::Update:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::Update() const
{
	// Printer name may have changed… out with the old in with the new...
	fPrinterChangeLevel = sfPrinterChangeLevel;
	
	TPrintInfo::Update();
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::DoUpdate:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::DoUpdate(ChangeID_AC theChange,
						 MDependable_AC* changedObject,
						 void* changeData,
						 CDependencySpace_AC* dependencySpace)
{
	switch (theChange)
	{
		case mRegainControl:
			if (CheckPrinterChangeLevel() != fPrinterChangeLevel)
			{
 				Invalidate();
				Changed(mPrinterChanged, this);

			}
			break;

		default:
			TPrintInfo::DoUpdate(theChange, changedObject, changeData, dependencySpace);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::JobMerge:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::JobMerge(TRefCntPrintInfo mergeFrom)
{
	CPrintJobStarterStopper		jobStarterStopper(this);
	::PrJobMerge(dynamic_cast_or_throw_AC(TClassicPrintJob*, mergeFrom.get())->GetHPrint(), GetHPrint());
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::IdleProc: 
//----------------------------------------------------------------------------------------

pascal void TClassicPrintJob::IdleProc()
{
	if (gJobPrintHandler)
	{
		CTempUseResFile_AC tempUseResFile(CurResFile_AC()); // save it so it can be restored if someone forgets

		GrafPtr		savedPort;
		GetPort(&savedPort);
		SetPortWindowPort(gWorkPort);

		TPrintHandler*	currentPrintHandler = TPrintHandler::gCurrPrintHandler.release();	// So we can focus when updating and activating windows
		bool			printingStatus = TView::gPrinting;
		TView::gPrinting = false;

		gDispatcher->SetEventLevel(gDispatcher->GetEventLevel() + 1);				// Increment the event level for proper busy cursor handling
		dynamic_cast_or_throw_AC(TClassicPrintJob*, gJobPrintHandler->fPrintInfo.get())->DoPrintIdling();		// Forward to the current print job handler
		gDispatcher->SetEventLevel(gDispatcher->GetEventLevel() - 1);

		TPrintHandler::gCurrPrintHandler = currentPrintHandler;
		TView::gPrinting = printingStatus;

		::SetPort_AC(savedPort);
	}
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::DoPrintIdling: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::DoPrintIdling()
{
	const short myDlgMask = mDownMask | mUpMask | keyDownMask | keyUpMask | autoKeyMask | activMask;

//	TToolboxEvent * event = gDispatcher->GetEvent(myDlgMask, 0, NULL);
	TToolboxEvent event(gDispatcher, NULL, TToolboxEvent::kDontFree);
	bool gotAnEvent = gDispatcher->GetEvent(myDlgMask, 0, NULL, event);
	if (gotAnEvent)
	{
		// Workaround for LaserWriter driver bug: it tries to set GhostWindow
		// so that its status window is invisible. Unfortunately, it doesn't
		// always set it, so IsDialogEvent returns false (the status window
		// is frontmost).  If ours isn't already in front, force it there.
		if ((WindowRef)fPrintDialog != FrontWindow())
			TWindow::MASelectToolboxWindow((WindowRef)fPrintDialog);// 3.5

		switch (event.GetWhat())
		{
			case keyDown:
				{
					if (((event.GetText() == '.') && event.IsCommandKeyPressed()) ||
						((event.GetText() == chEscape) && (event.GetKeyCode() == kEscapeVirtualCode)))
					{
						short item = 1;			// Want the 'Cancel' button 

//						if (fPrintingCommand == cFinderPrint || fPrintingCommand == cDragPrint)
//						item = cancel;		// Want the 'Cancel All' button 

						// Flash the appropriate button 
						Handle theItem;
						short itemType;
						CRect_AC box;
						GetDialogItem(fPrintDialog, item, &itemType, &theItem, box);

						HiliteControl((ControlRef)theItem, 10);
						DelayFuture_AC(8);
						HiliteControl((ControlRef)theItem, 0);

						SetError(iPrAbort);
						gCancelAllPrinting = true;
					}
					break;
				}

			default:
				{
					EventRecord anEventRecord = event.GetEventRecord(0);
					DialogRef aDialog;
					short item;
					if (IsDialogEvent(&anEventRecord) && DialogSelect(&anEventRecord, &aDialog, &item) && (aDialog == fPrintDialog))
					{
						switch (item)
						{
							case 1:
								SetError(iPrAbort);// Cancel
								break;

							case cancel:		// Cancel All Printing 
								SetError(iPrAbort);
								gCancelAllPrinting = true;
								break;
						}
					}
					else if (event.GetWhat() == mouseDown)
					{
						WindowRef aWindow;
						short itsPart = ::FindWindow_AC(event.GetWhere(), &aWindow);
						if (itsPart == inDrag && aWindow == (WindowRef)fPrintDialog)
						{
							CRect_AC moveBounds(-32000, -32000, 32000, 32000);
							TWindow::MADragWindow((WindowRef)fPrintDialog, event.GetWhere(), moveBounds);
						}
					}
					break;
				}
		}
	}
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::PosePrintDialog: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::PosePrintDialog(const CString_AC& docName, CommandNumber aCommandNumber)
// PosePrintDialog presents the application modal dialog which presents printing
// progress information.
//
// docName:			The name of the document being printed.
// aCommandNumber:	The number of the command causing the printing to be performed.
{
	short			dlgNumber;
	DialogTHndl		dlogTemplate;
	short			itemNo;
	Handle			theItem;
	short			itemType;
	CRect_AC		box;
	Str255			itemText;

	::ThrowIfOSErr_AC(MAInteractWithUser());

	if (aCommandNumber == cFinderPrint || aCommandNumber == cDragPrint)
	{
		dlgNumber = phFinderPrintDialog;
		itemNo = 3;
	}
	else
	{
		dlgNumber = phSpoolPrintDialog;
		itemNo = 2;
	}

	// Can't use GetNewCenteredDialog because vertically centering the dialog may cause it
	// to interfere with the Print Manager's status windows.  Therefore, leave the vertical
	// location of the dialog fixed.

	::SetCursorToArrow_AC();
	gDispatcher->InvalidateMouseRegions();
	dlogTemplate = (DialogTHndl)CMultiLocale_AC::GetResource('DLOG', dlgNumber);
	if (dlogTemplate)
	{
		CenterRectOnScreen(((CRect_AC &)(*dlogTemplate)->boundsRect), true, false, false);
		fPrintDialog = GetNewDialog(CMultiLocale_AC::GetExistingResourceID('DLOG', dlgNumber), NULL, (WindowRef) - 1);
		::ThrowIfNULL_AC(fPrintDialog);
	}
	else
	{
#if qDebugMsg
		ProgramReport_AC("You may have forgotten to include Printing.rsrc in your .r file…\n");
		::ProgramBreak_AC("The print job dialog resource can't be found.");
#endif

		::ThrowIfNULLResource_AC((Handle)dlogTemplate);
	}

	// Substitute the document name for '<<!=>>' in 'Document “<<!=>>” is being printed'.
	// ParamText would be a lot simpler, but the Print Mgr. also uses ParamText, and
	// the substitution doesn't happen until draw time.
	GetDialogItem(fPrintDialog, itemNo, &itemType, &theItem, &box);
	if (theItem)
	{
		GetDialogItemText(theItem, itemText);
		CStr255_AC	newItemText(CString_AC(itemText).DoSubstitution(docName));
		SetDialogItemText(theItem, newItemText);
	}

	SetPrintIdleProc();
	
	SetWTitle((WindowRef)fPrintDialog, CStr255_AC(docName));// In case Print Mgr. needs it. 
	DrawDialog(fPrintDialog);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::BanishPrintDialog: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::BanishPrintDialog()
{
	if (fPrintDialog)
	{
		if (GetWindowPort(fPrintDialog) == GetCGrafPtr_AC())// Only need to invalidate focus if freed
		// dialog is the current port
		{
			gDispatcher->InvalidateFocus();
			SetPortWindowPort(gWorkPort);
		}
		DisposeDialog(fPrintDialog);
		fPrintDialog = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::ShowDocBeingPrinted: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::ShowDocBeingPrinted(const CString_AC& docName, bool entering)
{
	if (entering)
	{
		fPrintDialog = GetNewDialog(phWhichDoc, NULL, (WindowRef) - 1);
		if (fPrintDialog)
		{
			SetWTitle((WindowRef)fPrintDialog, CStr255_AC(docName));
			DrawDialog(fPrintDialog);
		}
#if qDebug
		else
		{
			CString_AC	theString;
			stringprintf(theString, "%d", phWhichDoc);
			::ProgramBreak_AC("TClassicPrintJob::ShowDocBeingPrinted: Unable to load dialog " + theString);
		}
#endif

	}
	else
		BanishPrintDialog();
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetMaxSquareResolution:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::GetMaxSquareResolution(Fixed& hRes, Fixed& vRes) const
{
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TClassicPrintJob*>(this));

	TGetRslBlk aGetRslData;
	aGetRslData.iOpCode = getRslDataOp;
	aGetRslData.iError = 0;

	PrintGetGeneral(&aGetRslData);

	if (GetError() == noErr)
	{
		short dpi = 0;
		for (short i = 0; i < aGetRslData.iRslRecCnt; ++i)
			if (aGetRslData.rgRslRec[i].iXRsl == aGetRslData.rgRslRec[i].iYRsl)
			// only square 
				dpi = Max_AC(dpi, aGetRslData.rgRslRec[i].iXRsl);

		hRes = dpi;
		vRes = dpi;
	}
	else
	{
		hRes = IntToFixed(TPrintInfo::scClassicQDResolution);
		vRes = hRes;
	}
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetResolution:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetResolution(Fixed hRes, Fixed vRes)
{
	TSetRslBlk aSetRslData;
	aSetRslData.iOpCode = setRslOp;
	aSetRslData.iError = 0;
	aSetRslData.hPrint = GetHPrint();
	aSetRslData.iXRsl = hRes;
	aSetRslData.iYRsl = vRes;
	
	PrintSetGeneral(&aSetRslData);

	::ThrowIfOSErr_AC(GetError());

	Invalidate();
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::MaximizeResolution:
//----------------------------------------------------------------------------------------

void TClassicPrintJob::MaximizeResolution()
{
	// Thank you, A.D.
	CPrintJobStarterStopper		jobStarterStopper(this); // for grouping the two calls together

	long hRes;
	long vRes;
	GetMaxSquareResolution(hRes, vRes);
	SetResolution(hRes, vRes);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::GetScale:
//----------------------------------------------------------------------------------------

short TClassicPrintJob::GetScale() const
{
	CViewRect printingRect(GetPaperRect());
	VHSelect longerDirection = LongerSide(printingRect);
	ViewCoordinate projectionPaperSize = printingRect.GetSize()[longerDirection];

	//
	// NOTE: iPageV/H are currently undocumented but have a long history of safe usage. I would gladly
	// use any other means to calculate the scaling percentage if it was available. Any ideas?
	//
	short iPageV = (*GetHPrint())->prStl.iPageV;
	short iPageH = (*GetHPrint())->prStl.iPageH;
	
	short paperSizeIn_iPrPgFract = Max_AC(iPageH, iPageV);
	short paperSizeInDeviceResDPI = (paperSizeIn_iPrPgFract * GetDeviceRes()[longerDirection]) / iPrPgFract;
	
	return (paperSizeInDeviceResDPI * 100) / projectionPaperSize;
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::TotalSize:
//----------------------------------------------------------------------------------------

Size TClassicPrintJob::TotalSize(bool justLocked) const
{
	return GetHandleSizeIfLocked(reinterpret_cast<Handle>(fHPrint.get()), justLocked);
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::ShowSetupDialog: 
//----------------------------------------------------------------------------------------

bool TClassicPrintJob::ShowSetupDialog()
{
	return ::PrStlDialog(GetHPrint());
}

//----------------------------------------------------------------------------------------
// TClassicPrintJob::SetPrintIdleProc: 
//----------------------------------------------------------------------------------------

void TClassicPrintJob::SetPrintIdleProc()
{
	static PrIdleUPP	sPrintIdleProc = NULL;
	if (!sPrintIdleProc)
		sPrintIdleProc = NewPrIdleProc(TClassicPrintJob::IdleProc);
	::ThrowIfNULL_AC(sPrintIdleProc);		// It shouldn't be null by now.
	(*GetHPrint())->prJob.pIdleProc = sPrintIdleProc;
}

//----------------------------------------------------------------------------------------
// End of UClassicPrinting.cpp

