//----------------------------------------------------------------------------------------
// UUpDownControl.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __UUPDOWNCONTROL__
#include "UUpDownControl.h"
#endif

#if qAppearance || qEmulateStandardControls

// ACS

#if qEmulateStandardControls

	#ifndef __CUpDownControl_AC__
	#include "CUpDownControl_AC.h"
	#endif

	#ifndef __AGA_AC__
	#include "AGA_AC.h"
	#endif

#endif

// MacApp

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif


//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUUpDownControl
//----------------------------------------------------------------------------------------

void InitUUpDownControl()
{
	static bool UUpDownControlInitialized;

	if (!UUpDownControlInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TUpDownControl, kStdUpDownControl);
		}
		UUpDownControlInitialized = true;
	}
}

//========================================================================================
// CLASS TUpDownControl
//========================================================================================

#undef Inherited
#define Inherited TCtlMgr

MA_DEFINE_CLASS(TUpDownControl);

//----------------------------------------------------------------------------------------
// TUpDownControl constructor
//----------------------------------------------------------------------------------------

TUpDownControl::TUpDownControl(const CViewPoint& itsLocation,
								 const CViewPoint& itsSize,
								 SizeDeterminer itsHSizeDet,
								 SizeDeterminer itsVSizeDet,
							     IDType itsLinkedNumberTextID) :
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, gEmptyString),
	fLinkedNumberTextID(itsLinkedNumberTextID),
	fLinkedNumberText(NULL)
{
}

//----------------------------------------------------------------------------------------
// TUpDownControl copy constructor
//----------------------------------------------------------------------------------------

TUpDownControl::TUpDownControl(const TUpDownControl& inUpDownControl) :
	TCtlMgr(inUpDownControl),
	fLinkedNumberTextID(inUpDownControl.fLinkedNumberTextID),
	fLinkedNumberText(NULL) // NULL causes the reference to be found again when needed.
{

}

//----------------------------------------------------------------------------------------
// TUpDownControl destructor
//----------------------------------------------------------------------------------------

TUpDownControl::~TUpDownControl()
{
}

//----------------------------------------------------------------------------------------
// TUpDownControl::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TUpDownControl::GetStandardSignature() const
{
	return kStdUpDownControl;
}

//----------------------------------------------------------------------------------------
// TUpDownControl::ReadFields: 
//----------------------------------------------------------------------------------------

void TUpDownControl::ReadFields(CStream_AC* aStream)				// Override 
{
	Inherited::ReadFields(aStream);

	*aStream >> fLinkedNumberTextID;
}

//----------------------------------------------------------------------------------------
// TUpDownControl::WriteFields: 
//----------------------------------------------------------------------------------------

void TUpDownControl::WriteFields(CStream_AC* aStream) const			// Override 
{
	Inherited::WriteFields(aStream);

	*aStream << fLinkedNumberTextID;
}

//----------------------------------------------------------------------------------------
// TUpDownControl::HandleNotification
//----------------------------------------------------------------------------------------

void TUpDownControl::DoControlAction(ControlPartCode partCode)
{
	// Update the linked TNumberText, if any, call the
	// installed notification function, and propagate our
	// event number.
	short deltaValue = partCode == kControlUpButtonPart ? 1 : -1;
	TNumberText* itsNumberText = GetLinkedNumberText();
	if (itsNumberText != NULL)
		itsNumberText->SetValue(itsNumberText->GetValue() + deltaValue, kRedraw);

	HandleEvent(fEventNumber, this, NULL);

	(void) Focus();
}

//----------------------------------------------------------------------------------------
// TUpDownControl::SetLinkedNumberTextID
//----------------------------------------------------------------------------------------

void TUpDownControl::SetLinkedNumberTextID(IDType linkedNumberTextID)
{
	fLinkedNumberTextID = linkedNumberTextID;
	fLinkedNumberText = NULL; // causes it to be found again when needed.
}

//----------------------------------------------------------------------------------------
// TUpDownControl::SetLinkedNumberTextID
//----------------------------------------------------------------------------------------

TNumberText* TUpDownControl::GetLinkedNumberText()
{
	if (fLinkedNumberTextID != kNoIdentifier && fLinkedNumberText == NULL)
	{
		fLinkedNumberText = dynamic_cast_AC(TNumberText*,GetRootView()->FindSubView(fLinkedNumberTextID));
	}
	
	return fLinkedNumberText;
}

//----------------------------------------------------------------------------------------
// TUpDownControl::DoMakeControl
//----------------------------------------------------------------------------------------


CControl_AC* TUpDownControl::DoMakeControl(WindowRef theWindow,
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled, 
									const CStr255_AC& /*itsTitle*/)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CUpDownControl_AC(boundsRect, isEnabled, this);
	else
#endif // qEmulateStandardControls
		return CreateLittleArrows_AC(theWindow, boundsRect, isVisible, isEnabled, this);
}

#endif // qAppearance || qEmulateStandardControls


//----------------------------------------------------------------------------------------
// End of UUpDownControl.cpp
