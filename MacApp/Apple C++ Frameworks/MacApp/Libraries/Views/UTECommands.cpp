//----------------------------------------------------------------------------------------
// UTECommands.cpp
// Copyright � 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/20/01	[C] Make TCommand responsible for writing out a new clip view 
					to the desk scrap. 
		05/07/01	Comment out pragma messages for Carbon. 
		04/25/01	Call ClearForPutting before putting data in the scrap. 
		04/23/01	Protected gClipboardMgr fields. 
		01/15/01	There is no need to initialize fOldStaticText in ctors.  Use
					CString_AC functions instead of CStr255_AC.
		01/02/01	Update copyright.
		11/13/00	[PB] Change initialization order to match declaration. 
					Suppress unused variable warning in InstallNewText. 
		11/11/00	Cosmetic.  Eliminated Inherited.
		11/04/00	[C] Don�t include Packages.h.
		11/01/00	[PB] Include MacErrors instead of Errors.
		09/19/00	[C] Have TTECutCopyCommand::DoIt write to scrap immediately.
		09/07/00	Added embedded documentation.
		05/23/00	[2279264] Remove false from ProgramReport_AC.
		04/20/00	Include UPrinting.h instead of UPrintHandler.h.
		04/19/00	Removed UPrintHandler.h, as no longer used.
		11/04/99	Carbon: Move GivePasteData API back to what it was (remove ScrapRef).
					The clipboard will get the current scrap, instead of the caller.
		07/23/99	[C] New scrap management in TTEPasteCommand.
		03/29/99	Rename Patterns_AC to CPattern_AC to avoid confusion with the
					include file.
		03/26/99	Remove _AC from SetPenPatToWhite.
		03/24/99	Update copyright notice.
		03/23/99	Renamed SetPenPatToWhite_AC to Patterns_AC::SetPenPatToWhite.
		03/22/99	[W] TEKey not available in Windows.
		11/12/98	[2279244] Replaced dynamic_cast with dynamic_cast_AC.
		11/09/98	[2279101] Moved CSuppressTESelection into new TextUtil_AC.h/.cpp.
					Include TextUtil_AC.h.
		11/05/98	Carbon - use SetPenPatToWhite_AC
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.
		10/27/98	Carbonize
		10/08/98	MPurgeable.
*/

#ifndef __UTECOMMANDS__
#include "UTECommands.h"
#endif

// ACS

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __TextUtils_AC__
#include "TextUtils_AC.h"
#endif

// MacApp

#ifndef __UCLIPBOARDMGR__
#include "UClipboardMgr.h"
#endif

#ifndef __UDIALOGTEVIEW__
#include "UDialogTEView.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UEDITTEXT__
#include "UEditText.h"
#endif

#ifndef __UERRORMGR__
#include "UErrorMgr.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPATCH__
#include "UPatch.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __USCROLLER__
#include "UScroller.h"
#endif

#ifndef __USTATICTEXT__
#include "UStaticText.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// Toolbox

#ifndef __ALIASES__
#include <Aliases.h>
#endif

#ifndef __DIALOGS__
#include <Dialogs.h>
#endif

#if !qCarbon
	#ifndef __EDITIONS__
	#include <Editions.h>
	#endif
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MENUS__
#include <Menus.h>
#endif

#if !qCarbon
	#ifndef __PACKAGES__
	#include <Packages.h>
	#endif
#endif

#ifndef __SCRAP__
#include <Scrap.h>
#endif

#ifndef __SCRIPT__
#include <Script.h>
#endif

#ifndef __TOOLUTILS__
#include <ToolUtils.h>
#endif

// ANSI

#ifndef __STRING__
#include <string.h>
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

#if qDebug

//----------------------------------------------------------------------------------------
// DumpTTECommand:
//----------------------------------------------------------------------------------------

void DumpTTECommand(TTECommand* theTTECommand)
{
	long oldStyleSize;
	long newStyleSize;
	long last;

	long oldDiff = Max_AC(theTTECommand->fOldEnd - theTTECommand->fOldStart, 0L);
	long newDiff = Max_AC(theTTECommand->fNewEnd - theTTECommand->fNewStart, 0L);

	ProgramReport_AC("old start/end, TH_new start/end, diff :%1d/%1d,  %1d/%1d,  %1d \n", theTTECommand->fOldStart, theTTECommand->fOldEnd, theTTECommand->fNewStart, theTTECommand->fNewEnd, Max_AC(oldDiff, newDiff));
	ProgramReport_AC("fTextPad :%1d\n", theTTECommand->fTextPad);
	ProgramReport_AC("fPadding size :%1d\n", GetHandleSize(theTTECommand->fPadding));

	oldStyleSize = 0;
	newStyleSize = 0;
	ProgramReport_AC("** Old styles:\n");

	if (!theTTECommand->fOldStyles)
		ProgramReport_AC("NONE!\n");
	else
	{

		last = (*theTTECommand->fOldStyles)->scrpNStyles;
		ProgramReport_AC("Number of table entries: %1d\n", last);
		for (long i = 0; i <= last - 1; ++i)
		{
			ScrpSTElement & theScrpSTElement = (*theTTECommand->fOldStyles)->scrpStyleTab[i];

			ProgramReport_AC("%1d, ofs:%1d ", theScrpSTElement.scrpStartChar);
			ProgramReport_AC("\n");
		}
		oldStyleSize = GetHandleSize((Handle)(theTTECommand->fOldStyles));
	}

	ProgramReport_AC("** New styles:\n");

	if (!theTTECommand->fNewStyles)
		ProgramReport_AC("NONE!\n");
	else
	{
		last = (*theTTECommand->fNewStyles)->scrpNStyles;
		ProgramReport_AC("Number of table entries: %1d\n", last);
		for (long i = 0; i <= last - 1; ++i)
		{
			ScrpSTElement & theScrpSTElement = (*theTTECommand->fNewStyles)->scrpStyleTab[i];

			ProgramReport_AC("%1d, ofs:%1d ", theScrpSTElement.scrpStartChar);
			ProgramReport_AC("\n");
		}
		newStyleSize = GetHandleSize((Handle)(theTTECommand->fNewStyles));
	}

	ProgramReport_AC("Styles size diff: %1d\n", Max_AC(newStyleSize, oldStyleSize));
	ProgramReport_AC("fStylePad :%1d\n", theTTECommand->fStylePad);
}

#endif

//========================================================================================
// CLASS TTECommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TTECommand constructor
//----------------------------------------------------------------------------------------

TTECommand::TTECommand(TTEView*			itsTEView,
						CommandNumber	itsCommandNumber,
						bool			itsSaveText)
	:	TCommand(itsCommandNumber, NULL, kCanUndo, kCausesChange, NULL),
		fTEView(NULL),
		fEditText(NULL),
		fHTE(NULL),
		fOldStart(0),
		fOldEnd(0),
		fOldText(NULL),
		fOldStyles(NULL),
		fNewStart(0),
		fNewEnd(0),
		fNewText(NULL),
		fNewStyles(NULL),
		fPadding(NULL),
		fTextPad(0),
		fStylePad(0)
{
	CommonInit(itsTEView, itsCommandNumber, itsSaveText);
}

//----------------------------------------------------------------------------------------
// TTECommand::ITECommand:
//----------------------------------------------------------------------------------------

TTECommand::TTECommand(TEditText*		itsEditText,
						CommandNumber	itsCommandNumber,
						bool			itsSaveText)
	:	TCommand(itsCommandNumber, NULL, kCanUndo, kCausesChange, NULL),
		fTEView(NULL),
		fEditText(NULL),
		fHTE(NULL),
		fOldStart(0),
		fOldEnd(0),
		fOldText(NULL),
		fOldStyles(NULL),
		fNewStart(0),
		fNewEnd(0),
		fNewText(NULL),
		fNewStyles(NULL),
		fPadding(NULL),
		fTextPad(0),
		fStylePad(0)
{
	fEditText = itsEditText;
	AssureTEView();

	CommonInit(fTEView, itsCommandNumber, itsSaveText);

	ForgetTEView();
}

//----------------------------------------------------------------------------------------
// TTECommand::ITECommand:
//----------------------------------------------------------------------------------------

void TTECommand::CommonInit(TTEView*		itsTEView,
							CommandNumber	itsCommandNumber,
							bool			itsSaveText)
{
	fContext = itsTEView ? itsTEView->GetContext(itsCommandNumber) : NULL;
	fObjectToNotify = fContext;

	fTEView = itsTEView;
	fEditText = itsTEView->GetEditText();

	fHTE = itsTEView->fHTE;

	short selChars;
	{
		TERec & theTERec = **fHTE;

		fOldStart = theTERec.selStart;
		fOldEnd = theTERec.selEnd;
		selChars = theTERec.selEnd - theTERec.selStart;
	}

	if (itsSaveText)
	{
		Handle h = NewPermHandle(selChars);

		if (selChars > 0)
			BlockMove_AC((Ptr)((*((*fHTE)->hText)) + fOldStart), (*h), selChars);

		fOldText = h;
		fTextPad = fOldStart - fOldEnd;
		fPadding = NewPermHandle(0);

		if (fEditText)
			fOldStaticText = fEditText->TStaticText::GetText();
	}

	// TextEdit has this "feature" which it exercises if it runs out of memory. It's
	// called DS number 25. We'll try to avoid it by assuring that enough memory
	// exists to fulfill the request, but we won't die because of it. This is a
	// particularly ugly situation - there could be >600K of style information
	// associated with a 32K block of text. And to support undo, we've got to assume
	// that there may momentarily be THREE copies floating around, adding up to a
	// total potential liability of almost 2 Meg for a single TE record. The worst
	// that can happen, though, is that the text will be safe, but it won't have any
	// styles associated with it.

	if (itsTEView->SpaceForStyles((*fHTE)->selStart, (*fHTE)->selEnd))
	{
		CTempAllocation tempAllocation(false);
		fOldStyles = TEGetStyleScrapHandle(fHTE);

		::ThrowIfNULL_AC(fOldStyles);

		fStylePad = GetHandleSize((Handle)fOldStyles);
	}
}

//----------------------------------------------------------------------------------------
// TTECommand destructor
//----------------------------------------------------------------------------------------

TTECommand::~TTECommand()
{
	fOldText = ::DisposeIfHandle_AC(fOldText);
	fOldStyles = (StScrpHandle)::DisposeIfHandle_AC((Handle)fOldStyles);
	fNewText = ::DisposeIfHandle_AC(fNewText);
	fNewStyles = (StScrpHandle)::DisposeIfHandle_AC((Handle)fNewStyles);
	fPadding = ::DisposeIfHandle_AC(fPadding);
}

//----------------------------------------------------------------------------------------
// TTECommand::AssureTEView:
//----------------------------------------------------------------------------------------

void TTECommand::AssureTEView()
{
	if (fEditText)
	{
		if (!fEditText->fTEView)
			fEditText->InstallFloatingTEView(false);

		fTEView = fEditText->fTEView;
		fHTE = fTEView->fHTE;
	}
}

//----------------------------------------------------------------------------------------
// TTECommand::ForgetTEView:
//----------------------------------------------------------------------------------------

void TTECommand::ForgetTEView()
{
	if (fEditText)
	{
		fTEView = NULL;							// null these references so dependency
		fHTE = NULL;							// notifications work correctly.
	}
}

//----------------------------------------------------------------------------------------
// TTECommand::DoPostProcess
//----------------------------------------------------------------------------------------

void TTECommand::DoPostProcess()
{
	if (fEditText)
	{
		TWindow * theWindow = fEditText->GetWindow();
		TEventHandler * windowTarget = theWindow ? theWindow->GetWindowTarget() : NULL;

		if (!theWindow || (windowTarget != fTEView && windowTarget != fEditText))
		{
			if (!fEditText->IsValid())
				SetValidationError((OSErr)kInvalidValue);
			fEditText->StopEdit();
		}
		ForgetTEView();
	}
}

//----------------------------------------------------------------------------------------
// TTECommand::BanishOldText:
//----------------------------------------------------------------------------------------

void TTECommand::BanishOldText()
// BanishOldText checks if the selection is valid and then removes the text
// that is being deleted or replaced.
//
// Call?		Seldom.
// Override?	Seldom.
{
	if (fOldEnd > fOldStart)
		TEDelete(fHTE);
	if (fPadding)
		SetPermHandleSize(fPadding, Max_AC(-(fTextPad + fStylePad), 0));
}

//----------------------------------------------------------------------------------------
// TTECommand::InstallNewText:
//----------------------------------------------------------------------------------------

void TTECommand::InstallNewText()
{
	if (fNewEnd > fNewStart)
	{
		Handle itsText = fTEView->fText;
		long savedSize = GetHandleSize(itsText);

#if qDebug
		if (!fNewText)
			::ProgramBreak_AC("InstallNewText called with fNewText == nil!");
#endif

		CTempHandleLock_AC tempHandleLock(fNewText, eMoveHi); // Prevent heap fragmentation for TEInsert

		// Replace invalid characters with spaces.

		bool allocationState = TemporaryAllocation(false);
		Handle space = NULL;
		unsigned char charSpace = chSpace;
		OSErr err = PtrToHand((Ptr)&charSpace, &space, 1);
		TemporaryAllocation(allocationState);

		::ThrowIfOSErr_AC(err);

#if !qMSWindows && !qCarbon
		// ���  [Mac]ReplaceText is not yet implemented in CarbonLibLite.
		// ��� NOTE: ReplaceText isn't working in QTML.  Figure out a workaround.
		for (unsigned char i = 0; i < chSpace; ++i)
		{
			if (!macroIn(fTEView->fControlChars, macroAsSetElem(i)))
			{
				CStr15_AC key = i;
				err = ReplaceText(fNewText, space, key);
				if (err < 0) ::ThrowIfOSErr_AC(err);
			}
		}
#endif

		fTEView->StyleInsert((*fNewText), GetHandleSize(fNewText), fNewStyles);

		if (GetHandleSize(itsText) <= savedSize)
			::ThrowIfOSErr_AC(memFullErr);
	}
}

//----------------------------------------------------------------------------------------
// TTECommand::RemoveAdditions:
//----------------------------------------------------------------------------------------

void TTECommand::RemoveAdditions()
{
	if (fNewText)
	{
		fTEView->SetSelection(fNewStart, fNewEnd, kRedraw);

		// Suppress TextEdit so that the spare carets are not left laying around.
		CSuppressTESelection	tempSuppressSelection(fHTE, false);
		TEDelete(fHTE);
	}
	if (fPadding)
		SetPermHandleSize(fPadding, Max_AC(fTextPad + fStylePad, 0));
}

//----------------------------------------------------------------------------------------
// TTECommand::RestoreSelection:
//----------------------------------------------------------------------------------------

void TTECommand::RestoreSelection()
{
	fTEView->SetSelection(fOldStart, fOldEnd, kRedraw);
}

//----------------------------------------------------------------------------------------
// TTECommand::PrepareForUndoRedo:
//----------------------------------------------------------------------------------------

void TTECommand::PrepareForUndoRedo()
{
	if (fEditText)
		fEditText->PrepareForUndoRedo(this);
	else if (fTEView)
		fTEView->PrepareForUndoRedo(this);
	else
		TCommand::PrepareForUndoRedo();
}

//----------------------------------------------------------------------------------------
// TTECommand::RevealUndoRedo:
//----------------------------------------------------------------------------------------

void TTECommand::RevealUndoRedo()
{
	if (fEditText)
		fEditText->RevealUndoRedo(this);
	else if (fTEView)
		fTEView->RevealUndoRedo(this);
	else
		TCommand::RevealUndoRedo();
}

//----------------------------------------------------------------------------------------
// TTECommand::ReviveDeletions:
//----------------------------------------------------------------------------------------

void TTECommand::ReviveDeletions()
{
	fTEView->SetSelection(fOldStart, fOldStart, !kRedraw);	// so insert will take place at right point
	short nChars = static_cast<short>(GetHandleSize(fOldText));
	if (nChars > 0)
	{
		Handle itsText = fTEView->fText;
		long savedSize = GetHandleSize(itsText);

		CTempHandleLock_AC tempHandleLock(fOldText, eMoveHi); // Prevent heap fragmentation

		fTEView->StyleInsert((*fOldText), nChars, fOldStyles);

		if (GetHandleSize(itsText) <= savedSize)
			::ThrowIfOSErr_AC(memFullErr);
	}

	if (fEditText)
		fEditText->TStaticText::SetText(fOldStaticText, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TTECommand::DoMainFunction:
//----------------------------------------------------------------------------------------

void TTECommand::DoMainFunction()
{
	if (fIdentifier != cCopy)
		BanishOldText();
	InstallNewText();
	if (fIdentifier != cCopy)
		fTEView->SynchView(kRedraw);
}

//----------------------------------------------------------------------------------------
// TTECommand::SetupDependencies:
//----------------------------------------------------------------------------------------

void TTECommand::SetupDependencies()
{
	TCommand::SetupDependencies();

	if (CanBeUndone())
	{
		if (fEditText)
			fEditText->AddDependent(this);
		else if (fTEView)
			fTEView->AddDependent(this);
	}
}

//----------------------------------------------------------------------------------------
// TCommand::DoUpdate:
//----------------------------------------------------------------------------------------

void TTECommand::DoUpdate(ChangeID_AC			theChange,
						  MDependable_AC*		changedObject,
						  void*					changeData,
						  CDependencySpace_AC*	dependencySpace)
{
	if ((theChange == mClosed) && ((changedObject == fTEView) || changedObject == fEditText))
		fContext->CommitLastCommand();
	else
		TCommand::DoUpdate(theChange, changedObject, changeData, dependencySpace);
}

//----------------------------------------------------------------------------------------
// TTECommand::DoIt:
//----------------------------------------------------------------------------------------

void TTECommand::DoIt()
{
	AssureTEView();
	fTEView->Focus();

	DoMainFunction();

#if qDebug
	if (TTEView::fgTEIntenseDebugging)
		DumpTTECommand(this);
#endif

	// Send a text changed event through the TE view.
	fTEView->HandleEvent(fIdentifier, fTEView, this);

	DoPostProcess();
}

//----------------------------------------------------------------------------------------
// TTECommand::UndoIt:
//----------------------------------------------------------------------------------------

void TTECommand::UndoIt()
{
	AssureTEView();
	fTEView->Focus();

	RemoveAdditions();
	if (fOldText || !fOldStaticText.empty())
		ReviveDeletions();

	RestoreSelection();
	if (fIdentifier != cCopy)
		fTEView->SynchView(kRedraw);

#if qDebug
	if (TTEView::fgTEIntenseDebugging)
		DumpTTECommand(this);
#endif

	// Send a text changed event through the TE view.
	fTEView->HandleEvent(cUndo, fTEView, this);

	DoPostProcess();
}

//----------------------------------------------------------------------------------------
// TTECommand::RedoIt:
//----------------------------------------------------------------------------------------

void TTECommand::RedoIt()
{
	AssureTEView();
	fTEView->Focus();

	RestoreSelection();
	DoMainFunction();

#if qDebug
	if (TTEView::fgTEIntenseDebugging)
		DumpTTECommand(this);
#endif

	// Send a text changed event through the TE view.
	fTEView->HandleEvent(fIdentifier, fTEView, this);

	DoPostProcess();
}

//----------------------------------------------------------------------------------------
// TTECommand::TotalSize:
//----------------------------------------------------------------------------------------

Size TTECommand::TotalSize(bool justLocked) const
{
	return GetHandleSizeIfLocked(fOldText, justLocked) +
		   GetHandleSizeIfLocked(reinterpret_cast<Handle>(fOldStyles), justLocked) +
		   GetHandleSizeIfLocked(fNewText, justLocked) +
		   GetHandleSizeIfLocked(reinterpret_cast<Handle>(fNewStyles), justLocked) +
		   GetHandleSizeIfLocked(fPadding, justLocked);
}

//========================================================================================
// CLASS TTECutCopyCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TTECutCopyCommand::TTECutCopyCommand
//----------------------------------------------------------------------------------------

TTECutCopyCommand::TTECutCopyCommand(TTEView* itsTEView, CommandNumber itsCommandNumber)
	:	TTECommand(itsTEView, itsCommandNumber, true),
		fClipCreated(false)
{
	fChangesClipboard = true;
	fCausesChange = (itsCommandNumber != cCopy);
	fCanUndo = fCausesChange;
}

//----------------------------------------------------------------------------------------
// TTECutCopyCommand::Free:
//----------------------------------------------------------------------------------------

TTECutCopyCommand::~TTECutCopyCommand()
{
	if (fClipCreated)
		fOldText = NULL;
}

//----------------------------------------------------------------------------------------
// TTECutCopyCommand::DoIt:
//----------------------------------------------------------------------------------------

void TTECutCopyCommand::DoIt()
{
	fTEView->Focus();

	CTextStyle_AC clipStyle(applFont, 0, 12, gRGBBlack);// Initial style same as virgin TEView

	CViewPoint itsSize(100, 50);					// An arbitrary initial size.
	CViewRect itsMargins(10, 8, 10, 0);				// No bottom margin.

	CAutoPtr_AC<TTEView> clipTEView = TH_new TTEView(gZeroVPt, itsSize, sizeSuperView, sizeVariable, itsMargins, clipStyle, teFlushDefault, true, true);
	clipTEView->fAcceptsChanges = false;		// This is a read-only view

	// Cut can eat into temp memory so users can rescue text from overweight documents
	if (!WillCauseChange())						// If Copy-ing, assure there's enough room
		FailSpaceIsLow();

	clipTEView->StuffText(fOldText);
	FailSpaceIsLow();

	TEFeatureFlag( teFOutlineHilite, teBitClear, clipTEView->fHTE ); // Turn off gray caret.

	TEUseStyleScrap(0, SHRT_MAX, fOldStyles,// �then put in the styles
						kDontRedraw, clipTEView->fHTE);
	FailSpaceIsLow();

	clipTEView->fFreeText = true;				// Let TEView know it has to free the text

	ClaimClipboard(clipTEView);					// Okay to claim (will call RecalcText!)
	clipTEView.release();

	fClipCreated = true;						// We be done
	DoMainFunction();							// Do the actual cut/copy

	// Send a text changed event through the TE view.
	fTEView->HandleEvent(fIdentifier, fTEView, this);

#if qDebug
	if (TTEView::fgTEIntenseDebugging)
	{
		TTEView::DumpTERecord(clipTEView->fHTE);
		DumpTTECommand(this);
	}
#endif
}

//----------------------------------------------------------------------------------------
// TTECutCopyCommand::ReviveDeletions:
//----------------------------------------------------------------------------------------

void TTECutCopyCommand::ReviveDeletions()
{
	if (fIdentifier == cCut)
		TTECommand::ReviveDeletions();			// Don't do it for COPY
}

//========================================================================================
// CLASS TTEPasteCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TTEPasteCommand::ITEPasteCommand: We can't use TEPaste because it clobbers the
// DeskScrap; the text would be recoverable from the special TextEdit Scrap, but other
// types of non-TEXT scrap are permanently lost, it seems
//----------------------------------------------------------------------------------------

TTEPasteCommand::TTEPasteCommand(TTEView* itsTEView)
	:	TTECommand(itsTEView, cPaste, true)		// Perform stock initializations
{
	Handle newText = NULL;
	StScrpHandle newStyles = NULL;

	try
	{
		newText = NewPermHandle(0);				// Create handle to receive clipboard data
		newStyles = (StScrpHandle)NewPermHandle(0);// Same for handle to receive style info

#if qCarbon
		//#pragma message ("TTEPasteCommand::ctor: Why is '%%%%' being used here?")
		// ���  I'm not sure why '%%%%' was being used here.
		ResType dataType = kTextType_AC;
#else
		ResType dataType = '%%%%';
#endif
		short newLength = static_cast<short>(gClipboardMgr->GetDataToPaste(newText, dataType));

		if (newLength > 0)
		{
#if qDebug
			if (dataType != kTextType_AC)
				::ProgramBreak_AC("TEPasteCommand given some non-text from clipboard");
			else
#endif

				{								// Prime "new" values
					fNewText = newText;
					fNewStart = (*fHTE)->selStart;
					fNewEnd = fNewStart + newLength;
					fTextPad = newLength - (fOldEnd - fOldStart);

					long newStyleLen = gClipboardMgr->GetClipView()->GivePasteData((Handle)newStyles, kStyleType_AC);

					if (newStyleLen > 0)
					{
						fNewStyles = newStyles;
						fStylePad =			// Difference between old and new styles
								   newStyleLen - fStylePad;
					}
					else
						newStyles = (StScrpHandle)::DisposeIfHandle_AC((Handle)newStyles);

					if (fPadding)
						SetPermHandleSize(fPadding, Max_AC(fTextPad + fStylePad, 0));

					FailSpaceIsLow();
				}
		}
		else
		{
			newText = ::DisposeIfHandle_AC(newText);
			newStyles = (StScrpHandle)::DisposeIfHandle_AC((Handle)newStyles);
		}

		if (fEditText)
			fEditText->TStaticText::SetText(fEditText->GetText(), kDontRedraw);
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		if (newText != fNewText)			// newText is assigned to fNewText
			newText = ::DisposeIfHandle_AC(newText);// �so avoid disposing twice.
		if (newStyles != fNewStyles)		// Ditto for newStyles.
			newStyles = (StScrpHandle)::DisposeIfHandle_AC((Handle)newStyles);
		throw;
	}
}

//----------------------------------------------------------------------------------------
// TTEPasteCommand destructor
//----------------------------------------------------------------------------------------

TTEPasteCommand::~TTEPasteCommand()
{
}

//========================================================================================
// CLASS TTEStyleCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TTEStyleCommand constructor
//----------------------------------------------------------------------------------------

TTEStyleCommand::TTEStyleCommand(TTEView*				itsTEView,
								 const CTextStyle_AC&	itsNewStyle,
								 CommandNumber			itsCommandNumber,
								 short					itsMode)
	:	TTECommand(itsTEView, itsCommandNumber, false),// Perform stock initialization, sans text
		fOldTextStyle(itsTEView ? itsTEView->fTextStyle : itsNewStyle),
		fNewTextStyle(itsNewStyle),
		fMode(itsMode)
{
}

//----------------------------------------------------------------------------------------
// TTEStyleCommand destructor
//----------------------------------------------------------------------------------------

TTEStyleCommand::~TTEStyleCommand()
{
}

//----------------------------------------------------------------------------------------
// TTEStyleCommand::InstallOneStyle:
//----------------------------------------------------------------------------------------

void TTEStyleCommand::InstallOneStyle(const CTextStyle_AC& newStyl)
{
	fTEView->SetOneStyle(fOldStart, fOldEnd, fMode, newStyl, kRedraw);// Focus'es for us
}

//----------------------------------------------------------------------------------------
// TTEStyleCommand::InstallManyStyles:
//----------------------------------------------------------------------------------------

void TTEStyleCommand::InstallManyStyles(StScrpHandle newStyls)
{
	fTEView->Focus();
	TEUseStyleScrap(fOldStart, fOldEnd, newStyls, kRedraw, fHTE);

	if (fOldEnd == fOldStart)
	{
		CTextStyle_AC theStyle(*(TextStyle*)&(*newStyls)->scrpStyleTab[0].scrpFont);

		TESetStyle(doAll, &theStyle, kRedraw, fHTE);
	}

	fTEView->RecalcText();						// Might have changed number of lines
	fTEView->SynchView(kRedraw);				// Show corrected view
}

//----------------------------------------------------------------------------------------
// TTEStyleCommand::DoIt:
//----------------------------------------------------------------------------------------

void TTEStyleCommand::DoIt()
{
	InstallOneStyle(fNewTextStyle);

#if qDebug
	if (TTEView::fgTEIntenseDebugging)
		DumpTTECommand(this);
#endif

}

//----------------------------------------------------------------------------------------
// TTEStyleCommand::UndoIt:
//----------------------------------------------------------------------------------------

void TTEStyleCommand::UndoIt()
{
	fTEView->Focus();

	RestoreSelection();

	InstallManyStyles(fOldStyles);
#if qDebug
	if (TTEView::fgTEIntenseDebugging)
		DumpTTECommand(this);
#endif

}

//----------------------------------------------------------------------------------------
// TTEStyleCommand::RedoIt:
//----------------------------------------------------------------------------------------

void TTEStyleCommand::RedoIt()
{
	fTEView->Focus();
	RestoreSelection();
	DoIt();
}

//========================================================================================
// CLASS TTETypingCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TTETypingCommand constructor
//----------------------------------------------------------------------------------------

TTETypingCommand::TTETypingCommand(TTEView* itsTEView, const CStr2_AC& itsFirstCh)
	:	TTECommand(itsTEView, cTyping, true),
		fCompleted(false)
{
	fNewStart = (*fHTE)->selStart;		// Start and end are the same
	fNewEnd = fNewStart;

	fNewText = NewPermHandle(0);		// Allocate an empty block for text

	AddCharacter(itsFirstCh);			// [1115111] moved here from DoIt

	// Send a text changed event through the TE view.
	fTEView->HandleEvent(fIdentifier, fTEView, this);
}

//----------------------------------------------------------------------------------------
// TTETypingCommand destructor
//----------------------------------------------------------------------------------------

TTETypingCommand::~TTETypingCommand()
{
	if (fTEView)
	{
		fTEView->ForgetIfTypingCommand(this);
	}
	if (fEditText)
	{
		TDialogTEView* teView = fEditText->fTEView;
		if (teView)
			teView->ForgetIfTypingCommand(this);
	}
}

//----------------------------------------------------------------------------------------
// TTETypingCommand::DoNormalChar:
//----------------------------------------------------------------------------------------

void TTETypingCommand::DoNormalChar(const CStr2_AC& ch)
{
	// Append char[s] to end of fNewText

	CTempAllocation tempAllocation(false);
	::ThrowIfOSErr_AC(PtrAndHand((Ptr) & ch[1], fNewText, ch.Length()));

	fNewEnd += ch.Length();						// Bump both end of "selection"
	fTextPad += ch.Length();					// �and padding value

	// This SetPermHandleSize can't grow the handle,
	if (fPadding)
		SetPermHandleSize(fPadding, Max_AC(-(fTextPad + fStylePad), 0));// �so it shouldn't fail.
}

//----------------------------------------------------------------------------------------

void TTETypingCommand::BkSpcLeft(Handle theText, short curStart)
// BkSpcLeft handles keystrokes that backspace to the left of the original
// selection.  First, copy the character (which may be more than one byte long
// if we are using a non-Roman script) to a temporary buffer. The assumption
// is that no character will ever be longer than two bytes. Next, copy the
// character to the front of fOldText, and adjust fOldStart, fNewStart, and
// fNewEnd. Note that we do !check for MemSpaceIsLow, since we want to let
// the user delete characters.
//
// theText:		Specifies a handle to the text being edited.
// curStart:	Specifies an integer specifying the starting location of the
// 				text insertion point.
//
// Call?		Seldom.
// Override?	Seldom.
{
	unsigned char saveLength = 1;
	if (MACharacterByteType((*theText), curStart - 1, smCurrentScript) == smLastByte)
		++saveLength;
	curStart -= saveLength;

	CStr2_AC savedCh(static_cast<void*>(*theText + curStart), saveLength);

	CTextStyle_AC delStyle;
	short theHeight;
	short theAscent;
	TEGetStyle(curStart, &delStyle,			// Get the style of the deleted character
			   &theHeight, &theAscent, fHTE);// (1 or 4 bytes, it's all only one style)

	if (!EqualBlocks(&delStyle,		// If style doesn't match first in the list
					 &(*fOldStyles)->scrpStyleTab[0].scrpFont, sizeof(delStyle)))
	{
		// �then insert new style at head of list

		long oldSize =						// Make room for the new style element
					  GetHandleSize((Handle)fOldStyles);
		SetPermHandleSize((Handle)fOldStyles, oldSize + sizeof(ScrpSTElement));
		fStylePad += sizeof(ScrpSTElement);

		{
			//ScrpSTElement & theScrpSTElement = (*fOldStyles)->scrpStyleTab[0];
			ScrpSTElement * theScrpSTElement = &(*fOldStyles)->scrpStyleTab[0];

			//	BlockMove_AC(&(theScrpSTElement.scrpStartChar),// Move entire array up one element's size
			//				(Ptr)&(theScrpSTElement.scrpStartChar) + sizeof(ScrpSTElement),
			//				oldSize - sizeof((*fOldStyles)->scrpNStyles));
   			BlockMove_AC(theScrpSTElement, (Ptr)theScrpSTElement + sizeof(ScrpSTElement), oldSize - sizeof((*fOldStyles)->scrpNStyles));
		}

		++(*fOldStyles)->scrpNStyles;		// One more style

		{
			ScrpSTElement & theScrpSTElement = (*fOldStyles)->scrpStyleTab[0];

			theScrpSTElement.scrpHeight = theHeight;// Fill in the blanks
			theScrpSTElement.scrpAscent = theAscent;
			BlockMove_AC(&delStyle, &theScrpSTElement.scrpFont, sizeof(TextStyle));
		}
	}

	--(*fOldStyles)->scrpStyleTab[0].scrpStartChar;// Regardless, back off offset by one

	if (fPadding)
		SetPermHandleSize(fPadding, GetHandleSize(fOldText) + savedCh.Length() + fStylePad);
	Munger(fOldText, 0, NULL, 0, &savedCh[1], savedCh.Length());
	::ThrowIfMemError_AC();
	fOldStart = curStart;						// Treat this as though original selection
	fNewStart = curStart;						// �had included this character
	fNewEnd = curStart;
	fTextPad -= savedCh.Length();
}

//----------------------------------------------------------------------------------------
// TTETypingCommand::BkSpcRight:
//----------------------------------------------------------------------------------------

void TTETypingCommand::BkSpcRight(Handle theText, short curStart)
// BkSpcRight handles keystrokes that backspace to the right of the original
// selection.
//
// theText:		Specifies a handle to the text being edited.
// curStart:	Specifies an integer specifying the starting location of the
// 				text insertion point.
//
// Call?		Seldom. BkSpcRight is called by TTETypingCommand::AddCharacter
//				when the user backspaces to the right of the original selection.
// Override?	Seldom.
{
	short savedSize = 1;
	if (MACharacterByteType((*theText), curStart - savedSize, smCurrentScript) == smLastByte)
		++savedSize;
	if (fPadding)
		SetPermHandleSize(fPadding, Max_AC(-(fTextPad - savedSize + fStylePad), 0));
	fNewEnd -= savedSize;
	fTextPad -= savedSize;

	SetPermHandleSize(fNewText, fNewEnd - fNewStart);// Shouldn't fail as we're only shrinking it
}

//----------------------------------------------------------------------------------------
// TTETypingCommand::FwdDelete: Forward delete courtesy of: Larry Goldman. Used by
// permission.
//----------------------------------------------------------------------------------------

void TTETypingCommand::FwdDelete(Handle theText, short curStart, short curEnd)
{
	short theHeight;
	short theAscent;
	long oldSize;
	CTextStyle_AC delStyle;
	long oldTextSize;

	CStr2_AC savedCh;

	long textSize = GetHandleSize(theText);
	if ((curStart == curEnd) && (curStart < textSize))
	{
		unsigned char saveLength = 0;			//Get the complete character
		if ((curStart + saveLength <= textSize) && (MACharacterByteType((*theText), curStart + saveLength, smCurrentScript) == smLastByte))
			++saveLength;
		++saveLength;

		savedCh.CopyFrom(static_cast<void*>(*theText + curStart), saveLength);

		if ((curStart >= fNewStart) && (curStart < fNewEnd))// char is within fNewText
		{
			// Remove the char from fNewText and update fNewEnd and fTextPad
			if (fPadding)
				SetPermHandleSize(fPadding, Max_AC(-(fTextPad - savedCh.Length() + fStylePad), 0));
			fNewEnd -= savedCh.Length();
			fTextPad -= savedCh.Length();

			// Shouldn't fail as we're only shrinking it
			Munger(fNewText, curStart - fNewStart, NULL, savedCh.Length(), &savedCh[1], 0);
			::ThrowIfMemError_AC();
		}
		else									// add char to the end of fOldChars, don't
			// update fOldEnd, but update fPadding
			{
				oldTextSize = GetHandleSize(fOldText);
				TEGetStyle(curStart, &delStyle,// Get the style of the deleted character
						   &theHeight, &theAscent, fHTE);// (1 or 4 bytes, it's all only one style)

				if (!EqualBlocks(&delStyle,// If style doesn't match last in the list
								 &(*fOldStyles)->scrpStyleTab[(*fOldStyles)->scrpNStyles - 1].scrpFont, sizeof(delStyle)))
				{
					// �then insert new style at end of list

					oldSize = GetHandleSize((Handle)fOldStyles);// Make room for the new style element
					SetPermHandleSize((Handle)fOldStyles, oldSize + sizeof(ScrpSTElement));
					fStylePad += sizeof(ScrpSTElement);

					++(*fOldStyles)->scrpNStyles;// One more style

					{
						ScrpSTElement & theScrpSTElement = (*fOldStyles)->scrpStyleTab[(*fOldStyles)->scrpNStyles - 1];

						theScrpSTElement.scrpStartChar = oldTextSize;
						theScrpSTElement.scrpHeight = theHeight;// Fill in the blanks
						theScrpSTElement.scrpAscent = theAscent;
						BlockMove_AC(&delStyle, &theScrpSTElement.scrpFont, sizeof(TextStyle));
					}
				}

				if (fPadding)
					SetPermHandleSize(fPadding, oldTextSize + savedCh.Length() + fStylePad);
				Munger(fOldText, oldTextSize, NULL, 0, &savedCh[1], savedCh.Length());
				::ThrowIfMemError_AC();
				fTextPad = fTextPad - savedCh.Length();
			}
	}
}

//----------------------------------------------------------------------------------------
// TTETypingCommand::AddCharacter:
//----------------------------------------------------------------------------------------

void TTETypingCommand::AddCharacter(const CStr2_AC& ch)
{
	// Make sure that we were actually passed a character to add.
	if (ch.Length() > 0)
	{
		Handle theText;
		short curSelStart;
		short curSelEnd;

		fTEView->Update();							// Makes sure that all of TE's actions are Visible
		fTEView->Focus();

		{
			TERec & theTERec = **fHTE;

			curSelStart = theTERec.selStart;
			curSelEnd = theTERec.selEnd;
			theText = theTERec.hText;
		}

		CWhileOutlinePreferred_AC setOP(fTEView->fPreferOutline);
		{
			CTempAllocation tempAllocation(false);

			// Update the fNewText handle and other information. Note that because of
			// backspace, this can be tricky.*/
			if (ch == chFwdDelete)					// User types forward delete, so keep in  synch
				FwdDelete(theText, curSelStart, curSelEnd);

			else if (ch != chBackspace)				// Not a backspace. Do the right thing
				DoNormalChar(ch);

			else if ((curSelStart <= fOldStart) && (curSelStart > 0) && (curSelStart == curSelEnd))// User typed backspace so keep in synch
				BkSpcLeft(theText, curSelStart);	// Handle backspace to left of start

			else if (fNewEnd > fNewStart)			// Delete 1 character from end of fNewText
				BkSpcRight(theText, curSelStart);	// Handle backspace to right of start
		}

		if (ch != chFwdDelete)
		{
			// Let TextEdit have the character, as either 1) we're adding a byte, so we know
			// there is a reserve tank, so the worst this will do is eat into it a little, or
			// 2) we're deleting a character, which can only decrease memory usage.

			// NOTE: here is where we insert multibyte characters all at once
#if qMSWindows
			#pragma message ("UTECommands.cpp: TEKey not available in Windows.  Workaround required!")
#else
			TEKey(ch[1], fHTE);
			if (ch.Length() > 1)
				TEKey(ch[2], fHTE);
#endif
		}
		else if (curSelStart != curSelEnd)			// forward delete with chars selected
			TEDelete(fHTE);
		else if (curSelStart < GetHandleSize(theText))
		{
			// forward delete with insertion point
#if !qMSWindows
			TEKey(chRight, fHTE);
			TEKey(chBackspace, fHTE);
#endif
		}

		fTEView->SynchView(kRedraw);				// Now clean up the view.

		// Send a text changed event through the TE view.
		fTEView->HandleEvent(fIdentifier, fTEView, this);

	#if qDebugMsg
		if (TTEView::fgTEIntenseDebugging)
		{
			WrLblHandleContents("fOldText", fOldText);
			ProgramReport_AC("\n");
			WrLblHandleContents("fNewText", fNewText);
			ProgramReport_AC("\n");
			DumpTTECommand(this);
		}
	#endif
	}
}

//----------------------------------------------------------------------------------------
// TTETypingCommand::DoIt:
//----------------------------------------------------------------------------------------

void TTETypingCommand::DoIt()
{
#if qDebug
	if (TTEView::fgTEIntenseDebugging)
		DumpTTECommand(this);
#endif
}

//----------------------------------------------------------------------------------------
// TTETypingCommand::RedoIt:
//----------------------------------------------------------------------------------------

void TTETypingCommand::RedoIt()
{
	AssureTEView();		// ���  Make sure fHTE is valid before referencing it!

	if ((fOldEnd - fOldStart) == GetHandleSize(fOldText))
	{	// No chars were vacuumed
		bool resetStyle = false;

		if (fOldEnd == fOldStart)
		{
			CTextStyle_AC currentStyle;
			short lineHeight;
			short fontAscent;
			TEGetStyle(fOldStart, &currentStyle, &lineHeight, &fontAscent, fHTE);
			resetStyle = !EqualBlocks(&currentStyle, &(*fOldStyles)->scrpStyleTab[0].scrpFont, sizeof(currentStyle));
		}

		if (resetStyle)							// The new text has a style of its own
			fNewStyles = fOldStyles;			// Make InstallNewText insert styles, too
		TTECommand::RedoIt();
		if (resetStyle)
			fNewStyles = NULL;					// So fNewStyles doesn't get disposed
	}
	else
	{
		fTEView->Focus();
		// select vacuumed chars, too
		fTEView->SetSelection(fOldStart, fOldStart + GetHandleSize(fOldText), kRedraw);
		TEDelete(fHTE);							// Remove old text, including vacuumed chars
		if (fPadding)
			SetPermHandleSize(fPadding, Max_AC(-(fTextPad + fStylePad), 0));
		InstallNewText();
		fTEView->SynchView(kRedraw);

		// Send a text changed event through the TE view.
		fTEView->HandleEvent(fIdentifier, fTEView, this);

#if qDebug
		if (TTEView::fgTEIntenseDebugging)
			DumpTTECommand(this);
#endif

	}
}

//----------------------------------------------------------------------------------------
// TTETypingCommand::UndoIt:
//----------------------------------------------------------------------------------------

void TTETypingCommand::UndoIt()
{
	CompleteTyping();
	TTECommand::UndoIt();
}

//----------------------------------------------------------------------------------------
// TTETypingCommand::CompleteTyping:
//----------------------------------------------------------------------------------------

void TTETypingCommand::CompleteTyping()
// CompleteTyping indicates that typing has been completed for this command
// and updates the style scrap, if any.
//
// Call?		Seldom. Call TTEView::DoneTyping instead.
// Override?	Seldom.
{
	fCompleted = true;

	StScrpRec & theStScrpRec = **fOldStyles;
	long offset = -theStScrpRec.scrpStyleTab[0].scrpStartChar;
	if (offset > 0)
		for (short i = 0; i <= theStScrpRec.scrpNStyles - 1; ++i)
			theStScrpRec.scrpStyleTab[i].scrpStartChar += offset;
#if qDebug
	if (TTEView::fgTEIntenseDebugging)
		DumpTTECommand(this);
#endif

}

#if qDrag

//========================================================================================
// CLASS TTEDragDropCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TTEDragDropCommand constructor
//----------------------------------------------------------------------------------------

TTEDragDropCommand::TTEDragDropCommand(TTEView* itsTEView, CommandNumber itsCommandNumber)
	:	TTECommand(itsTEView, itsCommandNumber, false)
{
}

//----------------------------------------------------------------------------------------
// TTEDragDropCommand constructor
//----------------------------------------------------------------------------------------

TTEDragDropCommand::TTEDragDropCommand(TEditText* itsEditText, CommandNumber itsCommandNumber)
	:	TTECommand(itsEditText, itsCommandNumber, false)
{
}

//----------------------------------------------------------------------------------------
// TTEDragDropCommand destructor
//----------------------------------------------------------------------------------------

TTEDragDropCommand::~TTEDragDropCommand()
{
}

//----------------------------------------------------------------------------------------
// TTEDragDropCommand::DoMainFunction:
//----------------------------------------------------------------------------------------

void TTEDragDropCommand::DoMainFunction()
{
	InstallNewText();
	fTEView->SynchView(kRedraw);
}

//----------------------------------------------------------------------------------------
// TTEDragDropCommand::SetNewText:
//----------------------------------------------------------------------------------------

void TTEDragDropCommand::SetNewText(Handle newText, StScrpHandle newStyles)
{
	fNewText = newText;
	fNewEnd = fNewStart + static_cast<short>(GetHandleSize(newText));// correct for text size
	fNewStyles = newStyles;
}

//----------------------------------------------------------------------------------------
// TTEDragDropCommand::SetNewStart:
//----------------------------------------------------------------------------------------

void TTEDragDropCommand::SetNewStart(short newStart)
{
	short textSize = fNewEnd - fNewStart;
	fNewStart = newStart;
	fNewEnd = fNewStart + textSize;
}

//----------------------------------------------------------------------------------------
// TTEDragDropCommand::InstallNewText:
//----------------------------------------------------------------------------------------

void TTEDragDropCommand::InstallNewText()
{
	CViewRect textEditArea(fTEView->GetExtent());
	fTEView->SetSelection(fNewStart, fNewStart, kRedraw);
	fTEView->Draw(textEditArea);
	TTECommand::InstallNewText();
	// fTEView->SetSelection(fNewStart, fNewEnd, kRedraw);
	fTEView->Draw(textEditArea);
}

//========================================================================================
// CLASS TTEDragMoveCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// TTEDragMoveCommand constructor
//----------------------------------------------------------------------------------------

TTEDragMoveCommand::TTEDragMoveCommand(TTEView*			itsTEView,
									   CommandNumber	itsCommandNumber,
									   short			newStart)
	:	TTECommand(itsTEView, itsCommandNumber, true)
{
	// initialize the command, and save the selection into fOldText

	// fOldStart and fOldEnd represent the text being dragged
	// fNewStart takes its impending relocation into account
	fNewStart = (fOldStart < newStart) ? (newStart - (fOldEnd - fOldStart)) : newStart;
	fNewEnd = fNewStart + (fOldEnd - fOldStart);

	// since new and old text are the same, the text handle can be shared
	fNewText = fOldText;
	fNewStyles = fOldStyles;
}

//----------------------------------------------------------------------------------------
// TTEDragMoveCommand constructor
//----------------------------------------------------------------------------------------

TTEDragMoveCommand::TTEDragMoveCommand(TEditText*		itsEditText,
									   CommandNumber	itsCommandNumber,
									   short			newStart)
	:	TTECommand(itsEditText, itsCommandNumber, true)
{
	// initialize the command, and save the selection into fOldText

	// fOldStart and fOldEnd represent the text being dragged
	// fNewStart takes its impending relocation into account
	fNewStart = (fOldStart < newStart) ? (newStart - (fOldEnd - fOldStart)) : newStart;
	fNewEnd = fNewStart + (fOldEnd - fOldStart);

	// since new and old text are the same, the text handle can be shared
	fNewText = fOldText;
	fNewStyles = fOldStyles;
}

//----------------------------------------------------------------------------------------
// TTEDragMoveCommand destructor
//----------------------------------------------------------------------------------------

TTEDragMoveCommand::~TTEDragMoveCommand()
{
	// fNewText and fOldText share a handle in this command. fNewText is NULLed to
	// prevent double disposal in the base destructor.
	fNewText = NULL;
	fNewStyles = NULL;
}

//----------------------------------------------------------------------------------------
// TTEDragMoveCommand::InstallNewText:
//----------------------------------------------------------------------------------------

void TTEDragMoveCommand::InstallNewText()
{
	// set the text insertion point
	fTEView->SetSelection(fNewStart, fNewStart, kRedraw);

	TTECommand::InstallNewText();

	fTEView->SetSelection(fNewStart, fNewEnd, kRedraw);
}

//========================================================================================
// CLASS TTEDragTracker
//========================================================================================

//----------------------------------------------------------------------------------------
// TTEDragTracker constructor
//----------------------------------------------------------------------------------------

TTEDragTracker::TTEDragTracker(CommandNumber			itsCommandNumber,
							   TTEView*					itsTEView,
							   TEditText*				itsEditText,
							   const CViewPoint&		itsMouse,
							   const TToolboxEvent*		event)
	:	TDragTracker(itsCommandNumber, itsTEView, itsMouse, event),
		fTEView(itsTEView),
		fEditText(itsEditText),
		fHTE(itsTEView->fHTE),
		fHiliteRgn(NULL),
		fLastCaretTime(0L),
		fLastCaretOffset(0),
		fCaretIsShown(false)
{
}

//----------------------------------------------------------------------------------------
// TTEDragTracker destructor
//----------------------------------------------------------------------------------------

TTEDragTracker::~TTEDragTracker()
{
}

//----------------------------------------------------------------------------------------
// TTEDragTracker::DoDragEnter:
//----------------------------------------------------------------------------------------

void TTEDragTracker::DoDragEnter()
{
	fLastCaretOffset = 0;
	fLastCaretTime = 0L;
	fCaretIsShown = false;

	if (TDragDropSession::fgDragDropSession->GetCurrentDragSource() == fTEView)
	{
		fHiliteRgn = MakeNewRgn();
		CWhileOutlinePreferred_AC setOP(fTEView->fPreferOutline);
		::TEGetHiliteRgn(fHiliteRgn, fHTE);
		::ThrowIfNULL_AC(fHiliteRgn);
	}
}

//----------------------------------------------------------------------------------------
// TTEDragTracker::DoDragWithin:
//----------------------------------------------------------------------------------------

void TTEDragTracker::DoDragWithin(const CViewPoint& localMouse)
{
	unsigned long currentTime = TickCount();
	short offset = -1;
	bool caretMoved = true;

	fTEView->Focus();

	// if this view is the source and the target of the drag, don't allow dropping
	// into the selection
	if (fHiliteRgn && PtInRgn(fTEView->ViewToQD(localMouse), fHiliteRgn))
	{
		if (fLastCaretOffset != -1)
		{
			offset = -1;
			caretMoved = true;					// force redraw
		}
	}
	else
	{
		offset = fTEView->PtToOffset(localMouse);
		caretMoved = (fLastCaretOffset != offset);
	}

	if (caretMoved && fCaretIsShown)
		DrawCaret(fLastCaretOffset);

	if (caretMoved || (currentTime - fLastCaretTime) > GetCaretTime())
	{
		if (offset != -1)
			DrawCaret(offset);
		fLastCaretOffset = offset;
		fLastCaretTime = currentTime;
	}
}

//----------------------------------------------------------------------------------------
// TTEDragTracker::DoDragLeave:
//----------------------------------------------------------------------------------------

void TTEDragTracker::DoDragLeave()
{
	if (fCaretIsShown)
		DrawCaret(fLastCaretOffset);

	if (fHiliteRgn)
		fHiliteRgn = DisposeIfRgnHandle(fHiliteRgn);
}

//----------------------------------------------------------------------------------------
// TTEDragTracker::DoMakeDragDropCommand:
//----------------------------------------------------------------------------------------

TCommand* TTEDragTracker::DoMakeDragDropCommand(CommandNumber		itsCommandNumber,
												CDragItemIterator&	dragItemIterator,
												TDragTracker*		targetTracker)
{
	TCommand* returnCommand = NULL;

	switch (itsCommandNumber)
	{
		case cDrag:
			if (fEditText)
				returnCommand = TH_new TTECommand(fEditText, itsCommandNumber, true);
			else
				returnCommand = TH_new TTECommand(fTEView, itsCommandNumber, true);
			break;

		case cDrop:
			{
				Handle textHandle = NULL;

				TDragItem* firstItem = dragItemIterator.First();
				firstItem->FocusOnFlavor(kTextType_AC);
				textHandle = firstItem->GetDataAsHandle();
				::ThrowIfNULL_AC(textHandle);

				TTEDragDropCommand* dropCommand;
				if (fEditText)
				{
					dropCommand = TH_new TTEDragDropCommand(fEditText, itsCommandNumber);
					dropCommand->SetNewText(textHandle, NULL);
					dropCommand->SetNewStart(fLastCaretOffset);
				}
				else
				{
					StScrpHandle textStyles = NULL;
					if (firstItem->FlavorExists(kStyleType_AC))
					{
						firstItem->FocusOnFlavor(kStyleType_AC);
						textStyles = (StScrpHandle)firstItem->GetDataAsHandle();
					}

					dropCommand = TH_new TTEDragDropCommand(fTEView, itsCommandNumber);
					dropCommand->SetNewText(textHandle, textStyles);
					dropCommand->SetNewStart(fLastCaretOffset);
				}
				returnCommand = dropCommand;
			}
			break;

		case cDragMove:
			{
				TTEDragTracker*	targTracker = dynamic_cast_AC(TTEDragTracker*, targetTracker);
				if (targTracker)
				{
					short lastCaretOffset = targTracker->fLastCaretOffset;
					if (lastCaretOffset != -1)		// can't drop into selection
					{
						if (fEditText)
							returnCommand = TH_new TTEDragMoveCommand(fEditText, itsCommandNumber, lastCaretOffset);
						else
							returnCommand = TH_new TTEDragMoveCommand(fTEView, itsCommandNumber, lastCaretOffset);
					}
				}
			}
			break;

		default:
			// Don't need to call Inherited because it just returns NULL
			//returnCommand = Inherited::DoMakeDragDropCommand(itsCommandNumber, dragItemIterator);
			break;
	}

	return returnCommand;
}

//----------------------------------------------------------------------------------------
// TTEDragTracker::DoFulfillPromise
//----------------------------------------------------------------------------------------

void TTEDragTracker::DoFulfillPromise(TDragItem* promisedItem)
{
	switch (promisedItem->GetFlavorType())
	{
		case kTextType_AC:
			{
				CTempHandleLock_AC tempHandleLock(fTEView->fText);

				try
				{
					long byteCount = (*fHTE)->selEnd - (*fHTE)->selStart;
					char* textPtr = *fTEView->fText + (*fHTE)->selStart;
					promisedItem->SetData(textPtr, byteCount);
				}
				catch(CException_AC& theException)
				{
					DoCatchMessage_AC(theException);
					theException.SetError(cantGetFlavorErr);
					throw;
				}

			}
			break;

		case kStyleType_AC:
			{
				CTempHandle_AC tempHandle;

				try
				{
					tempHandle = (Handle)::TEGetStyleScrapHandle(fHTE);
					::ThrowIfNULL_AC(tempHandle);

					promisedItem->SetDataFromHandle(tempHandle);
				}
				catch(CException_AC& theException)
				{
					DoCatchMessage_AC(theException);
					theException.SetError(cantGetFlavorErr);
					throw;
				}

			}
			break;

		default:
			TDragTracker::DoFulfillPromise(promisedItem);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TTEDragTracker::DrawCaret:
//----------------------------------------------------------------------------------------

void TTEDragTracker::DrawCaret(short offset)
{
	fTEView->Focus();	// Make sure the coordinates are set up.

	//	Get the coordinates and the line of the offset to draw the caret.
	CPoint_AC theLoc(::TEGetPoint(offset, fHTE));
	short theLine = fTEView->TEGetLine(offset, fHTE);

	long lineHeight = ::TEGetHeight(theLine, theLine, fHTE);

	//	For some reason, TextEdit doesn't return the proper coordinates
	//	of the last offset in the field if the last character in the record
	//	is a carriage return. TEGetPoint returns a point that is one line
	//	higher than expected. The following code fixes this problem.

	if ((offset == (*fHTE)->teLength) && (*((*fHTE)->hText))[(*fHTE)->teLength - 1] == 0x0D)
		theLoc.v += static_cast<short>(lineHeight);

	PenNormal();
	// The caret supposed to be nice and dark (which the white pattern will accomplish)
	CPattern_AC::SetPenPatToWhite();
	::PenMode(notPatXor);						//	set invert mode

	::MoveToPt(--theLoc);						//	Draw the caret image
	Line(0, 1 - lineHeight);

	PenNormal();								// reset the pen

	fCaretIsShown = !fCaretIsShown;
}

#endif // qDrag

//----------------------------------------------------------------------------------------
// End of UTECommands.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/21/96	[1117870] (2-BYTE) TTEView and Left&Right Arrow
							[1115111] (2-BYTE) TTEView::GetNumberOfChars returns 0 after 1 character has been typed
							[1353017] (Double-byte) Second Character Lost
		06/14/96	Filter pastes and drops for invalid characters.
		05/10/96	Call the fTEView to reselect text in TTECommand::RestoreSelection. This will ensure
							the view is properly focused before drawing.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/08/96	Cleanup CRGBColor_AC and add new class CTextStyle_AC
		05/07/96	Use enums for parameters of CTempHandleLock_AC constructor.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		05/02/95	Call FreeIfObject, don't call Free directly since it will eventually be removed.
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/15/96	account for MDependable_AC moving from TObject
		04/15/96	Phase 1 of View Breakup changes
		----- R10 -----
		04/03/96	GestaltEqu.h renamed to Gestalt.h.
		03/23/96	Removed '', changed all occurrances of (**foo). to (*foo)->
							Ran thru C++ formatter. Changed pCurrTEView to fgCurrTEView
							Changed pClickLoopProc to fgClickLoopProc. Changed
							gDefClickLoopProc to fgDefClickLoopProc. Changed
							pTEIntenseDebugging to fgTEIntenseDebugging
		03/23/96	TTETypingCommand::DoNormalChar now takes a CStr2_AC and handles
							multibyte character insertion.
		03/22/96	Added MACharacterByteType to UMacAppUtilities
		03/18/96	Made better use of TView calls that return CRect_AC/CViewPoint/CViewRect
		03/06/96	Removed bogus bitflip of fMode from TEStyleCommand::DoIt
		03/01/96	Grouped some globals and global functions as static members.
		12/20/95	Use GetEditText so a TECommand always knows if its TEView has
							an EditText, even if it was created by the TEView.
							Add PrepareForUndoRedo and RevealUndoRedo
		 12/8/95	Don't need to include UApplication.
		----- 3.3 -----
		10/31/95	TTECutCopyCommand sets fCausesChange and fCanUndo to true
							if this is not a copy operation otherwise false.  1297870
		10/20/95	TEDragMoveCommand sets new text style.
		----- 3.3b1 -----
		08/22/95	Use TCommand::SetValidationError.
		08/22/95	TextEdit commands never change the current target.
		 					Force validation of non-target TEditTexts at command end.
							Save and restore TStaticText contents AND TTEView contents.
		07/31/95	ClickThrough: Text views are targeted before accepting new text.
		07/28/95	Add configuration functions to use instead of gConfiguration.
		07/03/95	Add TTECommand::ForgetTEView. Don't force TEditText
		  					validation until command is completed. Set TEditText
		  					text after command completion.
		04/08/95	Use size limits from limits.h instead of MacAppTypes.
		04/06/95	Remove gAcquiredTEView. It was a test-code relic.
		03/29/95	Fix BkSpcLeft call to BlockMove_AC (make room for the new style
		 					element) to compile with PPCC.
		03/17/95	MAVolatile.
		03/13/95	1184026 (GER.XSE0039) More on 1178386 & TTEStyleCommand::RestoreSelection()
		03/13/95	Change Free methods to destructors.
		03/10/95	TTECommands work with TEditText.
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		02/22/95	Add TTEDragMoveCommand.
		02/21/95	TTECommand::UndoIt tests fOldText before calling
		 					ReviveDeletions.
		 					TTECommand::RemoveAdditions doesn't set the size of
		 					fPadding if its nil.
		----- 3.5d3 Release -----
		12/15/94	Add TTEDragDropCommand::NeedsToUnloadAllSegments
							to prevent catastrophic unloading of all segments
							while receiving dropped text.
		11/12/94	Cast text size to short in SetNewText to get rid
							of compiler warning.
		11/11/94	Conditionally compile drag and drop support out
							when qDrag is false.
		11/10/94	Add textStyles parameter to
							TTECommand::SetNewText to support stylized text.
		11/00/94	Add TTEDragDropCommand.
*/