//----------------------------------------------------------------------------------------
// UCluster.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/24/01	Change cluster label to be a CString_AC, not a StringHandle.  It
					is now fLabel, not fDataHandle so a variety of fDataHandles have
					been removed and ctors, dtor, GetLabel, SetLabel, IsDrawingBorder
					and SetLabelWithStrListID have been modified.  Eliminated ReleaseLabel.
		01/20/01	GetLabel and SetLabel now use CString_AC.  Include CPascalString_AC.h.
		01/02/01	Update copyright.
		11/27/00	Use nil instead of NULL in call to TextBox_AC in DrawCluster.
		09/22/00	Improved graphics device iterator. 
		09/11/00	GetClipRegion method should only be used on the view's port. 
					In Carbon, need to set the updated clip. 
		09/05/00	Added validity test in DrawFrame.
		09/01/00	Stripped dead code.  Eliminated Inherited.  Cosmetic.
		06/21/00	Remove unnecessary GetRegion calls.
		03/24/00	Construct savedClip instead of assigning in two DrawFrames.
		03/20/00	Fixed TCluster copy-ctor so that it does not create two cluster behaviors.
		02/24/00	[W] Include UWindow.h.  Change GetClipRegion usage in ClipOutGap.
		12/21/99	Use kThemeStateInactive instead of kThemeStateDisabled (kThemeStateDisabled
					is obsolete). 
		09/28/99	Carbon:TCluster::ClipOutGap changed out reference to qd.port.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		07/26/99	Increase titleGap from 5 to 7 in DrawCluster.  Change drawing to clip
					out the title gap in both DrawFrames.  Added ClipOutGap.  Removed
					EraseFrameGap.
		03/24/99	Update copyright notice.
		11/05/98	Moved InitUCluster to bottom of file to get rid of Mach-0 Linker errors
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.
*/

#ifndef __UCLUSTER__
#include "UCluster.h"
#endif

// ACS

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __TextBox_AC__
#include "TextBox_AC.h"
#endif

// MacApp

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __USUBSTITUTION__
#include "USubstitution.h"
#endif

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef	__UWINDOW__
#include "UWindow.h"
#endif

//========================================================================================
// CLASS TClusterBehavior
//========================================================================================

MA_DEFINE_CLASS(TClusterBehavior);

//----------------------------------------------------------------------------------------
// TClusterBehavior constructor
//----------------------------------------------------------------------------------------

TClusterBehavior::TClusterBehavior(IDType itsIdentifier)
	:	TBehavior(itsIdentifier),
		fCurrentChoice(kNoIdentifier)
{
}
	
//----------------------------------------------------------------------------------------
// TClusterBehavior destructor
//----------------------------------------------------------------------------------------

TClusterBehavior::~TClusterBehavior()
{
}

//----------------------------------------------------------------------------------------
// TClusterBehavior::DoEvent:
//----------------------------------------------------------------------------------------

void TClusterBehavior::DoEvent(EventNumber eventNumber,
								TEventHandler* source,
								TEvent* event)
// Responsible for resetting the radio buttons so that the last selected one is
// the only one selected.
{
	// If we got this far, a radio's changed state. Only worry about it if it's our subview!
	TView* ownerAsView = dynamic_cast_AC(TView*,fOwner);
	
	if (eventNumber == mRadioHit)
	{	
		TView* sourceView = dynamic_cast_AC(TView*,source);
	
		if (ownerAsView && sourceView && (sourceView->GetSuperView() == ownerAsView))
		{
			for (CSubViewIterator iter(ownerAsView); iter; ++iter)
			{
				// If the subview is a TRadio, and it's not the calling radio… 
				if (iter.Current() != source)
					iter->HandleEvent(mTurnOff, ownerAsView, NULL);	// …set it off and redraw it 
			}
			
			fCurrentChoice = source->GetIdentifier();
		}
	}
	
	TBehavior::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// TClusterBehavior::GetCurrentChoice: 
//----------------------------------------------------------------------------------------

IDType TClusterBehavior::GetCurrentChoice()
{
	return fCurrentChoice;
}

//----------------------------------------------------------------------------------------
// TClusterBehavior::SetCurrentChoice: 
//----------------------------------------------------------------------------------------

void TClusterBehavior::SetCurrentChoice(IDType newChoice)
{
	TView* ownerAsView = dynamic_cast_or_throw_AC(TView*,fOwner);
	
	for (CSubViewIterator iter(ownerAsView); iter; ++iter)
		iter->DoEvent(iter->GetIdentifier() == newChoice ? mTurnOn : mTurnOff, ownerAsView, NULL);	 

	fCurrentChoice = newChoice;
}

//----------------------------------------------------------------------------------------
// TClusterBehavior::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TClusterBehavior::GetStandardSignature() const
{
	return kStdClusterBehavior;
}

//========================================================================================
// CLASS TCluster
//========================================================================================

MA_DEFINE_CLASS(TCluster);

//----------------------------------------------------------------------------------------
// TCluster constructor
//----------------------------------------------------------------------------------------

TCluster::TCluster(const CViewPoint&	itsLocation,
				   const CViewPoint&		itsSize,
				   SizeDeterminer		itsHSizeDet,
				   SizeDeterminer		itsVSizeDet,
				   ResNumber			itsRsrcID,
				   short itsIndex)
	:	TControl(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
		fStrListID(itsRsrcID),
		fIndex(itsIndex),
		fTitleGap(0),
		fWasActive(false)
{
	fEventNumber = mClusterHit;

	if (fStrListID != kNoResource)
	{
		CString_AC aString(fStrListID, fIndex);
		::ThrowIfResError_AC();

		SetLabel(aString, kDontRedraw);
	}

	// Create the cluster behavior by signature.

	// fClusterBehavior = TH_new TClusterBehavior(kStdClusterBehavior);
	MStreamable_AC* object = ::NewStdObject_AC(kStdClusterBehavior);
	fClusterBehavior = dynamic_cast_or_throw_AC(TClusterBehavior*, object);
	AddBehavior(fClusterBehavior);	// •••  (virtual call)
}

//----------------------------------------------------------------------------------------
// TCluster copy constructor
//----------------------------------------------------------------------------------------

TCluster::TCluster(const TCluster& inCluster)
	:	TControl(inCluster),
		fLabel(inCluster.fLabel),
		fClusterBehavior(),		// The TEventHandler copy-ctor will make a copy of the cluster behavior.
		fStrListID(inCluster.fStrListID),
		fIndex(inCluster.fIndex),
		fTitleGap(inCluster.fTitleGap),
		fWasActive(false)
{
	// Look for the cluster behavior created by the TEventHandler copy constructor.
	TBehavior* aBehavior = GetBehaviorWithIdentifier(kStdClusterBehavior);
	fClusterBehavior = dynamic_cast_or_throw_AC(TClusterBehavior*, aBehavior);
}

//----------------------------------------------------------------------------------------
// TCluster::Free: 
//----------------------------------------------------------------------------------------

TCluster::~TCluster()
{
}

//----------------------------------------------------------------------------------------
// TCluster::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TCluster::GetStandardSignature() const
{
	return kStdCluster;
}

//----------------------------------------------------------------------------------------
// TCluster::ReadFields: 
//----------------------------------------------------------------------------------------

void TCluster::ReadFields(CStream_AC* aStream)
{
	TControl::ReadFields(aStream);

	*aStream >> fStrListID
			 >> fIndex;
	
	// retrieve the buttons's label from the resource
	SetLabel(CString_AC(fStrListID, fIndex), kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TCluster::WriteFields: 
//----------------------------------------------------------------------------------------

void TCluster::WriteFields(CStream_AC* aStream) const
{
	TControl::WriteFields(aStream);

	*aStream << fStrListID
			 << fIndex;
}

//----------------------------------------------------------------------------------------
// TCluster::Draw: 
//----------------------------------------------------------------------------------------

void TCluster::Draw(const CViewRect& area)
{
	#pragma unused (area)

	// Draw the cluster in the appropriate state.
	DrawCluster();
}

//----------------------------------------------------------------------------------------
// TCluster::IsDrawingBorder: 
//----------------------------------------------------------------------------------------

bool TCluster::IsDrawingBorder() const
{
	return !fLabel.empty();
}

//----------------------------------------------------------------------------------------
// TCluster::ClipOutGap
//----------------------------------------------------------------------------------------

CRegion_AC TCluster::ClipOutGap(const CRect_AC& frameRect, SInt16 gapSize, SInt16 gapInset)
{
	CTempRegion_AC savedClip;
	::GetClip(savedClip);

	RgnHandle clipRgn = GetClipRegion();

	SInt16 gapLeft = frameRect.left + gapInset;
	CTempRegion_AC frameGap(gapLeft, frameRect.top, gapLeft + gapSize, frameRect.top + 4);

	::DiffRgn(clipRgn, frameGap, clipRgn);
#if qCarbon
	::SetClip(clipRgn);
#endif

	return savedClip.release();
}

//----------------------------------------------------------------------------------------
// TCluster::DrawCluster: 
//----------------------------------------------------------------------------------------

void TCluster::DrawCluster()
{
	CRect_AC boundsRect(ControlQDArea());
	ThemeDrawState state = IsActive() ? kThemeStateActive : kThemeStateInactive;
	
	if (IsDrawingBorder())
	{
		SInt16		titleGap = 0;
		SInt16		topIndent = 0;
		FontInfo	fontInfo;

		// retrieve the label and set it
		CString_AC theText(GetLabel());
		MAReplaceText(theText);
		if (!theText.empty())
		{
			fTextStyle.SetPortTextStyle();	// calculate gap for title's text style
			::GetFontInfo(&fontInfo);
			
			topIndent = fontInfo.ascent;	// text baseline should be at frame top

			titleGap = 7 + ::StringWidth(CStr255_AC(theText));
		}
		else
			titleGap = fTitleGap;

		DrawFrame(boundsRect, state, topIndent, titleGap);

		if (!theText.empty())
		{
			CRect_AC	titleRect;
			
			titleRect.left = boundsRect.left + 4 + GetGapLeftInset(boundsRect, titleGap);
			titleRect.top = boundsRect.top + 2;
			titleRect.right = titleRect.left + titleGap - 5;
			titleRect.bottom = titleRect.top + fontInfo.ascent + fontInfo.descent;

			for (CGDIterator_AC iter; iter; ++iter)
			{
				AGASetThemeTextColor(IsActive() ? kThemeActiveDialogTextColor :
												  kThemeInactiveDialogTextColor,
									 iter->Depth(), iter->IsColor());
				CStr255_AC		clusterTitle(theText);
				TextBox_AC((Ptr) &clusterTitle[1],
							clusterTitle.Length(),
							titleRect,
							teFlushDefault,
							kNoAutoWrap,				// no auto wrap
							nil,						// no wordBreak function
							kNoEraseFirst,				// no erase first
							kNoSpaceForCaret,			// no space for caret
							kDontPreferOutlineFonts);	// no outline fonts
				//AGAStringOut(theText, titleRect, kNoTruncation, teFlushDefault, (state == kThemeStateActive) ? kNormalOutput : kDisabledOutput, iter->IsDeep(), fTextStyle);
			}
		}
	}
}

//----------------------------------------------------------------------------------------
// TCluster::DrawFrame: 
//----------------------------------------------------------------------------------------

void TCluster::DrawFrame(const CRect_AC& boundsRect, ThemeDrawState state, SInt16 topIndent, SInt16 gapSize)
{
	// Draw the group box as a primary group box.
	CRect_AC clusterFrame(boundsRect);
	
	clusterFrame.top += topIndent;

	// Make sure the frame can reasonably be drawn.
	if (clusterFrame.IsValid())
	{
		CTempRegion_AC savedClip(ClipOutGap(clusterFrame, gapSize,
											GetGapLeftInset(clusterFrame, gapSize)));
		AGADrawThemePrimaryGroup(clusterFrame, state);
		::SetClip(savedClip.release());
	}
#if qDebug
	else
		ProgramReport_AC("TCluster::DrawFrame: Frame is invalid.");
#endif
}
		
//----------------------------------------------------------------------------------------
// TCluster::GetGapLeftInset
//----------------------------------------------------------------------------------------

SInt16 TCluster::GetGapLeftInset(const CRect_AC& boundsRect, SInt16 gapSize)
{
	// Return the number of pixels from the left edge of the group box
	// to the start of the gap. This depends on the title justification,
	// because the gap is not necessarily a fixed number of pixels from
	// the left.
	
	SInt16	inset;
	
	switch (CTextStyle_AC::RuntimeJustify(teFlushDefault))
	{
		case teCenter:
			inset = (boundsRect.right - boundsRect.left - gapSize - 12) / 2;
			break;
		case teFlushRight:
			inset = boundsRect.right - boundsRect.left - gapSize - 12;
			break;
		default: //case teFlushLeft:
			inset = 10;
			break;
	}
	
	return inset;
}

//----------------------------------------------------------------------------------------
// TCluster::GetLabel: 
//----------------------------------------------------------------------------------------

CString_AC TCluster::GetLabel() const
{
	return fLabel;
}

//----------------------------------------------------------------------------------------
// TCluster::SetLabel: 
//----------------------------------------------------------------------------------------

void TCluster::SetLabel(const CString_AC& theLabel, bool redraw)

{
	fLabel = theLabel;
	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TCluster::SetLabelWithStrListID: 
//----------------------------------------------------------------------------------------

void TCluster::SetLabelWithStrListID(ResNumber theStrListID, short theIndex, bool redraw)
{
	fStrListID = theStrListID;
	fIndex = theIndex;
	if (fStrListID != kNoResource)
	{
		CString_AC aString(fStrListID, fIndex);
		::ThrowIfResError_AC();
		SetLabel(aString, kDontRedraw);
	}

	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TCluster::GetCurrentChoice: 
//----------------------------------------------------------------------------------------

IDType TCluster::GetCurrentChoice()
{
	return fClusterBehavior->GetCurrentChoice();
}

//----------------------------------------------------------------------------------------
// TCluster::SetCurrentChoice: 
//----------------------------------------------------------------------------------------

void TCluster::SetCurrentChoice(IDType newChoice)
{
	fClusterBehavior->SetCurrentChoice(newChoice);
}

//----------------------------------------------------------------------------------------
// TCluster::Activate:
//----------------------------------------------------------------------------------------

void TCluster::Activate(bool entering)
{
	if (fWasActive != entering && Focus() && IsVisible())
	{
		fWasActive = entering;

//		if (!HasPendingUpdate())
//			DrawContents();
//		else
		ForceRedraw(); //DrawCluster(); // Draws the label and edges of cluster in the appropriate state.		
	}
	
	// don't let inherited add a dim adorner.
}

//----------------------------------------------------------------------------------------
// TCluster::DoMouseCommand: 
//----------------------------------------------------------------------------------------

void TCluster::DoMouseCommand(CViewPoint&		theMouse,
							  TToolboxEvent*	event,
							  CPoint_AC			hysteresis)
{
	#pragma unused (theMouse, event, hysteresis)

	// Group box drawing can be based on enable state, but we don't
	// want clicking on the group box itself to cause highlighting.
}

//========================================================================================
// CLASS TPrimaryCluster
//========================================================================================

MA_DEFINE_CLASS(TPrimaryCluster);

//----------------------------------------------------------------------------------------
// TPrimaryCluster constructor
//----------------------------------------------------------------------------------------

TPrimaryCluster::TPrimaryCluster(const CViewPoint& itsLocation,
								const CViewPoint& itsSize, 
								SizeDeterminer itsHSizeDet,
								SizeDeterminer itsVSizeDet, 
								ResNumber itsRsrcID,
								short itsIndex,
								IDType titleViewID)
	:	TCluster(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsRsrcID, itsIndex),
		fTitleViewID(titleViewID)
{
}

//----------------------------------------------------------------------------------------
// TPrimaryCluster destructor
//----------------------------------------------------------------------------------------

TPrimaryCluster::~TPrimaryCluster()
{
}

//----------------------------------------------------------------------------------------
// TPrimaryCluster::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TPrimaryCluster::GetStandardSignature() const
{
	return kStdPrimaryCluster;
}

//----------------------------------------------------------------------------------------
// TPrimaryCluster::IsDrawingBorder: 
//----------------------------------------------------------------------------------------

bool TPrimaryCluster::IsDrawingBorder() const
{
	return true;
}

//----------------------------------------------------------------------------------------
// TPrimaryCluster::ReadFields: 
//----------------------------------------------------------------------------------------

void TPrimaryCluster::ReadFields(CStream_AC* aStream)
{
	TCluster::ReadFields(aStream);

	*aStream >> fTitleViewID;
}

//----------------------------------------------------------------------------------------
// TPrimaryCluster::WriteFields: 
//----------------------------------------------------------------------------------------

void TPrimaryCluster::WriteFields(CStream_AC* aStream) const
{
	TCluster::WriteFields(aStream);

	*aStream << fTitleViewID;
}

//----------------------------------------------------------------------------------------
// TPrimaryCluster::DoPostCreate: 
//----------------------------------------------------------------------------------------
	
void TPrimaryCluster::DoPostCreate(TDocument* itsDocument)
{
	TCluster::DoPostCreate(itsDocument);

	SetViewTitleGap(fTitleViewID);
}

//----------------------------------------------------------------------------------------
// TPrimaryCluster::SetViewTitleGap
//----------------------------------------------------------------------------------------

void TPrimaryCluster::SetViewTitleGap(IDType titleViewID)
{
	fTitleViewID = titleViewID;
	if ((fTitleViewID != kNoIdentifier) && (fSuperView != NULL))
	{
		TView* gapView = fSuperView->FindSubView(fTitleViewID);

		if (gapView != NULL)
			fTitleGap = 5 + gapView->GetQDExtent().GetLength(hSel);
	}
}

//========================================================================================
// CLASS TSecondaryCluster
//========================================================================================

MA_DEFINE_CLASS(TSecondaryCluster);

//----------------------------------------------------------------------------------------
// TSecondaryCluster constructor
//----------------------------------------------------------------------------------------

TSecondaryCluster::TSecondaryCluster(const CViewPoint& itsLocation,
									 const CViewPoint& itsSize,
									 SizeDeterminer itsHSizeDet,
									 SizeDeterminer itsVSizeDet,
									 ResNumber itsRsrcID,
									 short itsIndex,
									 IDType titleViewID)
	:	TPrimaryCluster(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsRsrcID, itsIndex, titleViewID)
{
}

//----------------------------------------------------------------------------------------
// TSecondaryCluster destructor
//----------------------------------------------------------------------------------------

TSecondaryCluster::~TSecondaryCluster()
{
}

//----------------------------------------------------------------------------------------
// TSecondaryCluster::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TSecondaryCluster::GetStandardSignature() const
{
	return kStdSecondaryCluster;
}

//----------------------------------------------------------------------------------------
// TSecondaryCluster::DrawFrame: 
//----------------------------------------------------------------------------------------

void TSecondaryCluster::DrawFrame(const CRect_AC& boundsRect, ThemeDrawState state, SInt16 topIndent, SInt16 gapSize)
{
	CRect_AC r(boundsRect);
	
	r.top += topIndent;

	CTempRegion_AC savedClip(ClipOutGap(r, gapSize, GetGapLeftInset(r, gapSize)));
	AGADrawThemeSecondaryGroup(r, state);
	::SetClip(savedClip.release());
}

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUCluster
//----------------------------------------------------------------------------------------

void InitUCluster(bool initPrimaryCluster, bool initSecondaryCluster)
{
	static bool UClusterInitialized;

	if (!UClusterInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TCluster, kStdCluster);
			REGISTER_SIGNATURE_AC(TClusterBehavior, kStdClusterBehavior);

			if (initPrimaryCluster)
			{
				REGISTER_SIGNATURE_AC(TPrimaryCluster, kStdPrimaryCluster);
			}
			if (initSecondaryCluster)
			{
				REGISTER_SIGNATURE_AC(TSecondaryCluster, kStdSecondaryCluster);
			}
		}
		UClusterInitialized = true;
	}
}

//----------------------------------------------------------------------------------------
// End of UCluster.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added #include "UStream.h", "UMacAppUtilities.h" 
							"USubstitution.h" for noload buids
		06/20/96	[1290382] (Strings) CStr255_AC could have constructor for STR# id & index
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		05/31/96	[1352846] Cluster behavior change. Calling DimState or SetEnabled will 
							propigate the changes to to subviews.
		05/08/96	Cleanup CRGBColor_AC and add new class CTextStyle_AC
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/26/96	Made TControl::ControlArea/ControlQDArea non virtual. Made TView/TControl::GetAdornExtent
							return their CViewRect as function results
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/18/96	Use post-increment with iterators in while loops
		04/17/96	InitUCluster
		04/15/96	Use "while" style iteration for subviews
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
		
*/