//----------------------------------------------------------------------------------------
// UImageWell.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		11/02/98	Include CStream_AC.h.
*/


#ifndef __UIMAGEWELL__
#include "UImageWell.h"
#endif

#if qAppearance

// ACS

#ifndef __CStream_AC__
#include "CStream_AC.h"
#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

//========================================================================================
// Global Initialization Procedure
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// InitUImageWell: 
//----------------------------------------------------------------------------------------


void InitUImageWell()
{
	static bool UImageWellInitialized;

	if (!UImageWellInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TImageWell, kStdImageWell);
		}
		UImageWellInitialized = true;
	}
}


//========================================================================================
// CLASS TImageWell
//========================================================================================
#undef Inherited
#define Inherited TView


MA_DEFINE_CLASS(TImageWell);

//----------------------------------------------------------------------------------------
// TImageWell constructor 
//----------------------------------------------------------------------------------------


TImageWell::TImageWell(const CViewPoint& itsLocation,
			 const CViewPoint& itsSize,
			 SizeDeterminer itsHSizeDet,
			 SizeDeterminer itsVSizeDet,
			 const CTextStyle_AC& itsTextStyle,
			 ControlContentType itsContentType,
			 SInt16 itsRsrcID) : 
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, gEmptyString, itsTextStyle),
	
	fContentType(itsContentType),
	fRsrcID(itsRsrcID)
{
}

//----------------------------------------------------------------------------------------
// TImageWell constructor 
//----------------------------------------------------------------------------------------


TImageWell::TImageWell(const TImageWell& inImageWell) : 
	TCtlMgr(inImageWell),
	
	fContentType(inImageWell.fContentType),
	fRsrcID(inImageWell.fRsrcID)
{
}

//----------------------------------------------------------------------------------------
// TImageWell destructor
//----------------------------------------------------------------------------------------


TImageWell::~TImageWell()
{
}

//----------------------------------------------------------------------------------------
// TImageWell::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TImageWell::GetStandardSignature() const
{
	return kStdImageWell;
}

//----------------------------------------------------------------------------------------
// TImageWell::ReadFields: 
//----------------------------------------------------------------------------------------

void TImageWell::ReadFields(CStream_AC* aStream)		// Override 
{
	Inherited::ReadFields(aStream);
	
	*aStream >> fContentType
			 >> fRsrcID;
}

//----------------------------------------------------------------------------------------
// TImageWell::WriteFields: 
//----------------------------------------------------------------------------------------

void TImageWell::WriteFields(CStream_AC* aStream) const		// Override 
{
	Inherited::WriteFields(aStream);

	*aStream << fContentType
			 << fRsrcID;
}

//----------------------------------------------------------------------------------------
// TImageWell::DoMakeControl: 
//----------------------------------------------------------------------------------------

CControl_AC* TImageWell::DoMakeControl(WindowRef theWindow, 
										const CRect_AC& boundsRect, 
										bool isVisible, bool isEnabled, 
										const CStr255_AC& /*itsTitle*/)
{
	return CreateImageWell_AC(theWindow, boundsRect, isVisible, isEnabled, 
							  fRsrcID, fContentType, this);
}

//----------------------------------------------------------------------------------------
// TImageWell::SetContentInfo: 
//----------------------------------------------------------------------------------------

	
void TImageWell::SetContentInfo(ControlButtonContentInfo& itsContent, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetImageWellContent(itsContent);
	}
}

//----------------------------------------------------------------------------------------
// TImageWell::GetContentInfo: 
//----------------------------------------------------------------------------------------
	
ControlButtonContentInfo TImageWell::GetContentInfo()
{
	ControlButtonContentInfo itsContent;
	if (GetControl())
	{
		itsContent = GetControl()->GetImageWellContent();
	}
	return itsContent;
}

//----------------------------------------------------------------------------------------
// TImageWell::SetTransform: 
//----------------------------------------------------------------------------------------

	
void TImageWell::SetTransform(IconTransformType newTransform, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetImageWellIconTransform(newTransform);
	}
}

//----------------------------------------------------------------------------------------
// TImageWell::GetTransform: 
//----------------------------------------------------------------------------------------
	
IconTransformType TImageWell::GetTransform()
{
	return GetControl() ? GetControl()->GetImageWellIconTransform() : ttNone;
}
	
#endif // qAppearance

//----------------------------------------------------------------------------------------
// End of UImageWell.cpp
