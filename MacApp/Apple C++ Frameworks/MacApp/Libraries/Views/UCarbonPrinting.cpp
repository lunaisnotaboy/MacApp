//----------------------------------------------------------------------------------------
// UCarbonPrinting.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		05/02/01	In CheckPrinterChangeLevel, don't need to use EqualString to
							compare old and new driver names. 
		04/07/01	[PB] GetScale was converting 'double' to 'short'. 
		03/30/01	Reenable use of PMGetAdjustedPaperRect in GetPaperRect.  Can also 
							now call PMGetScale in GetScale.
		01/22/01	Catch failure to get driver name in InitializePrinting.
		01/19/01	Use CString_AC instead of CStr255_AC.  Include CStdReporter_AC.h.
		01/02/01	Update copyright.
		11/13/00	[PB] GetHandleSize returns a Size, not a size_t. 
		11/09/00	[PB] Change initialization order to match declaration. 
							Remove unused local variable in InitializePrinting. 
		11/03/00	Don’t include Printing.h; already included by header.  Use
							NewPMIdleUPP instead of NewPMIdleProc.
		09/07/00	Suppress unused variable warning in GetPaperRect. 
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Include CMultiLocal.h.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		04/25/00	Reenable GetJobPort’s call to PMGetGrafPtr and use of 
							in a couple of other places.
		04/25/00	Pass jobContext, not jobPort, in FinishJob.
		04/24/00	PMGetScale and PMGetAdjustedPaperRect aren't supported in Carbon
							yet.  Don't dispose of flat handles in dtor (they're auto).
		04/21/00	Removed GetHPrint.  Renamed fPrintPort, fPrintShopOpens,
							fgLastPrinterName and fgPrinterChangeLevel to sfPrintPort,
							sfPrintShopOpens, sfLastPrinterName and sfPrinterChangeLevel. 
							Incorporated Open into StartPrintJob and Close into
							StopPrintJob, eliminating Open and Close.  Integrated
							ShowPrintDialog into CallJobDialog and ShowSetupDialog into
							CallStyleDialog.  Moved CallPrPicFile implementation into header.
							Added FlattenSettingsAndFormat. GetPrintPages and SetPrintPages now
							use unsigned longs.
		04/20/00	Move IsOpen implementation into header.  
		04/06/00	Cloned from the original Views:UPrinting.cpp.  All things
							TCarbonPrint are herein.
*/

#define __INCLUDED_BY_UCARBONPRINTING__

#ifndef __UCarbonPrinting__
#include "UCarbonPrinting.h"
#endif

#undef __INCLUDED_BY_UCARBONPRINTING__

// MacApp

#ifndef __MacAppRequired__
#include "MacAppRequired.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UFILE__
#include "UFile.h"
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CDependencies_AC__
#include "CDependencies_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CStdReporter_AC__
#include "CStdReporter_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// Toolbox

#ifndef __RESOURCES__
#include <Resources.h>
#endif

// ANSI

#ifndef __LIMITS__
#include <limits.h>
#endif

#ifndef __STDLIB__
#include <stdlib.h>
#endif

#ifndef __STRING__
#include <string.h>
#endif

//========================================================================================
// CLASS TCarbonPrintJob
//========================================================================================

//----------------------------------------------------------------------------------------
// TCarbonPrintJob statics
//----------------------------------------------------------------------------------------

unsigned short	TCarbonPrintJob::sfPrintShopOpens = 0;
GrafPtr 		TCarbonPrintJob::sfPrintPort;
CString_AC		TCarbonPrintJob::sfLastPrinterName;
unsigned long	TCarbonPrintJob::sfPrinterChangeLevel = 0;

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::InitializePrinting: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::InitializePrinting(TPrintInfo* defaultPrintInfo)
{
	static bool		carbonPrintingInitialized;
	
	try
	{
		if (!carbonPrintingInitialized)
		{
			// If no one else has already initialized
			// printing then we should.
			if (defaultPrintInfo == NULL)
				defaultPrintInfo = TH_new TCarbonPrintJob;
	
			TPrintHandler::gCouldPrint = true;
			carbonPrintingInitialized = true;
		}
		
		// Create a StdPrintHandler to install in global variable gPrintHandler
		TStdPrintHandler* aTStdPrintHandler = TH_new TStdPrintHandler;
		aTStdPrintHandler->fFinderJobDialog = true;
			
		TPrintInfo::InitUPrintMgr(TRefCntPrintInfo(defaultPrintInfo),
								  aTStdPrintHandler);
	}
	catch(CException_AC& theException)
	{
		if (theException.GetError() != resNotFound)
			throw(theException);
	}
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob constructor
//----------------------------------------------------------------------------------------

TCarbonPrintJob::TCarbonPrintJob()
	:	fPrintSettingsFlat(NULL),
		fPageFormatFlat(NULL),
		fPrintContext(NULL),
		fPrintDialog(NULL),
		fMinFromPage(0),
		fMaxToPage(0),
		fResFile(kNoFileRefNum_AC),
		fPrinterChangeLevel(0)
// TCarbonPrintJob constructor.
{
	if (sfPrintShopOpens == 0)
		ThrowIfBadOSStatus_AC(::PMBegin());		// Have to have an active print session.

	// Initialize PMPrintSettings and PMPageFormat.
	ThrowIfBadOSStatus_AC(::PMNewPrintSettings(&fPrintSettings));
	ThrowIfBadOSStatus_AC(::PMNewPageFormat(&fPageFormat));
	ThrowIfBadOSStatus_AC(::PMDefaultPrintSettings(fPrintSettings));
	ThrowIfBadOSStatus_AC(::PMDefaultPageFormat(fPageFormat));

	// Flatten the print settings since they are not persistent across calls to PMBegin.
	Handle			flatHandle = NULL;

	ThrowIfBadOSStatus_AC(::PMFlattenPrintSettings(fPrintSettings, &flatHandle));
	fPrintSettingsFlat = flatHandle;  // This will delete the old handle, if any.

	ThrowIfBadOSStatus_AC(::PMFlattenPageFormat(fPageFormat, &flatHandle));
	fPageFormatFlat = flatHandle;  // This will delete the old handle, if any.

	if (!sfPrinterChangeLevel)
		CheckPrinterChangeLevel();
	fPrinterChangeLevel = sfPrinterChangeLevel;

	if (sfPrintShopOpens == 0)
		ThrowIfBadOSStatus_AC(::PMEnd());
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob THPrint constructor
//----------------------------------------------------------------------------------------

TCarbonPrintJob::TCarbonPrintJob(THPrint itsHPrint)
	:	fPrintSettingsFlat(NULL),
		fPageFormatFlat(NULL),
		fPrintContext(NULL),
		fPrintDialog(NULL),
		fMinFromPage(0),
		fMaxToPage(0),
		fResFile(kNoFileRefNum_AC),
		fPrinterChangeLevel(0)
// TCarbonPrintJob constructor which takes an old-style THPrint and builds a new
// TCarbonPrintJob therefrom.
{
	if (sfPrintShopOpens == 0)
		ThrowIfBadOSStatus_AC(::PMBegin());		// Have to have an active print session.

	if (itsHPrint)
		ThrowIfBadOSStatus_AC(::PMConvertOldPrintRecord(reinterpret_cast<Handle>(itsHPrint),
														&fPrintSettings, &fPageFormat));
	else
	{
#if qDebug
		ProgramReport_AC("TCarbonPrintJob::TCarbonPrintJob: THPrint provided is NULL.");
#endif
		// Initialize PMPrintSettings, PMPageFormat and PMPrintContext.
		ThrowIfBadOSStatus_AC(::PMNewPrintSettings(&fPrintSettings));
		ThrowIfBadOSStatus_AC(::PMNewPageFormat(&fPageFormat));
		ThrowIfBadOSStatus_AC(::PMDefaultPrintSettings(fPrintSettings));
		ThrowIfBadOSStatus_AC(::PMDefaultPageFormat(fPageFormat));
	}

	// Flatten the print settings since they are not persistent across calls to PMBegin.
	Handle			flatHandle = NULL;

	ThrowIfBadOSStatus_AC(::PMFlattenPrintSettings(fPrintSettings, &flatHandle));
	fPrintSettingsFlat = flatHandle;  // This will delete the old handle, if any.

	ThrowIfBadOSStatus_AC(::PMFlattenPageFormat(fPageFormat, &flatHandle));
	fPageFormatFlat = flatHandle;  // This will delete the old handle, if any.

	if (!sfPrinterChangeLevel)
		CheckPrinterChangeLevel();
	fPrinterChangeLevel = sfPrinterChangeLevel;

	if (sfPrintShopOpens == 0)
		ThrowIfBadOSStatus_AC(::PMEnd());
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob copy constructor
//----------------------------------------------------------------------------------------

TCarbonPrintJob::TCarbonPrintJob(const TCarbonPrintJob& inPrintJob)
	:	TPrintInfo(inPrintJob),
		fPrintSettingsFlat(NULL),
		fPageFormatFlat(NULL),
		fPrintContext(NULL),
		fPrintDialog(NULL),		// Sorry, but this just can't be cloned
		fMinFromPage(inPrintJob.fMinFromPage),
		fMaxToPage(inPrintJob.fMaxToPage),
		fResFile(kNoFileRefNum_AC),
		fPrinterChangeLevel(inPrintJob.fPrinterChangeLevel)
{
	if (this != &inPrintJob)
	{
		// Copy PMPrintSettings and PMPageFormat.
		Handle			flatHandle = NULL;
		if (IsHandle_AC(inPrintJob.fPrintSettingsFlat))
		{
			CopyHandle_AC(inPrintJob.fPrintSettingsFlat, flatHandle);
			fPrintSettingsFlat = flatHandle;
		}
		if (IsHandle_AC(inPrintJob.fPageFormatFlat))
		{
			CopyHandle_AC(inPrintJob.fPageFormatFlat, flatHandle);
			fPageFormatFlat = flatHandle;
		}
	}
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::ReadFrom: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::ReadFrom(CStream_AC* aStream)
{
	TPrintInfo::ReadFrom(aStream);

	fPrintSettingsFlat = aStream->ReadHandle();
	fPageFormatFlat = aStream->ReadHandle();

	Invalidate();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::WriteTo: 
//----------------------------------------------------------------------------------------


void TCarbonPrintJob::WriteTo(CStream_AC* aStream) const
{
	TPrintInfo::WriteTo(aStream);	// Was: MStreamable::WriteTo(aStream);

	aStream->WriteHandle(fPrintSettingsFlat);
	aStream->WriteHandle(fPageFormatFlat);
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::OpenPrintShop: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::OpenPrintShop()
{
	ThrowIfBadOSStatus_AC(::PMBegin());

	// Restore the print settings and page format by unflattening the old data.
	ThrowIfBadOSStatus_AC(::PMUnflattenPrintSettings(fPrintSettingsFlat, &fPrintSettings));
	ThrowIfBadOSStatus_AC(::PMUnflattenPageFormat(fPageFormatFlat, &fPageFormat));
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::ClosePrintShop: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::ClosePrintShop()
{
	// Save the print settings and page format.
	FlattenSettingsAndFormat();
	ThrowIfBadOSStatus_AC(::PMEnd());
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetFrom
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetFrom(TRefCntPrintInfo jobToCopy)
{
	TPrintInfo::SetFrom(jobToCopy);

	TCarbonPrintJob* aJobToCopy = dynamic_cast_or_throw_AC(TCarbonPrintJob*, jobToCopy.get());

	if (this != aJobToCopy)
	{
		aJobToCopy->FlattenSettingsAndFormat();
		
		// Copy PMPrintSettings and PMPageFormat.
		Handle		newFlatHandle = NULL;
		Handle		oldFlatHandle = aJobToCopy->GetPrintSettingsFlat();

		if (::IsHandle_AC(oldFlatHandle))
		{
			::CopyHandle_AC(oldFlatHandle, newFlatHandle);
			fPrintSettingsFlat = newFlatHandle;
		}

		oldFlatHandle = aJobToCopy->GetPageFormatFlat();
		if (::IsHandle_AC(oldFlatHandle))
		{
			::CopyHandle_AC(oldFlatHandle, newFlatHandle);
			fPageFormatFlat = newFlatHandle;
		}
	}

	if (IsOpen())
	{
		// If we're already open then we need to unflatten our new settings.
		ThrowIfBadOSStatus_AC(::PMUnflattenPrintSettings(fPrintSettingsFlat, &fPrintSettings));
		ThrowIfBadOSStatus_AC(::PMUnflattenPageFormat(fPageFormatFlat, &fPageFormat));
		Changed(mPrintInfoChanged, this);
	}
	else
		Invalidate();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetFrom
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetFrom(	THPrint		hPrintToCopy,
								bool		isValid,
								bool		needsDefault)
{
	CPrintJobStarterStopper		jobStarterStopper(this);

	::ThrowIfNULL_AC(hPrintToCopy);
	ThrowIfBadOSStatus_AC(::PMConvertOldPrintRecord(reinterpret_cast<Handle>(hPrintToCopy),
													&fPrintSettings, &fPageFormat));
	FlattenSettingsAndFormat();

	fIsValid = isValid;
	fNeedsDefault = needsDefault;

	if (fIsValid)
		Changed(mPrintInfoChanged, this);
	else
		Invalidate();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetSize
//----------------------------------------------------------------------------------------

long TCarbonPrintJob::GetSize(bool asResource) const
{
	#pragma unused (asResource)
	FlattenSettingsAndFormat();

	long returnVal = GetHandleSize(fPrintSettingsFlat.get())
					+ GetHandleSize(fPageFormatFlat.get());

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::IsMatch
//----------------------------------------------------------------------------------------

bool TCarbonPrintJob::IsMatch(const TRefCntPrintInfo thePrintInfo) const
{
	FlattenSettingsAndFormat();
	TCarbonPrintJob*	oldPrintJob = dynamic_cast_or_throw_AC(TCarbonPrintJob*, thePrintInfo.get());
	Handle				hPrintSettings = oldPrintJob->GetPrintSettingsFlat();
	Handle				hPageFormat = oldPrintJob->GetPageFormatFlat();
	Size				settingsSize = GetHandleSize(hPrintSettings);
	Size				formatSize = GetHandleSize(hPageFormat);

	return fIsValid
			&& GetHandleSize(fPrintSettingsFlat.get()) == settingsSize
			&& GetHandleSize(fPageFormatFlat.get()) == formatSize
			&& EqualBlocks_AC(*fPrintSettingsFlat, *hPrintSettings, settingsSize)
			&& EqualBlocks_AC(*fPageFormatFlat, *hPageFormat, formatSize);
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetToDefault:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetToDefault()
{
	fNeedsDefault = true;
	SetFrom(GetDefaultPrintInfo());

	Invalidate();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::IsSetToDefault:
//----------------------------------------------------------------------------------------


bool TCarbonPrintJob::IsSetToDefault() const
{
	return fNeedsDefault || GetDefaultPrintInfo()->IsMatch(const_cast<TCarbonPrintJob*>(this));
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetPrintPages:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::GetPrintPages(unsigned long& fromPage,
									unsigned long& toPage,
									unsigned long& minFromPage,
									unsigned long& maxToPage) const
{
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TCarbonPrintJob*>(this));
	ThrowIfBadOSStatus_AC(::PMGetFirstPage(fPrintSettings, &fromPage));
	ThrowIfBadOSStatus_AC(::PMGetLastPage(fPrintSettings, &toPage));

	minFromPage = fMaxToPage;
	maxToPage = fMaxToPage;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetPrintPages:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetPrintPages(unsigned long fromPage,
									unsigned long toPage,
									unsigned long minFromPage,
									unsigned long maxToPage)
{
// •••  Check out what 'lock' means.
//#pragma message ("TCarbonPrintJob::SetPrintPages: Just exactly what does the third parameter, 'lock' mean?")
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TCarbonPrintJob*>(this));
	ThrowIfBadOSStatus_AC(::PMSetFirstPage(fPrintSettings, fromPage, false));
	ThrowIfBadOSStatus_AC(::PMSetLastPage(fPrintSettings, toPage, false));
	
	fMinFromPage = minFromPage;
	fMaxToPage = maxToPage;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetPrintCopies:
//----------------------------------------------------------------------------------------

unsigned long TCarbonPrintJob::GetPrintCopies() const
// GetPrintCopies retrieves and returns the number of copies the user has
// specified for the print job.
{
	unsigned long	copies;
	ThrowIfBadOSStatus_AC(::PMGetCopies(fPrintSettings, &copies));
	return copies;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetNumCopies:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetPrintCopies(unsigned long numCopies)
// SetPrintCopies allows the number of copies of the current print job to be
// specified.
//
// numCopies:	A long containing the number of copies of the print job requested.
{
	ThrowIfBadOSStatus_AC(::PMSetCopies(fPrintSettings, numCopies, false));
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetPaperRect:
//----------------------------------------------------------------------------------------

CViewRect TCarbonPrintJob::GetPaperRect() const
// GetPaperRect retrieves the physical paper size for the selected printer and returns
// it as a CViewRect.  This function must be called within an active print job.
{
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TCarbonPrintJob*>(this));
	
	PMRect paperRect;
	ThrowIfBadOSStatus_AC(::PMGetAdjustedPaperRect(fPageFormat, &paperRect));
	return CViewRect(paperRect.left, paperRect.top, paperRect.right, paperRect.bottom);
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetInkRect:
//----------------------------------------------------------------------------------------

CViewRect TCarbonPrintJob::GetInkRect() const
// GetInkRect retrieves the logical page size, or the size of the area in which
// printing can be performed, for the selected printer and returns
// it as a CViewRect.  This function must be called within an active print job.
{
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TCarbonPrintJob*>(this));
	PMRect						pageRect;
	
	ThrowIfBadOSStatus_AC(::PMGetAdjustedPageRect(fPageFormat, &pageRect));
	return CViewRect(pageRect.left, pageRect.top, pageRect.right, pageRect.bottom);
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetDeviceRes:
//----------------------------------------------------------------------------------------

CPoint_AC TCarbonPrintJob::GetDeviceRes() const
// GetDeviceRes determines and returns a CPoint_AC containing the horizontal
// and vertical resolution of the printing device for the current print jobl.
{
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TCarbonPrintJob*>(this));
	PMResolution				theResolution;
	ThrowIfBadOSStatus_AC(::PMGetResolution(fPageFormat, &theResolution));
	return CPoint_AC(theResolution.hRes, theResolution.vRes);
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::CheckPrinterChangeLevel: 
//----------------------------------------------------------------------------------------

unsigned long TCarbonPrintJob::CheckPrinterChangeLevel()
// CheckPrinterChangeLevel retrieves the name of the printer driver for the currently
// selected printer, compares that with the previous name, increments the change
// count if they are different, and returns the count as an unsigned long.
{
	CString_AC driverName;
	GetDriverName(driverName);

	if (driverName != sfLastPrinterName)
	{
		sfLastPrinterName = driverName;				// Save it for later
		++sfPrinterChangeLevel;						// bump the change level

		TPrintHandler::gCouldPrint = true;			// Could be OK now
		TMenuBarManager::InvalidateMenus();			// so the menus stay in sync.
	}

	return sfPrinterChangeLevel;
}

//----------------------------------------------------------------------------------------
// void TCarbonPrintJob::StartPrintJob: 
//----------------------------------------------------------------------------------------

bool TCarbonPrintJob::StartPrintJob(CPrintJobStarterStopper* starterStopper)
// StartPrintJob is called to start up a print job and returns a true if the job
// was actually started.  If the print job has already been started then a false is
// returned.
//
// starterStopper:	A CPrintJobStarterStopper* which made the call.
//
// Call:		Seldom.  StartPrintJob is usally called by an instance of CPrintJobStarterStopper
//				in response to a call to some other TCarbonPrintJob or TPrintInfo routine.
// Override:	Rarely.  Override only if you have a custom print job which must save
//				additional job related information.
{
	#pragma unused (starterStopper)
	
	bool	jobStarted = false;
	
	if (sfPrintShopOpens == 0)		// Only start up the print job if it is not already started.
	{
		fResFile = CurResFile_AC();
		ClearError();					// Clear printer-error flag 

		OpenPrintShop();
#if 0
// •••  I don't believe the following is necessary under Carbon since the
// PMBegin should toss any errors it encounters.

		// The Universal Headers as of 10/17/95 don't provide the following constant!!!
		static const OSErr kPAPNoPrinter = -4101;

		OSErr err = GetError();					// Get code 
		if (err != noErr)
		{
			if ((err == fnfErr) || (err == resFNotFound) || (err == resNotFound) || (err == dirNFErr) || (err == kPAPNoPrinter))
				err = errNoPrintDrvr;
			else if ((err == fBsyErr) || (err == opWrErr))
				err = errPrintDriverBusy;
			::ThrowException_AC(err, 0);
		}
#endif
		jobStarted = true;
	}
	++sfPrintShopOpens;

	if (jobStarted)
		Changed(mPrinterOpened, starterStopper);
	
	return jobStarted;
}

//----------------------------------------------------------------------------------------
// void TCarbonPrintJob::StopPrintJob: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::StopPrintJob(	CPrintJobStarterStopper*	starterStopper,
									bool						wasStarted)
// StopPrintJob is called to shut down a print job.  Since multiple overlapping start
// job requests may be made only that oldest request to shut down the print job will
// be honored.
//
// starterStopper:	A CPrintJobStarterStopper* which made this call.  This can be compared
//					to the starterStopper which last called StartPrintJob if necessary
//					(though that information is not saved by this implementation).
// wasStarted:		A bool indicating if this instance of starterStopper was the one which
//					caused the job to be opened.
//
// Call:		Seldom.  StopPrintJob is usally called by the destructor of an instance of
//				CPrintJobStarterStopper. 
// Override:	Rarely.  Override only if you have a custom print job which must restore
//				additional job related information.
{
	#pragma unused (starterStopper)
	
	if (wasStarted)
	{
		if (GetError() == errNoPrintDrvr)
		{
			TPrintHandler::gCouldPrint = false;		// well, we didn't make it. don't bother to try again
			TMenuBarManager::InvalidateMenus();		// so the menus stay in sync.
		}

		bool didClose = false;
	
		if (sfPrintShopOpens == 1)
		{
			ClosePrintShop();
	
#if 0
	// •••  I don't believe the following is necessary under Carbon since the
	// PMEnd should toss any errors it encounters.
	#if qDebugMsg
			OSErr err = GetError();
			// Now check for fresh error from Print Manager --
			// only for debugging, since WasPrintError
			// checks afresh in the real world
			if (err != noErr)
				ProgramReport_AC("TCarbonPrintJob::StopPrintJob: Error from Print Manager is: %1d\n", err);
	#endif
#endif
	
			didClose = true;
		}
	
#if qDebug
		// Make sure we don't have too many calls to Close.
		if (sfPrintShopOpens == 0)
			ProgramBreak_AC("TCarbonPrintJob::StopPrintJob: Too many calls to shut down print job.");
#endif
	
	
		if (didClose)
			Changed(mPrinterClosed, starterStopper);
	
		UseResFile_AC(fResFile);
		SetPortWindowPort(gWorkPort);			// Might be left looking at a dead port 
		gDispatcher->InvalidateFocus();
	}
#if qDebug
	else if (sfPrintShopOpens == 1)
	{
		// This should have probably been the call which shut down the print shop
		// but whoever called us doesn't seem to think so.
		ProgramBreak_AC("TCarbonPrintJob::StopPrintJob: Our caller does not think we should shut down but our count indicates we should.");
	}

	if (sfPrintShopOpens == 0)
	{
		// We should never be being called with sfPrintShopOpens == 0.
		ProgramBreak_AC("TCarbonPrintJob::StopPrintJob: Called when sfPrintShopOpens == 0.  This should never happen.");
	}
#endif

	--sfPrintShopOpens;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetError: 
//----------------------------------------------------------------------------------------

OSErr TCarbonPrintJob::GetError() const
// GetError returns the current error status from the print job as an OSErr (although
// it starts out life as an OSStatus).
{
	return ::PMError();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::WasPrintError: 
//----------------------------------------------------------------------------------------

bool TCarbonPrintJob::WasPrintError(OSErr& error, bool& ranOutOfSpace) const
{
	bool proceed = true;			// Default is "No error so proceed!"
	error = GetError();
	if (error != noErr)
	{
#if qDebugMsg
		if (gDebugPrinting)
			ProgramReport_AC("TCarbonPrintJob::WasPrintError: Error from PrError is %d\n", error);
#endif

		proceed = false;
		if (error == dskFulErr)
			ranOutOfSpace = true;
	}

	return proceed;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetError: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetError(OSErr err)
{
	if (sfPrintShopOpens > 0)
		ThrowIfBadOSStatus_AC(::PMSetError((OSStatus)err));
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::StartJob: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::StartJob(const CString_AC& docTitle, long numPages)
// StartJob is called by the print handler attached to a document.  It is the main
// entry point to the printing job.  It must be called within an already started
// print job.
//
// docTitle:	A const CString_AC& containing the name of the document being printed.
// numPages:	A long containing the number of pages which are to be printed.  This
//				only gives a number which can be displayed in a progress indicator.
//
// Call:		Never.  StartJob should be called by the print handler.
// Override:	Never.
{
	#pragma unused (numPages)

	fCurrentDocTitle = docTitle;
	ThrowIfBadOSStatus_AC(::PMBeginDocument(fPrintSettings, fPageFormat, &fPrintContext));
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetJobPort: 
//----------------------------------------------------------------------------------------

GrafPtr TCarbonPrintJob::GetJobPort() const
// GetJobPort returns the current printing grafPort.  
{
	ThrowIfBadOSStatus_AC(::PMGetGrafPtr(fPrintContext, &sfPrintPort));
	return sfPrintPort;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::FinishJob: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::FinishJob()
// FinishJob is called by the print handler attached to a document to indicate that
// printing has been completed and the print job can be shut down.  It is the main
// exit point from the printing job.  It must be called within an already started
// print job.
//
// Call:		Never.  FinishJob should be called by the print handler.
// Override:	Never.
{
#if qDebug
	if (sfPrintShopOpens == 0)
		::ProgramBreak_AC("TCarbonPrintJob::FinishJob: sfPrintShopOpens is 0, should be > 0.");
#endif
	ThrowIfBadOSStatus_AC(::PMEndDocument(fPrintContext));	// This will close the port!
	sfPrintPort = NULL;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::StartPage: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::StartPage(long pageNumber)
// StartPage is called by the print handler to indicate that a new page is going to
// be started.  It must be called within an already started print job.
//
// pageNumber:	A long containing the number of the page which is to be printed.  This
//				gives a number which can be used to control a progress indicator.
//
// Call:		Never.  StartPage should be called by the print handler.
// Override:	Never.
{
	#pragma unused (pageNumber)
#if qDebug
	if (sfPrintShopOpens == 0)
		::ProgramBreak_AC("TCarbonPrintJob::StartPage: sfPrintShopOpens is 0, should be > 0.");
#endif
	ThrowIfBadOSStatus_AC(::PMBeginPage(fPrintContext, NULL));
	ThrowIfBadOSStatus_AC(::PMGetGrafPtr(fPrintContext, &sfPrintPort));
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::FinishPage: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::FinishPage()
// FinishPage is called by the print handler to indicate that the current page
// has been completed.  It must be called within an already started print job.
//
// Call:		Never.  FinishPage should be called by the print handler.
// Override:	Never.
{
#if qDebug
	if (sfPrintShopOpens == 0)
		::ProgramBreak_AC("TCarbonPrintJob::FinishPage: sfPrintShopOpens is 0, should be > 0.");
#endif
	ThrowIfBadOSStatus_AC(::PMEndPage(fPrintContext));
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::CallJobDialog: 
//----------------------------------------------------------------------------------------

bool TCarbonPrintJob::CallJobDialog()
// CallJobDialog presents the print dialog to the user.  If the user accepts the dialog
// by pressing OK then a true is returned.
{
	::ThrowIfOSErr_AC(MAInteractWithUser());
	PullApplicationToFront();

	::SetCursorToArrow_AC();
	if (gDispatcher)
		gDispatcher->InvalidateMouseRegions();

	CPrintJobStarterStopper		jobStarterStopper(this);

	gDispatcher->AboutToLoseControl(true);		// so scrap gets converted and floaters get removed

	Boolean wasAccepted;
	ThrowIfBadOSStatus_AC(::PMPrintDialog(fPrintSettings, fPageFormat, &wasAccepted));
	gDispatcher->RegainControl(true);			// scrap gets converted, printer gets checked, floaters get restored

	return wasAccepted;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::CallStyleDialog: 
//----------------------------------------------------------------------------------------

bool TCarbonPrintJob::CallStyleDialog()
// CallStyleDialog presents the print setup dialog to the user.  If the user accepts the
// dialog by pressing OK then a true is returned.
{
	::ThrowIfOSErr_AC(MAInteractWithUser());
	PullApplicationToFront();

	::SetCursorToArrow_AC();
	if (gDispatcher)
		gDispatcher->InvalidateMouseRegions();

	CPrintJobStarterStopper		jobStarterStopper(this);

	gDispatcher->AboutToLoseControl(true);		// so scrap gets converted and floaters get removed
	Boolean wasAccepted;
	ThrowIfBadOSStatus_AC(::PMPageSetupDialog(fPageFormat, &wasAccepted));
	gDispatcher->RegainControl(true);			// scrap gets converted, printer gets checked, floaters get restored

	return wasAccepted;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::ValidatePrintJob: 
//----------------------------------------------------------------------------------------

bool TCarbonPrintJob::ValidatePrintJob()
// ValidatePrintJob validates the print settings and page format and returns true if
// everything is okay.
{
	CPrintJobStarterStopper		jobStarterStopper(this);
	Boolean						aSettingResult;
	Boolean						aFormatResult;
	
	ThrowIfBadOSStatus_AC(::PMValidatePrintSettings(fPrintSettings, &aSettingResult));
	ThrowIfBadOSStatus_AC(::PMValidatePageFormat(fPageFormat, &aFormatResult));
	return (aFormatResult && aSettingResult);
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetPrintJobDefaults: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetPrintJobDefaults()
// SetPrintJobDefaults initializes the print settings and page format according to the
// current printer’s default values for resolution, number of copies, and so on. 
{
	bool						wasPrinting = IsOpen();
	CPrintJobStarterStopper		jobStarterStopper(this);

	if (!wasPrinting)
	{
		// Unflatten the old data, if necessary.
		ThrowIfBadOSStatus_AC(::PMUnflattenPrintSettings(fPrintSettingsFlat, &fPrintSettings));
		ThrowIfBadOSStatus_AC(::PMUnflattenPageFormat(fPageFormatFlat, &fPageFormat));
	}

	ThrowIfBadOSStatus_AC(::PMDefaultPrintSettings(fPrintSettings));
	ThrowIfBadOSStatus_AC(::PMDefaultPageFormat(fPageFormat));
	FlattenSettingsAndFormat();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::FlattenSettingsAndFormat: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::FlattenSettingsAndFormat() const
// FlattenSettingsAndFormat reflattens the print settings and page format records.  Nothing
// is done if we are not currently in an active print job since the records should have
// already been flattened.
{
	if (IsOpen())
	{
		Handle			flatHandle = NULL;
	
		ThrowIfBadOSStatus_AC(::PMFlattenPrintSettings(fPrintSettings, &flatHandle));
		fPrintSettingsFlat = flatHandle;  // This will delete the old handle, if any.
	
		ThrowIfBadOSStatus_AC(::PMFlattenPageFormat(fPageFormat, &flatHandle));
		fPageFormatFlat = flatHandle;  // This will delete the old handle, if any.
	}
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetDriverName: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::GetDriverName(CString_AC& driverName)
{
	driverName = CString_AC(static_cast<ResNumber>(kPrintDriverName)); 
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::Update:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::Update() const
{
	// Printer name may have changed… out with the old in with the new...
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TCarbonPrintJob*>(this));
	fPrinterChangeLevel = sfPrinterChangeLevel;
	
	TPrintInfo::Update();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::DoUpdate:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::DoUpdate(ChangeID_AC		theChange,
						 MDependable_AC*		changedObject,
						 void*					changeData,
						 CDependencySpace_AC*	dependencySpace)
{
	switch (theChange)
	{
		case mRegainControl:
			if (CheckPrinterChangeLevel() != fPrinterChangeLevel)
			{
 				Invalidate();
				Changed(mPrinterChanged, this);
			}
			break;

		default:
			TPrintInfo::DoUpdate(theChange, changedObject, changeData, dependencySpace);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::JobMerge:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::JobMerge(TRefCntPrintInfo mergeFrom)
{
	#pragma unused (mergeFrom)
#if qDebug
	::ProgramBreak_AC("TCarbonPrintJob::JobMerge: PrJobMerge not supported by Carbon.  How did you get here?");
#endif
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::IdleProc: 
//----------------------------------------------------------------------------------------

pascal void TCarbonPrintJob::IdleProc()
// IdleProc is installed after posing the print dialog and just before printing starts.
{
	if (gJobPrintHandler)
	{
		CTempUseResFile_AC tempUseResFile(CurResFile_AC()); // save it so it can be restored if someone forgets

		GrafPtr savedPort;
		GetPort(&savedPort);
		SetPortWindowPort(gWorkPort);

		TPrintHandler*	currentPrintHandler = TPrintHandler::gCurrPrintHandler.release();	// So we can focus when updating and activating windows
		bool			printingStatus = TView::gPrinting;

		TView::gPrinting = false;

		gDispatcher->SetEventLevel(gDispatcher->GetEventLevel() + 1);				// Increment the event level for proper busy cursor handling
		dynamic_cast_or_throw_AC(TCarbonPrintJob*, gJobPrintHandler->fPrintInfo.get())->DoPrintIdling();		// Forward to the current print job handler
		gDispatcher->SetEventLevel(gDispatcher->GetEventLevel() - 1);

		TPrintHandler::gCurrPrintHandler = currentPrintHandler;
		TView::gPrinting = printingStatus;

		::SetPort_AC(savedPort);
	}
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::DoPrintIdling: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::DoPrintIdling()
// DoPrintIdling is a print job idle time handler.  It handles events in the 'Print Dialogs'
// and gives the user 'Cancel', and, in the case of printing from the Finder, 'Cancel All
// Printing.'
{
	const short myDlgMask = mDownMask | mUpMask | keyDownMask | keyUpMask | autoKeyMask | activMask;

//	TToolboxEvent * event = gDispatcher->GetEvent(myDlgMask, 0, NULL);
	TToolboxEvent event(gDispatcher, NULL, TToolboxEvent::kDontFree);
	bool gotAnEvent = gDispatcher->GetEvent(myDlgMask, 0, NULL, event);
	if (gotAnEvent)
	{
		// Workaround for LaserWriter driver bug: it tries to set GhostWindow
		// so that its status window is invisible. Unfortunately, it doesn't
		// always set it, so IsDialogEvent returns false (the status window
		// is frontmost).  If ours isn't already in front, force it there.
		if ((WindowRef)fPrintDialog != FrontWindow())
			TWindow::MASelectToolboxWindow((WindowRef)fPrintDialog);// 3.5

		switch (event.GetWhat())
		{
			case keyDown:
				{
					if (((event.GetText() == '.') && event.IsCommandKeyPressed()) ||
						((event.GetText() == chEscape) && (event.GetKeyCode() == kEscapeVirtualCode)))
					{
						short item = 1;			// Want the 'Cancel' button 

//						if (fPrintingCommand == cFinderPrint || fPrintingCommand == cDragPrint)
//						item = cancel;		// Want the 'Cancel All' button 

						// Flash the appropriate button 
						Handle theItem;
						short itemType;
						CRect_AC box;
						GetDialogItem(fPrintDialog, item, &itemType, &theItem, box);

						HiliteControl((ControlRef)theItem, 10);
						DelayFuture_AC(8);
						HiliteControl((ControlRef)theItem, 0);

						SetError(iPrAbort);
						gCancelAllPrinting = true;
					}
					break;
				}

			default:
				{
					EventRecord anEventRecord = event.GetEventRecord(0);
					DialogRef aDialog;
					short item;
					if (IsDialogEvent(&anEventRecord) && DialogSelect(&anEventRecord, &aDialog, &item) && (aDialog == fPrintDialog))
					{
						switch (item)
						{
							case 1:
								SetError(iPrAbort);// Cancel
								break;

							case cancel:		// Cancel All Printing 
								SetError(iPrAbort);
								gCancelAllPrinting = true;
								break;
						}
					}
					else if (event.GetWhat() == mouseDown)
					{
						WindowRef aWindow;
						short itsPart = ::FindWindow_AC(event.GetWhere(), &aWindow);
						if (itsPart == inDrag && aWindow == (WindowRef)fPrintDialog)
						{
							CRect_AC moveBounds(-32000, -32000, 32000, 32000);
							TWindow::MADragWindow((WindowRef)fPrintDialog, event.GetWhere(), moveBounds);
						}
					}
					break;
				}
		}
	}
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::PosePrintDialog: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::PosePrintDialog(const CString_AC& docName, CommandNumber aCommandNumber)
// PosePrintDialog presents the application modal dialog which presents printing
// progress information.
//
// docName:			The name of the document being printed.
// aCommandNumber:	The number of the command causing the printing to be performed.
//
// Call:		Never.  PosePrintDialog is called by the print handler.
// Override:	Seldom.  Override only if you want to do something special with the
//				print progress dialog.
{
	short			dlgNumber;
	DialogTHndl		dlogTemplate;
	short			itemNo;
	Handle			theItem;
	short			itemType;
	CRect_AC		box;
	Str255			itemText;

	::ThrowIfOSErr_AC(MAInteractWithUser());

	if (aCommandNumber == cFinderPrint || aCommandNumber == cDragPrint)
	{
		dlgNumber = phFinderPrintDialog;
		itemNo = 3;
	}
	else
	{
		dlgNumber = phSpoolPrintDialog;
		itemNo = 2;
	}

	// Can't use GetNewCenteredDialog because vertically centering the dialog may cause it
	// to interfere with the Print Manager's status windows.  Therefore, leave the vertical
	// location of the dialog fixed.

	::SetCursorToArrow_AC();
	gDispatcher->InvalidateMouseRegions();
	dlogTemplate = (DialogTHndl)CMultiLocale_AC::GetResource('DLOG', dlgNumber);
	if (dlogTemplate)
	{
		CenterRectOnScreen(((CRect_AC &)(*dlogTemplate)->boundsRect), true, false, false);
		fPrintDialog = GetNewDialog(CMultiLocale_AC::GetExistingResourceID('DLOG', dlgNumber), NULL, (WindowRef) - 1);
		::ThrowIfNULL_AC(fPrintDialog);
	}
	else
	{
#if qDebugMsg
		ProgramReport_AC("You may have forgotten to include Printing.rsrc in your .r file…\n");
		::ProgramBreak_AC("The print job dialog resource can't be found.");
#endif

		::ThrowIfNULLResource_AC((Handle)dlogTemplate);
	}

	// Substitute the document name for '<<!=>>' in 'Document “<<!=>>” is being printed'.
	// ParamText would be a lot simpler, but the Print Mgr. also uses ParamText, and
	// the substitution doesn't happen until draw time.
	::GetDialogItem(fPrintDialog, itemNo, &itemType, &theItem, &box);
	if (theItem)
	{
		::GetDialogItemText(theItem, itemText);
		::SetDialogItemText(theItem, CStr255_AC(CString_AC(itemText).DoSubstitution(docName)));
	}

	SetPrintIdleProc();
	
	::SetWTitle((WindowRef)fPrintDialog, CStr255_AC(docName));	// In case Print Mgr. needs it. 
	DrawDialog(fPrintDialog);
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::BanishPrintDialog: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::BanishPrintDialog()
// BanishPrintDialog gets rid of the print job progress dialog.
//
// Call:		Never.  BanishPrintDialog is called by the print handler.
// Override:	Seldom.  Only override if you must do some special cleanup for the dialog.
{
	if (fPrintDialog)
	{
		if (::GetDialogPort(fPrintDialog) == GetGrafPtr_AC())	// Only need to invalidate focus if freed

		// dialog is the current port
		{
			gDispatcher->InvalidateFocus();
			SetPortWindowPort(gWorkPort);
		}
		DisposeDialog(fPrintDialog);
		fPrintDialog = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::ShowDocBeingPrinted: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::ShowDocBeingPrinted(const CString_AC& docName, bool entering)
// ShowDocBeingPrinted plug the name of the document being printed into the progress
// dialog.
//
// docName:		A const CString_AC& containing the name of the document being printed.
// entering:	A book indicating if we are starting or have just completed printing
//				the document.
//
// Call:		Never.  ShowDocBeingPrinted is called by the print handler.
// Override:	Seldom, only when you've got some special progress dialog for which
//				additional information must be displayed.
{
	if (entering)
	{
		fPrintDialog = GetNewDialog(phWhichDoc, NULL, (WindowRef) - 1);
		if (fPrintDialog)
		{
			SetWTitle((WindowRef)fPrintDialog, CStr255_AC(docName));
			DrawDialog(fPrintDialog);
		}
#if qDebug
		else
		{
			CString_AC	theString;
			stringprintf(theString, "TCarbonPrintJob::ShowDocBeingPrinted: Unable to load dialog %d.", phWhichDoc);
			::ProgramBreak_AC(theString);
		}
#endif

	}
	else
		BanishPrintDialog();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::GetMaxSquareResolution:
//----------------------------------------------------------------------------------------

double TCarbonPrintJob::GetMaxSquareResolution() const
// GetMaxSquareResolution determines the maximum discrete resolution where hRes
// and vRes are the same.  The result is a double value.  This function can
// be called outside of a print job.
{
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TCarbonPrintJob*>(this));
	PMResolution				theResolution;
	
	ThrowIfBadOSStatus_AC(::PMGetPrinterResolution(kPMMaxSquareResolution, &theResolution));

	return theResolution.hRes;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetResolution:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetResolution(const PMResolution& theResolution)
// SetResolution sets the resolution for the print job.  This call must be made
// within an active print job.
//
// theResolution:	A const PMResolution& containing the new horizontal
//					and vertical resolution.
{
	ThrowIfBadOSStatus_AC(::PMSetResolution(fPageFormat, &theResolution));

	Invalidate();
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::MaximizeResolution:
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::MaximizeResolution()
// MaximizeResolution determines the maximum possible square resolution for the
// printer and then sets our job to print using that resolution.  This function may
// be called outside of a print loop.
{
	CPrintJobStarterStopper		jobStarterStopper(this);
	double						theResolution = GetMaxSquareResolution();
	PMResolution				maxResolution = {theResolution, theResolution};
	SetResolution(maxResolution);
}

//----------------------------------------------------------------------------------------
// TPrintInfo::GetScale:
//----------------------------------------------------------------------------------------

short TCarbonPrintJob::GetScale() const
// GetScale determines and returns the current print scaling as a whole percent
// where 100% == 100.
//
// Call:		If needed.
// Override:	Never.
{
	CPrintJobStarterStopper		jobStarterStopper(const_cast<TCarbonPrintJob*>(this));
	double						scale = 100;

	ThrowIfBadOSStatus_AC(::PMGetScale(fPageFormat, &scale));
	return static_cast<short>(scale);
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::TotalSize:
//----------------------------------------------------------------------------------------

Size TCarbonPrintJob::TotalSize(bool justLocked) const
{
	FlattenSettingsAndFormat();		// Just in case they've been changed.
	Size	theTotalSize = GetHandleSizeIfLocked(fPrintSettingsFlat.get(), justLocked);
	theTotalSize += GetHandleSizeIfLocked(fPageFormatFlat.get(), justLocked);
	return theTotalSize;
}

//----------------------------------------------------------------------------------------
// TCarbonPrintJob::SetPrintIdleProc: 
//----------------------------------------------------------------------------------------

void TCarbonPrintJob::SetPrintIdleProc()
{
	static PMIdleUPP	sPrintIdleProc = NULL;
	if (!sPrintIdleProc)
		::ThrowIfNULL_AC(sPrintIdleProc = ::NewPMIdleUPP(TCarbonPrintJob::IdleProc));
	ThrowIfBadOSStatus_AC(::PMSetIdleProc(sPrintIdleProc));
}

//----------------------------------------------------------------------------------------
// End of UCarbonPrinting.cpp

