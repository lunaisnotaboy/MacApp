//----------------------------------------------------------------------------------------
// UTabbedView.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		08/16/01	Make sure the document reference is carried through the tab pane. 
		06/05/01	Calculation of container view location in CreateContainerView
					should be based upon the tab view's QD offset.
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		11/13/00	[PB] Suppress GCC warnings about unused return variables. 
		10/13/00	Need to include stdio. 
		10/10/00	Add code to detect if there are problems with the clip for the 
					tab control. Added fixes to TDispatcher and TWindow so the 
					workaround here is no longer necessary. 
					Reuse the panel container view created by Ad Lib if it can be 
					found. Don't create the panel container view more than once. 
					Give each tab pane an identifier based on its view resource id. 
		10/04/00	Change the workaround to update the window instead of redrawing
					the control. Fixes problem with tab not highlighting properly
					in response to a mouse click. 
		10/03/00	Don't do mouse tracking in an inactive tabs control; otherwise
					it becomes active. 
		10/02/00	Updated comments. 
					Fix InstallPanel to use the view resource name only for new tabs. 
					InstallPanel now can be used to create a new tab. 
		09/27/00	Provide control over when the panes are installed. 
		09/26/00	Use a template list for the tab panes. 
					Add back GetTabPane and SetTabPane. 
					Install tab panes only when needed. 
					Move code for getting the actual tab label from AddPanel down
					into InstallPanel, so it will always be executed. 
					Redraw just the toolbox control instead of the view. 
		09/26/00	Work around Carbon tab control sometimes not updating
					properly after we show a tab panel. 
		09/22/00	Improved graphics device iterator. 
		09/01/00	Stripped dead code.  Added pragma unused.  Cosmetic.
		08/09/00	Added a cautionary note to TTabbedView::CreateContainerView about
					use of sizer behaviors.
		07/14/00	Don't emulate for now in TTabPane::DoMakeControl.
		07/12/00	Don't ApplyThemeBackground in Focus if no fPanelContainerView.
					Offset container view with SuperViewToLocal in CreateContainerView.
					Stripped out deprecated code: Close, BeInSuperView, Activate.  Moved
					empty dtor into .h.
		07/07/00	Changed to not attach and detach tab panes.  Removed SetPanelView
					and GetPanelView since no longer needed.  Removed tabbedView parm
					of AssertTabResource.  Made AssertTabResource and AssertOneBasedIndex
					static functions of TTabbedView.  Renamed GetActivePanelView to
					GetActiveTabPane and fActivePanelView to fActivePane.  Simplified
					FindPanelSubView.
		07/06/00	Added TTabPane.  Removed Inherited.  Other cosmetic cleanup.
		06/29/00	Use GetResInfo instead of reverse mapping in AddPanel.
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Include CMultiLocal.h.
		06/06/00	[2477959] Took out tabInfo.Version setting found in GetTabInfo.
		12/27/99	Cosmetic cleanup.
		12/08/99	Added assertion in DoMouseCommand.
		12/10/99	2285553:TTabbedView::GetTabInfo: whichTab is 1…n, so comparision
					should be '<=', not '<'.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		03/02/99	[2306528] Allow tab resource to get remapped if necessary in DoMakeControl.
		11/16/98	[2284744] Change assignment in SetTabLabel.  Emulate tabs if
					AppearanceMgrVersion_AC() < 0x0102 in TTabbedView:: and
					TSmallTabbedView::DoMakeControl.
		11/16/98	[2284720] Initialize tabInfo version in GetTabInfo.
		10/12/98	ApplyThemeBackground is PowerPC only.
*/

#ifndef __UTABBEDVIEW__
#include "UTabbedView.h"
#endif

#if qAppearance || qEmulateStandardControls

// MacApp

#ifndef __UAPPLICATION__
#include "UApplication.h"
#endif

#ifndef __UEDITTEXT__
#include "UEditText.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

// ACS

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

// Toolbox

#ifndef __APPEARANCE__
#include <Appearance.h>
#endif

// ANSI

#ifndef _STDIO_H
#include <stdio.h>
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUTabbedView
//----------------------------------------------------------------------------------------

void InitUTabbedView()
{
	static bool UTabbedViewInitialized;

	if (!UTabbedViewInitialized)
	{
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TTabbedView, kStdTabbedView);
			REGISTER_SIGNATURE_AC(TSmallTabbedView, kStdSmallTabbedView);
		}
		UTabbedViewInitialized = true;
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::AssertTabResource
//----------------------------------------------------------------------------------------

void TTabbedView::AssertTabResource(SInt16 labelsID)
{
	// If there is no tab# resource and one is expected, throw an exception now.
	// Also see if the user forgot to change the type of their STR# resource to tab#.
	if (labelsID)
	{
		SInt16**	stringListHandle = (SInt16**) CMultiLocale_AC::GetResource(kControlTabListResType, labelsID);
		if (!stringListHandle)
		{
#if qDebug
			stringListHandle = (SInt16**) CMultiLocale_AC::GetResource('STR#', labelsID);
			if (stringListHandle)
				ProgramReport_AC("AssertTabResource: Found STR# instead of tab# resource, type must be changed to tab#.");
#endif
			ThrowError_AC(resNotFound);
		}
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::AssertOneBasedIndex
//----------------------------------------------------------------------------------------

void TTabbedView::AssertOneBasedIndex(SInt16 tabIndex)
{
	// Install the specified View resource onto the specified existing tab.
	if (tabIndex == 0)
	{
#if qDebug
		ProgramReport_AC("Indexing of panels has changed from 0-based to 1-based.  Please change calls to InstallPanel to use 1-based tabIndex parameters.");
#endif
		ThrowError_AC(paramErr);
	}
}

//========================================================================================
// CLASS TTabbedView
//========================================================================================

MA_DEFINE_CLASS(TTabbedView);

//----------------------------------------------------------------------------------------
// TTabbedView constructor
//----------------------------------------------------------------------------------------

TTabbedView::TTabbedView(const CViewPoint&		itsLocation,
						 const CViewPoint&		itsSize,
						 SizeDeterminer			itsHSizeDet,
						 SizeDeterminer			itsVSizeDet,
						 const CTextStyle_AC&	itsTextStyle,
						 ResNumber				itsLabelsID)
	:	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, kEmptyString_AC, itsTextStyle),
		fPanelContainerView(NULL),
		fActiveTabPane(NULL),
		fPanelList(),
		fLabelsID(itsLabelsID)
{
	// For procedural post-initialization, call HandlePostCreate.
}

//----------------------------------------------------------------------------------------
// TTabbedView copy constructor
//----------------------------------------------------------------------------------------

TTabbedView::TTabbedView(const TTabbedView& inTabbedView)
	:	TCtlMgr(inTabbedView),
		fPanelContainerView(NULL),
		fActiveTabPane(NULL),
		fPanelList(),
		fLabelsID(inTabbedView.fLabelsID)
{
	// !!! No panels will be copied by the copy constructor.
	// The caller must iterate and clone panels after giving this view a window.
}

//----------------------------------------------------------------------------------------
// TTabbedView::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TTabbedView::GetStandardSignature() const
{
	return kStdTabbedView;
}

//----------------------------------------------------------------------------------------
// TTabbedView::ReadFields:
//----------------------------------------------------------------------------------------

void TTabbedView::ReadFields(CStream_AC* aStream)
{
	TCtlMgr::ReadFields(aStream);

	*aStream >> fLabelsID;
}

//----------------------------------------------------------------------------------------
// TTabbedView::WriteFields:
//----------------------------------------------------------------------------------------

void TTabbedView::WriteFields(CStream_AC* aStream) const
{
	TCtlMgr::WriteFields(aStream);

	*aStream << fLabelsID;
}

//----------------------------------------------------------------------------------------
// TTabbedView::SetupBackgroundColor:
//----------------------------------------------------------------------------------------

void TTabbedView::SetupBackgroundColor()
{
	// This configures the background color for the container view.
	TDrawingEnvironment* drawingEnvironment = fPanelContainerView->GetDrawingEnvironment();
	if (drawingEnvironment)
	{
		drawingEnvironment->fBackgroundColor = kRGBColorRamp[r1];
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::Focus:
//----------------------------------------------------------------------------------------

bool TTabbedView::Focus()
{
	bool didFocus = TCtlMgr::Focus();
#if qPowerPC
	if (didFocus && AppearanceMgrVersion_AC() >= 0x110 && fPanelContainerView)
	{
		CGraphicsDevice_AC mainDevice(CGraphicsDevice_AC::Main());
		OSStatus err = ::ApplyThemeBackground(kThemeBackgroundTabPane, fPanelContainerView->GetQDExtent(),
											  IsActive() ? kThemeStateActive : kThemeStateInactive,
											  mainDevice.Depth(), mainDevice.IsColor());
#if qProjectBuilder
		(void) err;
#endif
	}
#endif

	return didFocus;
}

//----------------------------------------------------------------------------------------
// TTabbedView::CreateControl
//----------------------------------------------------------------------------------------

void TTabbedView::CreateControl()
// CreateControl makes the Toolbox control which we wrap, creates the container view that
// holds the individual panes controlled by our tabs.
{
	fTextStyle.Normalize(gSystemStyle.tsFont, gApplicationStyle.tsFont);

	TCtlMgr::CreateControl();

	CreateContainerView();

	// Tabs have to erase when drawing, so make sure that
	// it doesn't assume we're on a gray background.

	if (AppearanceMgrVersion_AC() < 0x110 && !fPanelContainerView->GetDrawingEnvironment())
	{
		TDrawingEnvironment* drawingEnvironment = fPanelContainerView->DoMakeNewDrawingEnvironment();
		fPanelContainerView->SetDrawingEnvironment(drawingEnvironment, kDontInvalidate);
		SetupBackgroundColor();
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TTabbedView::DoMakeControl(WindowRef			theWindow,
										const CRect_AC&		boundsRect,
										bool				isVisible,
										bool				isEnabled,
										const CStr255_AC&	itsTitle)
{
	#pragma unused (itsTitle)

	ResNumber	labelsID(fLabelsID);
	if (labelsID)
		labelsID = CMultiLocale_AC::GetExistingResourceID('tab#', fLabelsID);
	AssertTabResource(labelsID);

#if qEmulateStandardControls
	if (EmulateControls_AC() || AppearanceMgrVersion_AC() < 0x0102)
		return TH_new CTabbedView_AC(boundsRect, isEnabled, fTextStyle, labelsID, 0, 0, true, kControlTabNorth_AC);
	else
#endif
		return CreateTabs_AC(theWindow, boundsRect, isVisible, isEnabled, labelsID, 0, 0, true, kControlTabNorth_AC);
}

//----------------------------------------------------------------------------------------
// TTabbedView::CreateContainerView
//----------------------------------------------------------------------------------------

void TTabbedView::CreateContainerView()
// CreateContainerView creates a generic TView that is used to hold the individual tab
// panes and then creates those tab panes according to the current maximum
// value of the control (which happens to be the number of tabs).
//
// Call:		Never.  CreateContainerView is part of the TTabbedView initialization
//				process and is called by TTabbedView::CreateControl.
// Override:	Unlikely.  Override only if some additional special initialization of
//				the container view is required.
{
	if (!fPanelContainerView)
	{
		// Create a subview to contain the panels that we load and unload.
		// Use the control to specify the container view's frame.
		CViewRect viewFrame(GetContentRect());
		viewFrame += GetViewToQDOffset();

		fPanelContainerView = FindSubView('    ');
		if (fPanelContainerView)
		{
			fPanelContainerView->SetFrame(viewFrame, kDontInvalidate);
			fPanelContainerView->SetSizeDeterminer(hSel, GetSizeDeterminer(hSel));
			fPanelContainerView->SetSizeDeterminer(vSel, GetSizeDeterminer(vSel));
		}
		else
		{
			// •••  NOTE: Since the following relies on size determiners then any use of TSizers
			// connected to this view will not result in the desired behavior.
			fPanelContainerView = TH_new TView(viewFrame[topLeft], viewFrame.GetSize(), GetSizeDeterminer(hSel), GetSizeDeterminer(vSel));
			AddSubView(fPanelContainerView);
		}
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::Draw
//----------------------------------------------------------------------------------------

void TTabbedView::Draw(const CViewRect& area)
{
	// Let the CControl_AC draw itself.

	TCtlMgr::Draw(area);

	// Set the background color so that any subviews
	// that erase their background without assuming a color
	// will use our current tab panel color.
	if (AppearanceMgrVersion_AC() < 0x110)
		kRGBColorRamp[r1].SetBackColor();
}

//----------------------------------------------------------------------------------------
// TTabbedView::DoMouseCommand
//----------------------------------------------------------------------------------------

void TTabbedView::DoMouseCommand(CViewPoint& theMouse, TToolboxEvent* event, CPoint_AC hysteresis)
{
	#pragma unused (hysteresis)

	CControl_AC* control = GetControl();
	Assertion_AC(control, "TTabbedView::DoMouseCommand: Could not get control ref.");
	
	// Track the mouse only if the control is active. 
	// By default, we give controls the mouse click, and trust them to do the right thing. 
	// But the tabs control resets its contrlHilite state on returning from 
	// HandleControlClick, which has the side effect of activating the control. 
	// That's bad, so we need this special case to prevent it. We know that an inactive 
	// tabs control is not going to do anything with a mouse click, so it's okay to
	// keep it in the dark. 
	if (control->IsActive())
	{
#if 0 && qCarbon
		// This code detects if the view's clip region doesn't match its visible
		// region. The Carbon tab control was sometimes not updating correctly,
		// because the clip was sometimes covering only the panel area and
		// not including the tabs. 
		{
			GrafPtr port = GetGrafPtr_AC();
			CTempRegion_AC extent(GetQDExtent());
			CTempRegion_AC visRgn;
			GetPortVisibleRegion(port, visRgn);
			CTempRegion_AC clipRgn;
			GetPortClipRegion(port, clipRgn);
			if ((clipRgn & extent) != (visRgn & extent))
			{
#if qDebugMsg
				ProgramReport_AC("\n*** TTabbedView::DoMouseCommand clip is whacked\n");
#endif
				// Force rebuilding the clip for this view. 
				// This workaround is no longer necessary because there is
				// a better fix in TDispatcher and TWindow. 
				//InvalidateFocus();
				//Focus();
			}
		}
#endif
		// Let the CControl_AC track the mouse; if tracking succeeds
		// handle our event number.

		SInt32 oldTabIndex = GetValue();

		ControlPartCode partHit;
		{
			CWhileFocused itsWhileFocused(this, kRedraw);
			partHit = control->TrackMouse(ViewToQD(theMouse), event->GetModifiers());
		}
		if (partHit)
			HandleTabSwitch(oldTabIndex, GetValue());
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::SwitchPanels
//----------------------------------------------------------------------------------------

void TTabbedView::SwitchPanels(SInt32 newTabIndex)
{
	// Switch to the specified tab index.
	SetValue(newTabIndex, kDontRedraw);

	bool containedTarget = SwitchPanelOut();
	SwitchPanelIn(newTabIndex, containedTarget);
}

//----------------------------------------------------------------------------------------
// TTabbedView::HandleTabSwitch
//----------------------------------------------------------------------------------------

void TTabbedView::HandleTabSwitch(SInt32 oldTabIndex, SInt32 newTabIndex)
{
	// If it's OK to switch tabs (may need to validate current
	// panel before switching), do the switch.

	if (newTabIndex != oldTabIndex)
	{
		if (ValidatePanel(oldTabIndex))
		{
			SwitchPanels(newTabIndex);
			HandleEvent(fEventNumber, this, NULL);
		}
		else
		{
			// Validation failed.  Set the value back to previous, and redraw.
			SetValue(oldTabIndex, kDontRedraw);
			ForceRedraw();
		}
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::AddPanel
//----------------------------------------------------------------------------------------

void TTabbedView::AddPanel(SInt16 panelResourceID, StringPtr tabLabel, bool immediate)
// AddPanel adds a new tab and its pane to the end of this tabbed view.
//
// panelResourceID:	The resource number of a 'View' resource which contains the
//					view which is to be shown under this tab.
// tabLabel:		A pointer to a string which contains the label to be placed
//					on the new tab.  If the pointer is NULL then use the name
//					of the view resource.
//
// Call:			Either call this or InstallPanel.  Call this if you don't care
//					about the position of the newly added tab; it will get added at
//					the end.
// Override:		Never.
{
	// Create another tab and then install the specified View resource
	// onto that tab.

	// Add the panel now by incrementing the tab count and making a tab pane.
	SInt32 numTabs = GetMaximum();

	// Instantiate the contents of the tab pane.
	InstallPanel(numTabs + 1, panelResourceID, tabLabel, immediate);
}

//----------------------------------------------------------------------------------------
// TTabbedView::InstallPanel
//----------------------------------------------------------------------------------------

void TTabbedView::InstallPanel(SInt32 tabIndex, SInt16 panelResourceID, StringPtr tabLabel,
							   bool immediate)
// InstallPanel retrieves a view resource and attaches it to the indicated existing tab
// by making it a subview of the tab's existing pane. If there already was a panel view
// for the tab, the old view will be deleted. 
//
// tabIndex:		The 1-based index number of an existing tab for which the specified
//					view resource is to be attached. If it is 1 more than the current
//					number of tabs, a new tab will be added. 
// panelResourceID:	The resource number of a 'View' resource which contains the
//					view which is to be shown under this tab. 
// tabLabel:		A pointer to a string which contains the label to be placed
//					on the new tab. If the pointer is NULL, then if a new tab is being
//					added, then use the name of the view resource, otherwise the
//					existing tab is left untouched.
//
// Call:			Either call this or AddPanel.  Call this if the tabbed view's
//					maximum control value has already been set to at least tabIndex and
//					you simply want to install a new view for the tab, possibly over an
//					existing view.  It's just as safe to call AddPanel which will make
//					sure there are enough tabs.
// Override:		Never.
{
	AssertOneBasedIndex(tabIndex); // this function changed from being 0-based to 1-based.

	SInt32 numTabs = GetMaximum();

	if (tabIndex == numTabs + 1)
	{
		SetMaximum(tabIndex, kRedraw);
		numTabs = tabIndex;

		// If we're not provided a tab label string, use the view resource name.
		if (!tabLabel)
		{
			Handle viewHandle = CMultiLocale_AC::GetResource('View', panelResourceID);
			::ThrowIfNULL_AC(viewHandle);

			SInt16 viewID;
			OSType viewType;
			CStr255_AC actualTabLabel;
			::GetResInfo(viewHandle, &viewID, &viewType, actualTabLabel);

			SetTabLabel(tabIndex, actualTabLabel, kRedraw);

			// Don't release it -- we're about to cause it to be read anyway.
		}
	}
	
	if (tabIndex <= numTabs)
	{
		if (tabLabel)
			SetTabLabel(tabIndex, tabLabel, kRedraw);

		TTabPane* aPanelView = GetTabPane(tabIndex);
		if (aPanelView)
		{
			SetTabPane(tabIndex, NULL);
			DeleteTabPane(aPanelView, kInvalidate);
		}

		aPanelView = AddTabPane(panelResourceID);
		SetTabPane(tabIndex, aPanelView);

		if (immediate)
			aPanelView->Install();

		// If this panel corresponds to the initial value, switch it in.
		if (GetValue() == tabIndex)
			SwitchPanels(tabIndex);
		else
			aPanelView->Show(false, kDontRedraw);
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::RemoveTab
//----------------------------------------------------------------------------------------

void TTabbedView::RemoveTab(SInt32 tabIndex, bool redraw)
// RemoveTab removes the specified tab and deletes the panel view
// associated with it. If you want to save the panel view, call
// GetTabPane and remove its subviews before removing the tab. 
// You are responsible for switching tabs *beforehand* if you are
// removing the currently selected tab. Note: tabIndex is 1-based.
{
	AssertOneBasedIndex(tabIndex); // this function changed from being 0-based to 1-based.

	// Remove the specified tab from the AGA object.

	// Remove the tab's panel if it's in the list
	if (tabIndex <= fPanelList.GetSize())
	{
		// Also delete the panel view if it isn't installed
		TTabPane* aPanelView = fPanelList.At(tabIndex);
		fPanelList.AtDelete(tabIndex);
		DeleteTabPane(aPanelView, kDontInvalidate);
	}

	SInt16 numTabs = GetMaximum();
	for (short i = tabIndex + 1; i <= numTabs; ++i)
	{
		// Scootch labels and tab enables
		SetTabInfo(i - 1, GetTabInfo(i), kDontRedraw);
		SetTabEnable(i - 1, IsTabEnabled(i), kDontRedraw);
	}
	SetMaximum(numTabs - 1, kDontRedraw);

	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TTabbedView::GetTabPane
//----------------------------------------------------------------------------------------

TTabPane* TTabbedView::GetTabPane(SInt32 tabIndex)
{
	AssertOneBasedIndex(tabIndex); // this function changed from being 0-based to 1-based.

	TTabPane* panel = NULL;

	if (tabIndex > 0 && tabIndex <= fPanelList.GetSize())
		panel = fPanelList.At(tabIndex);
	
	return panel;
}

//----------------------------------------------------------------------------------------
// TTabbedView::GetContentRect
//----------------------------------------------------------------------------------------

CRect_AC TTabbedView::GetContentRect() const
{
	return GetControl() ? GetControl()->GetTabContentRect() : CRect_AC::kZeroRect;
}

//----------------------------------------------------------------------------------------
// TTabbedView::IsTabEnabled
//----------------------------------------------------------------------------------------

bool TTabbedView::IsTabEnabled(SInt16 whichPanel) const
{
	return GetControl() ? GetControl()->GetTabEnable(whichPanel) : false;
}

//----------------------------------------------------------------------------------------
// TTabbedView::SetTabEnable
//----------------------------------------------------------------------------------------

void TTabbedView::SetTabEnable(SInt16 whichPanel, bool isEnabled, bool redraw)
{
	if (GetControl())
	{
		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetTabEnable(whichPanel, isEnabled);

		// ??? Propagate to the views?
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::GetTabInfo
//----------------------------------------------------------------------------------------

ControlTabInfoRec TTabbedView::GetTabInfo(SInt16 whichPanel) const
{
	ControlTabInfoRec tabInfo;
	if (GetControl() && whichPanel <= fPanelList.GetSize())
	{
		tabInfo = GetControl()->GetTabInfo(whichPanel);
	}
	else
	{
		tabInfo.version = kControlTabInfoVersionZero;
		tabInfo.iconSuiteID = 0;
		tabInfo.name[0] = 0;
	}
	return tabInfo;
}

//----------------------------------------------------------------------------------------
// TTabbedView::SetTabInfo
//----------------------------------------------------------------------------------------

void TTabbedView::SetTabInfo(SInt16 whichPanel, const ControlTabInfoRec& tabInfo, bool redraw)
{
	if (GetControl())
	{
#if qDebug
		if (tabInfo.version != kControlTabInfoVersionZero)
		{
			ProgramReport_AC("SetTabInfo: version field is either uninitialized or unsupported.");
		}
#endif

		CWhileFocused itsWhileFocused(this, redraw);
		GetControl()->SetTabInfo(whichPanel, tabInfo);
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::GetTabLabel
//----------------------------------------------------------------------------------------

CStr255_AC TTabbedView::GetTabLabel(SInt16 whichPanel) const
{
	ControlTabInfoRec tabInfo = GetTabInfo(whichPanel);
	return tabInfo.name;
}

//----------------------------------------------------------------------------------------
// TTabbedView::SetTabLabel
//----------------------------------------------------------------------------------------

void TTabbedView::SetTabLabel(SInt16 whichPanel, const CStr255_AC& tabLabel, bool redraw)
{
	ControlTabInfoRec tabInfo = GetTabInfo(whichPanel);
	reinterpret_cast<CStr255_AC&>(tabInfo.name) = tabLabel;
	SetTabInfo(whichPanel, tabInfo, redraw);
}

//----------------------------------------------------------------------------------------
// TTabbedView::ValidatePanel
//----------------------------------------------------------------------------------------

bool TTabbedView::ValidatePanel(SInt32 currentTabIndex)
{
	#pragma unused (currentTabIndex)

	// (Override for app-specific validation.)
	//
	// Return true if the current (specified) panel is valid and
	// it's OK to switch to a different panel. Return false otherwise
	// and the tab switch will not occur; it's OK to alert the user
	// of the invalid data before returning.

	return true;
}

//----------------------------------------------------------------------------------------
// TTabbedView::SwitchPanelOut
//----------------------------------------------------------------------------------------

bool TTabbedView::SwitchPanelOut()
// SwitchPanelOut makes the current pane inactive by hiding its associated user pane (which
// happens to be a tab pane).
{
	// Yank the current panel view hierarchy out of the container view.

	TWindow*		window = GetWindow();
	TEventHandler*	currentTarget = GetTarget();
	bool			panelContainedTarget = (currentTarget == NULL) ||
										   (currentTarget == window) ||
										   (currentTarget == gApplication);

	if (fActiveTabPane != NULL)
	{
		if (currentTarget)
		{
			TView* currentTargetView = dynamic_cast_AC(TView*, currentTarget);
			if (currentTargetView && fActiveTabPane->ContainsSubView(currentTargetView))
			{
				panelContainedTarget = true;
				if (window)
				{
					window->BecomeTarget();
					window->SetWindowTarget(NULL);
				}
			}
		}

		fActiveTabPane->Show(false, kRedraw);

		fActiveTabPane = NULL;
	}

	return panelContainedTarget;
}

//----------------------------------------------------------------------------------------
// TTabbedView::SwitchPanelIn
//----------------------------------------------------------------------------------------

void TTabbedView::SwitchPanelIn(SInt32 tabIndex, bool targetInPanel)
// SwitchPanelIn makes the desired tab pane the active pane by showing it.
{
	TTabPane* panel = GetTabPane(tabIndex);
	if (panel)
	{
		fActiveTabPane = panel;

		// Read in the panel's views if they haven't already been installed. 
		fActiveTabPane->Install();

		fActiveTabPane->Show(true, kRedraw);

		// Before redrawing, make the selection visible.
		if (targetInPanel)
		{
			TView* wannabeTarget = panel->FindTarget();
			if (wannabeTarget != NULL)
			{
				wannabeTarget->BecomeTarget();
				wannabeTarget->SetTargetSelection(kRedraw);
			}
		}
	}

	TMenuBarManager::InvalidateMenus();
}

//----------------------------------------------------------------------------------------
// TTabbedView::AddTabPane
//----------------------------------------------------------------------------------------

TTabPane* TTabbedView::AddTabPane(SInt16 panelResourceID)
// AddTabPane adds an empty tab pane to the tabbed view and its list of tab panes.  It
// also makes the new panel hidden.
//
// Call:		Never.
// Override:	Never.
{
	CViewPoint	viewTopLeft(0, 0);
	CViewPoint	viewSize(GetContentRect().GetSize());
	TTabPane*	aTabPane = TH_new TTabPane(viewTopLeft,
										   viewSize,
										   GetSizeDeterminer(hSel),
										   GetSizeDeterminer(vSel),
										   panelResourceID);
	::ThrowIfNULL_AC(aTabPane);
	{
		char idString[16];
		SInt16 idNumber = panelResourceID % 1000;
		sprintf(idString, "¶%03d", idNumber);
		IDType identifier = *(IDType*)&idString;
		aTabPane->SetIdentifier(identifier);
	}
	fPanelContainerView->AddSubView(aTabPane);
	aTabPane->HandlePostCreate(fDocument);

	return aTabPane;
}

//----------------------------------------------------------------------------------------
// TTabbedView::DeleteTabPane
//----------------------------------------------------------------------------------------

void TTabbedView::DeleteTabPane(TTabPane* panel, bool invalidate)
{
	if (panel)
	{
		if (fActiveTabPane == panel)
			fActiveTabPane = NULL;

		if (invalidate)
			panel->ForceRedraw();

		fPanelContainerView->RemoveSubView(panel);
		panel->Close();
		panel->BeInPort(NULL);
		delete panel;
	}
}

//----------------------------------------------------------------------------------------
// TTabbedView::SetTabPane
//----------------------------------------------------------------------------------------

void TTabbedView::SetTabPane(SInt32 tabIndex, TTabPane* panel)
{
	// Tabs may not be set in order, so insert NULL entries in the list
	while (fPanelList.GetSize() < tabIndex)
		fPanelList.InsertLast(NULL);

	// Update the entry for this tab
	fPanelList.AtPut(tabIndex, panel);
}

//----------------------------------------------------------------------------------------
// TTabbedView::FindPanelSubView
//----------------------------------------------------------------------------------------

TView* TTabbedView::FindPanelSubView(IDType itsIdentifier) const
{
	return fPanelContainerView->FindSubView(itsIdentifier);
}

//========================================================================================
// CLASS TSmallTabbedView
//========================================================================================

MA_DEFINE_CLASS(TSmallTabbedView);

//----------------------------------------------------------------------------------------
// TSmallTabbedView::TSmallTabbedView
//----------------------------------------------------------------------------------------

TSmallTabbedView::TSmallTabbedView(	const CViewPoint&		itsLocation,
									const CViewPoint&		itsSize,
									SizeDeterminer			itsHSizeDet,
									SizeDeterminer			itsVSizeDet,
							    	const CTextStyle_AC&	itsTextStyle,
							    	ResNumber				itsLabelsID)
	:	TTabbedView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTextStyle, itsLabelsID)
{
}

//----------------------------------------------------------------------------------------
// TSmallTabbedView copy constructor
//----------------------------------------------------------------------------------------

TSmallTabbedView::TSmallTabbedView(const TSmallTabbedView& inTSmallTabbedView)
	:	TTabbedView(inTSmallTabbedView)
{
	// !!! No panels will be copied by the copy constructor.
	// The caller must iterate and clone panels after giving this view a window.
}

//----------------------------------------------------------------------------------------
// TSmallTabbedView::~TSmallTabbedView
//----------------------------------------------------------------------------------------

TSmallTabbedView::~TSmallTabbedView()
{
}

//----------------------------------------------------------------------------------------
// TSmallTabbedView::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TSmallTabbedView::GetStandardSignature() const
{
	return kStdSmallTabbedView;
}

//----------------------------------------------------------------------------------------
// TSmallTabbedView::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TSmallTabbedView::DoMakeControl(WindowRef			theWindow,
											 const CRect_AC&	boundsRect,
											 bool				isVisible,
											 bool				isEnabled,
											 const CStr255_AC&	itsTitle)
{
	#pragma unused (itsTitle)

	AssertTabResource(fLabelsID);

#if qEmulateStandardControls
	if (EmulateControls_AC() || AppearanceMgrVersion_AC() < 0x0102)
		return TH_new CTabbedView_AC(boundsRect, isEnabled, fTextStyle, fLabelsID, 0, 0, false, kControlTabNorth_AC);
	else
#endif
		return CreateTabs_AC(theWindow, boundsRect, isVisible, isEnabled, fLabelsID, 0, 0, false, kControlTabNorth_AC);
}

//========================================================================================
// CLASS TTabPane
//========================================================================================

//----------------------------------------------------------------------------------------
// TTabPane constructor
//----------------------------------------------------------------------------------------

TTabPane::TTabPane(const CViewPoint& itsLocation,
				   const CViewPoint& itsSize,
				   SizeDeterminer itsHSizeDet,
				   SizeDeterminer itsVSizeDet,
				   SInt16 panelResourceID)
	:	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
		fPanelResourceID(panelResourceID)
{
}

//----------------------------------------------------------------------------------------
// TTabPane copy constructor
//----------------------------------------------------------------------------------------

TTabPane::TTabPane(const TTabPane& inTTabPane)
	:	TCtlMgr(inTTabPane),
		fPanelResourceID(kNoResource_AC)
{
}

//----------------------------------------------------------------------------------------
// TTabPane::SetPanelResourceID
//----------------------------------------------------------------------------------------

void TTabPane::SetPanelResourceID(SInt16 panelResourceID)
{
	fPanelResourceID = panelResourceID;
}

//----------------------------------------------------------------------------------------
// TTabPane::Install
//----------------------------------------------------------------------------------------

void TTabPane::Install()
{
	if ((CountSubViews() == 0) && (fPanelResourceID != kNoResource_AC))
	{
		// Wrap the DoCreateViews with custom color values so that the
		// AGA objects in the panel hierarchy will get the right background colors.

		MControlBackground_AC::TurnOnCustomBackgroundColors(kRGBColorRamp[r1], kRGBColorRamp[r1 /*r2*/]);

		TView* newPanelView = TViewServer::fgViewServer->DoCreateViews(fDocument, this, fPanelResourceID, gZeroVPt);
		::ThrowIfNULL_AC(newPanelView);

		MControlBackground_AC::TurnOffCustomBackgroundColors();
	}
}

//----------------------------------------------------------------------------------------
// TTabPane::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TTabPane::DoMakeControl(WindowRef theWindow,
									 const CRect_AC& boundsRect,
									 bool isVisible,
									 bool isEnabled,
									 const CStr255_AC& itsTitle)
{
	#pragma unused (itsTitle)

	return CreateUserPane_AC(theWindow, boundsRect, isVisible, isEnabled);
		// User panes can embed by default.
}

#endif // qAppearance || qEmulateStandardControls


//----------------------------------------------------------------------------------------
// End of UTabbedView.cpp
