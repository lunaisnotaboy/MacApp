//----------------------------------------------------------------------------------------
// UTargetBorderView.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/11/00	Cosmetic.  Eliminated Inherited.
		12/08/99	Fixed file name in banner.
		09/07/00	Added embedded documentation - TTargetBorderView::ComputeBorderRegion.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					PaintRgn_AC.  Include ImagingUtils_AC.h.
*/

#ifndef __UTARGETBORDERVIEW__
#include "UTargetBorderView.h"
#endif

// ACS

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

// MacApp

#ifndef __UCOREGLOBALS__
#include "UCoreGlobals.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

void InitUTargetBorderView()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TTargetBorderView, kStdTargetBorderView);
	}
}

//========================================================================================
// CLASS TTargetBorderView
//========================================================================================

MA_DEFINE_CLASS(TTargetBorderView);

//----------------------------------------------------------------------------------------
// TTargetBorderView constructor
//----------------------------------------------------------------------------------------

TTargetBorderView::TTargetBorderView(const CViewPoint&	itsLocation,
									 const CViewPoint&	itsSize,
									 SizeDeterminer		itsHSizeDet,
									 SizeDeterminer		itsVSizeDet,
									 IDType				itsTargetView)
	:	TView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
		fTargetView(itsTargetView)
{
	fActiveHL = hlOff;	 			// Gets turned on when a subview becomes the target
	fInactiveHL = hlOff; 			// Don't do dim highlighting
}

//----------------------------------------------------------------------------------------
// TTargetBorderView destructor
//----------------------------------------------------------------------------------------

TTargetBorderView::~TTargetBorderView()
{
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::GetStandardSignature:
//----------------------------------------------------------------------------------------

IDType TTargetBorderView::GetStandardSignature() const
{
	return kStdTargetBorderView;
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::ReadFields:
//----------------------------------------------------------------------------------------

void TTargetBorderView::ReadFields(CStream_AC* aStream)
{
	TView::ReadFields(aStream);

	fTargetView = aStream->ReadIDType();
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::WriteFields:
//----------------------------------------------------------------------------------------

void TTargetBorderView::WriteFields(CStream_AC* aStream) const
{
	TView::WriteFields(aStream);
	aStream->WriteIDType(fTargetView);
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::DoEvent:
//----------------------------------------------------------------------------------------

void TTargetBorderView::DoEvent(EventNumber		eventNumber,
								TEventHandler*	source,
								TEvent*			event)
{
	switch (eventNumber)
	{
		case mBecameTarget:
			if (ContainsTarget(source))
			{
				InvalidateBorderRegion();
			}
			TView::DoEvent(eventNumber, source, event);
			break;
		case mResignedTarget:
			if (ContainsTarget(source))
			{
				InvalidateBorderRegion();
			}
			TView::DoEvent(eventNumber, source, event);
			break;

		default:
			TView::DoEvent(eventNumber, source, event);
			break;
	}
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::DoMouseCommand:
//----------------------------------------------------------------------------------------

void TTargetBorderView::DoMouseCommand( CViewPoint& 	theMouse,
										TToolboxEvent* 	event,
										CPoint_AC		hysteresis)
{
	#pragma unused (theMouse, event, hysteresis)

	TView *targetView = FindSubView(fTargetView);
	if (targetView && targetView->IsEnabled() && targetView->WantsToBeTarget())
		targetView->BecomeTarget();
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::ComputeBorderRegion:
//----------------------------------------------------------------------------------------

void TTargetBorderView::ComputeBorderRegion(RgnHandle borderRegion)
// ComputeBorderRegion calculates the border area and stores the area in the
// borderRegion parameter.
//
// borderRegion:	Specifies the border region.
//
// Call?		Seldom.
// Override?	Seldom.
{
	CRect_AC QDArea(GetQDExtent());
	RectRgn(borderRegion, &QDArea);
	QDArea.Inset(2, 2);

	CTempRegion_AC innerRegion;
	RectRgn(innerRegion, &QDArea );
	DiffRgn(borderRegion, innerRegion, borderRegion);
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::InvalidateBorderRegion:
//----------------------------------------------------------------------------------------

void TTargetBorderView::InvalidateBorderRegion()
{
	CTempRegion_AC borderRegion;

	ComputeBorderRegion(borderRegion);
	Invalidate(borderRegion);
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::Draw:
//----------------------------------------------------------------------------------------

void TTargetBorderView::Draw(const CViewRect& /*area*/)
{
	if (ContainsTarget(GetTarget()))
	{
		CTempRegion_AC borderRegion;

		ComputeBorderRegion(borderRegion);
		::MacPaintRgn(borderRegion);
	}
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::SetFrame:
//----------------------------------------------------------------------------------------

void TTargetBorderView::SetFrame(const CViewRect& newFrame, bool invalidate)
{
	// make sure the entire old frame is invalidated
	if (invalidate)
		InvalidateBorderRegion();

	TView::SetFrame(newFrame, invalidate);

	// make sure the entire new frame is invalidated
	if (invalidate)
		InvalidateBorderRegion();
}

//----------------------------------------------------------------------------------------
// TTargetBorderView::ContainsTarget:
//----------------------------------------------------------------------------------------

bool TTargetBorderView::ContainsTarget(TEventHandler *target)
{
	TEventHandler 	*localTarget = target;
	bool			containsTarget = false;

	while (localTarget && !containsTarget)
	{
		if (localTarget == this)
			containsTarget = true;
		localTarget = localTarget->GetNextHandler();
	}
	return containsTarget;
}

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitUTargetBorderView
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----

*/