//----------------------------------------------------------------------------------------
// USlider.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		11/13/00	[PB] Change initialization order to match declaration. 
					Default constructor was not initializing fields as documented. 
		11/04/00	TLabelsSlider is emulated, so it is not compatible with a
					toolbox slider. 
		03/20/00	[2446352] DoMakeControl provides live feedback for call
					to CreateSlider_AC().
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		07/26/99	Define the TLabelsSlider class.  Got rid of Inherited.
		03/24/99	Update copyright notice.
		03/02/99	[2306509] Pass fRightJustify to CreateSlider_AC.
*/

#ifndef __USLIDER__
#include "USlider.h"
#endif

#if qAppearance || qEmulateStandardControls

// ACS

#ifndef __CSlider_AC__
#include "CSlider_AC.h"
#endif

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

// MacApp

#ifndef __USTREAM__
#include "UStream.h"
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// Unit initialization
//----------------------------------------------------------------------------------------

void InitUSlider()
{
	static bool USliderInitialized;

	if (!USliderInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TSlider, kStdSlider);
		}
		USliderInitialized = true;
	}
}

#if qEmulateStandardControls

void InitULabelsSlider()
{
	static bool ULabelsSliderInitialized;

	if (!ULabelsSliderInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TLabelsSlider, kStdSlider);
		}
		ULabelsSliderInitialized = true;
	}
}

#endif


//========================================================================================
// CLASS TSlider
//========================================================================================

MA_DEFINE_CLASS(TSlider);

//----------------------------------------------------------------------------------------
// TSlider constructor
//----------------------------------------------------------------------------------------

TSlider::TSlider(const CViewPoint& itsLocation,
				 const CViewPoint& itsSize,
				 SizeDeterminer itsHSizeDet,
				 SizeDeterminer itsVSizeDet,
			     const CTextStyle_AC& itsTextStyle,
			     ResNumber itsLabelsID,
			     bool preferLiveFeedback)
	:	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, kEmptyString_AC, itsTextStyle),
		fLabelsID(itsLabelsID),
		fRightJustify(false),
		fInitialVal(0),
		fInitialMin(0),
		fInitialMax(0),
 		fInitialViewSize(0),
		fPreferLiveFeedback(preferLiveFeedback)
{
	// For procedural post-initialization, call HandlePostCreate.
}

//----------------------------------------------------------------------------------------
// TSlider copy constructor
//----------------------------------------------------------------------------------------

TSlider::TSlider(const TSlider& inSlider)
	:	TCtlMgr(inSlider),
		fLabelsID(inSlider.fLabelsID),
		fRightJustify(inSlider.fRightJustify),
		fInitialVal(inSlider.fInitialVal),
		fInitialMin(inSlider.fInitialMin),
		fInitialMax(inSlider.fInitialMax),
		fInitialViewSize(inSlider.fInitialViewSize),
		fPreferLiveFeedback(inSlider.fPreferLiveFeedback)
{
}

//----------------------------------------------------------------------------------------
// TSlider destructor
//----------------------------------------------------------------------------------------

TSlider::~TSlider()
{
}

//----------------------------------------------------------------------------------------
// TSlider::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TSlider::GetStandardSignature() const
{
	return kStdSlider;
}

//----------------------------------------------------------------------------------------
// TSlider::DoControlAction
//----------------------------------------------------------------------------------------

void TSlider::DoControlAction(ControlPartCode /*partCode*/)
{
	// Propagate our event number.
	
	HandleEvent(fEventNumber, this, NULL);

	(void) Focus();	// HandleEvent may have caused another view to draw
}

//----------------------------------------------------------------------------------------
// TSlider::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TSlider::DoMakeControl(WindowRef theWindow,
									const CRect_AC& boundsRect, 
									bool isVisible, bool isEnabled,
									const CStr255_AC& /*itsTitle*/)
		// Factory method instantiates the control.
{
	// Warning:
	// The native Appearance slider control will not display labels, so this
	// base class no longer supports the use of labels.  This class reuses the labels field
	// to indicate the pointer kind and tick marks.
	
	// If you wish to continue using labels, you may use the emulated-only control
	// class TLabelsSlider, by calling InitULabelsSlider instead of InitUSlider.
	
	// Proportional slider behavior is governed by the use of SetViewSize, e.g.,
	// if you call SetViewSize with a non-zero value, the slider will become proportional,
	// if the theme supports proportional indicators and the support is turned on.
	// This is in order to be consistent with the native Appearance slider control.
	
#if qEmulateStandardControls
	if (::EmulateControls_AC())
	{
		fTextStyle.Normalize(gSystemStyle.tsFont, gApplicationStyle.tsFont);
		return TH_new CSlider_AC(boundsRect, isEnabled, fInitialMin, fInitialMax, fInitialVal, 
									fInitialViewSize, fTextStyle, 
									fRightJustify ? teFlushRight : teFlushDefault, 
									0 /*fLabelsID no labels support in base class, use TLabelsSlider*/,
									fLabelsID == 0 /* pointer if has labels */,
									fPreferLiveFeedback, 
									fLabelsID != 0 /* tick marks if has labels */,
									true /* proportional */,
									false /* reverse direction */,
									this);
	}
	else
#endif
		return CreateSlider_AC(theWindow,
								boundsRect,
								isVisible, isEnabled, 
								fInitialVal, fInitialMin, fInitialMax,
								fInitialViewSize,
								fPreferLiveFeedback,
								fLabelsID != 0,		// Tick marks if has labels
								fRightJustify,		// Reverse direction
								fLabelsID == 0,		// Directional pointer if has labels;
													// non-directional otherwise.
								this);
}

//----------------------------------------------------------------------------------------
// TSlider::ReadFields
//----------------------------------------------------------------------------------------

void TSlider::ReadFields(CStream_AC* aStream)
{
	TCtlMgr::ReadFields(aStream);
	
	*aStream >> fLabelsID
			 >> fRightJustify
			 >> fInitialMin
			 >> fInitialMax
			 >> fInitialVal
			 >> fInitialViewSize;
}

//----------------------------------------------------------------------------------------
// TSlider::WriteFields
//----------------------------------------------------------------------------------------

void TSlider::WriteFields(CStream_AC* aStream) const
{
	TCtlMgr::WriteFields(aStream);
	
	*aStream << fLabelsID
			 << fRightJustify
			 << fInitialMin
			 << fInitialMax
			 << fInitialVal
			 << fInitialViewSize;
}

//----------------------------------------------------------------------------------------
// TSlider::SetPreferLiveFeedback
//----------------------------------------------------------------------------------------

void TSlider::SetPreferLiveFeedback(bool preferLiveFeedback)
{
	if (preferLiveFeedback != fPreferLiveFeedback)
	{
		fPreferLiveFeedback = preferLiveFeedback;
		
		if (GetControl())
		{
			// Save up the values before deleting control, then create a new one with
			// the saved values (and with the new fPreferLiveFeedback setting).
			fInitialMin = GetMin();
			fInitialMax = GetMax();
			fInitialVal = GetValue();
			fInitialViewSize = GetViewSize();
			DeleteControl();
			CreateControl();
		}
	}
}


#if qEmulateStandardControls

//========================================================================================
// CLASS TLabelsSlider
//========================================================================================

MA_DEFINE_CLASS(TLabelsSlider);

//----------------------------------------------------------------------------------------
// TLabelsSlider constructor
//----------------------------------------------------------------------------------------

TLabelsSlider::TLabelsSlider(const CViewPoint& itsLocation,
								 const CViewPoint& itsSize,
								 SizeDeterminer itsHSizeDet,
								 SizeDeterminer itsVSizeDet,
							     const CTextStyle_AC& itsTextStyle,
							     ResNumber itsLabelsID,
							     bool preferLiveFeedback) :
	TSlider(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, itsTextStyle, itsLabelsID, preferLiveFeedback)
{
	// For procedural post-initialization, call HandlePostCreate.
}

//----------------------------------------------------------------------------------------
// TLabelsSlider copy constructor
//----------------------------------------------------------------------------------------

TLabelsSlider::TLabelsSlider(const TLabelsSlider& inSlider) :
	TSlider(inSlider)
{
}

//----------------------------------------------------------------------------------------
// TLabelsSlider destructor
//----------------------------------------------------------------------------------------

TLabelsSlider::~TLabelsSlider()
{
}
	
//----------------------------------------------------------------------------------------
// TLabelsSlider::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TLabelsSlider::DoMakeControl(WindowRef /*theWindow*/,
									const CRect_AC& boundsRect, 
									bool /*isVisible*/, bool isEnabled,
									const CStr255_AC& /*itsTitle*/)
{
	fTextStyle.Normalize(gSystemStyle.tsFont, gApplicationStyle.tsFont);
	return TH_new CSlider_AC(boundsRect, isEnabled, fInitialMin, fInitialMax, fInitialVal, 
								fInitialViewSize, fTextStyle, 
								fRightJustify ? teFlushRight : teFlushDefault, 
								fLabelsID,
								fLabelsID == 0 /* pointer if has labels */,
								fPreferLiveFeedback, 
								fLabelsID != 0 /* tick marks if has labels */,
								true /* proportional */,
								false /* reverse direction */,
								this);
}

#endif // qEmulateStandardControls
#endif // qAppearance || qEmulateStandardControls


//----------------------------------------------------------------------------------------
// End of USlider.cpp
