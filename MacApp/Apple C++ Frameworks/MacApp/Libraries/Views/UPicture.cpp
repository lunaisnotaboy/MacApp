//----------------------------------------------------------------------------------------
// UPicture.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/26/00/ADmdr		[W] Initialize SetNeedsOwnWindowsWindow and SetTransparentView in ctor.
		11/13/00	[PB] Change initialization order to match declaration. 
		06/21/00	Use GetReverseMappedResInfo instead of GetResInfo.
		09/29/99	LoadResource now called MacLoadResource.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		03/18/99	Removed '&' on parms to a variety of Toolbox calls.
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					LoadResource_AC.  Include ResourceUtils_AC.h.
		10/08/98	Need to include UMemory. 
					MPurgeable. 
					Merge TCommandHandler into TEventHandler. 
*/

#ifndef __UPICTURE__
#include "UPicture.h"
#endif

// ACS

#ifndef __ResourceUtils_AC__
#include "ResourceUtils_AC.h"
#endif

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#if qDrag
	#ifndef __UDRAGDROP__
	#include "UDragDrop.h"
	#endif
#endif

#ifndef __UMEMORY__
#include "UMemory.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

//========================================================================================
// GLOBAL Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUPicture
//----------------------------------------------------------------------------------------

void InitUPicture()
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TPicture, kStdPicture);
	}
}  


//========================================================================================
// CLASS TPicture
//========================================================================================
#undef Inherited
#define Inherited TControl


MA_DEFINE_CLASS(TPicture);

//----------------------------------------------------------------------------------------
// TPicture constructor
//----------------------------------------------------------------------------------------

TPicture::TPicture(const CViewPoint& itsLocation,
				   const CViewPoint& itsSize,
				   SizeDeterminer itsHSizeDet,
				   SizeDeterminer itsVSizeDet,
				   ResNumber itsRsrcID)
	:	TControl(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
		fDataHandle(NULL),
		fRsrcID(kNoResource)
{
	fEventNumber = mPictureHit;

	SetPictureRsrcID(itsRsrcID, kDontRedraw);
	SetEnable(false);						// Default is to not enable hit testing 
#if qMSWindows
	SetNeedsOwnWindowsWindow(true);
	SetTransparentView(false);
#endif
}


//----------------------------------------------------------------------------------------
// TPicture copy constructor
//----------------------------------------------------------------------------------------

TPicture::TPicture(const TPicture& inPicture) :
	fDataHandle(NULL),
	fRsrcID(kNoResource)
{
	if (inPicture.fDataHandle)
		SetPictureRsrcID(inPicture.fRsrcID, kDontRedraw);
}


//----------------------------------------------------------------------------------------
// TPicture::Free: 
//----------------------------------------------------------------------------------------

TPicture::~TPicture()
{
	ReleasePicture();
}

//----------------------------------------------------------------------------------------
// TPicture::GetStandardSignature: 
//----------------------------------------------------------------------------------------

IDType TPicture::GetStandardSignature() const	// Override 
{
	return kStdPicture;
}

//----------------------------------------------------------------------------------------
// TPicture::ReadFields: 
//----------------------------------------------------------------------------------------

void TPicture::ReadFields(CStream_AC* aStream)				// Override 
{
	Inherited::ReadFields(aStream);

	ResNumber itsRsrcID = aStream->ReadInteger();
	SetPictureRsrcID(itsRsrcID, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TPicture::WriteFields: 
//----------------------------------------------------------------------------------------

void TPicture::WriteFields(CStream_AC* aStream) const				// Override 
{
	Inherited::WriteFields(aStream);

#if qDebugMsg && !qDrag
	if (fRsrcID == kNoResource)
		ProgramReport_AC("Tried to write TPicture with no resource ID.\n");
#endif

	aStream->WriteInteger(fRsrcID);
}

//----------------------------------------------------------------------------------------
// TPicture::Draw: 
//----------------------------------------------------------------------------------------

void TPicture::Draw(const CViewRect& area)	// Override 
{
	if (fDataHandle)
	{
		if (IsAResource_AC((Handle)fDataHandle))
			::LoadResource_AC((Handle)fDataHandle);
		if (*fDataHandle)				// If there's room for the pictureÉ 
		{
			CTempHandleLock_AC tempHandleLock((Handle)fDataHandle, eDontMoveHi, eDontReleaseIt, eDontLockIt);
			::HNoPurge((Handle)fDataHandle);
			::PenNormal();
			::DrawPicture(fDataHandle, ControlQDArea());
		}
	}
	Inherited::Draw(area);
}

//----------------------------------------------------------------------------------------
// TPicture::ReleasePicture: 
//----------------------------------------------------------------------------------------

void TPicture::ReleasePicture()
{
	fRsrcID = kNoResource;
	if (fDataHandle)
	{
		HPurge((Handle)fDataHandle);
		fDataHandle = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TPicture::SetPicture: 
//----------------------------------------------------------------------------------------

void TPicture::SetPicture(PicHandle thePicture,
						  bool redraw)
{
	ReleasePicture();
	fDataHandle = thePicture;

	// get the rsrc id 
	ResNumber theID;
	ResType theType;
	CStr255_AC name;

	CMultiLocale_AC::GetReverseMappedResInfo((Handle)thePicture, &theID, &theType, name);
	if (ResError() == noErr)
		fRsrcID = theID;

	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TPicture::SetPictureRsrcID: 
//----------------------------------------------------------------------------------------

void TPicture::SetPictureRsrcID(ResNumber itsRsrcID, bool redraw)
{
	ReleasePicture();

	fRsrcID = itsRsrcID;

	if (fRsrcID != kNoResource)
	{
		fDataHandle = GetPicture(CMultiLocale_AC::GetExistingResourceID('PICT', fRsrcID));
		::ThrowIfNULLResource_AC((Handle)fDataHandle);		// was ::ThrowIfResError_AC();
	}

	if (redraw)
		ForceRedraw();
}

#if qDrag

//----------------------------------------------------------------------------------------
// TPicture::WillDrag
//----------------------------------------------------------------------------------------

bool TPicture::WillDrag(const CViewPoint& localMouse,
						const RgnHandle	dragCursorRegion)
{
	return Inherited::WillDrag(localMouse, dragCursorRegion) ? (fDataHandle || fRsrcID != kNoResource) : false;
}

//----------------------------------------------------------------------------------------
// TPicture::DoAddDragContent
//----------------------------------------------------------------------------------------

void TPicture::DoAddDragContent()
{
	CFlavorFlags	flags;
	
	TDragDropSession::fgDragDropSession->AddDragItem(1)->PromiseFlavor(kPictType_AC, flags);
}

//----------------------------------------------------------------------------------------
// TPicture::WillAcceptDrop
//----------------------------------------------------------------------------------------

bool TPicture::WillAcceptDrop(CDragItemIterator& dragItemIterator)
{
	bool returnVal = false;

	if (dragItemIterator.GetItemCount() == 1)
		returnVal = dragItemIterator.First()->FlavorExists(kPictType_AC);
	
	return returnVal;
}

//----------------------------------------------------------------------------------------
// TPicture::DoMakeDragDropCommand
//----------------------------------------------------------------------------------------

TCommand* TPicture::DoMakeDragDropCommand(CommandNumber itsCommandNumber,
										  CDragItemIterator& dragItemIterator,
										  TDragTracker* /*targetTracker*/)
{
	TCommand  *returnCommand = NULL;
	TEventHandler *itsContext = GetContext(itsCommandNumber);
	
	switch(itsCommandNumber)
	{
		case cDrag:
			returnCommand = TH_new TPictureCommand(kNoResource, NULL, this, itsCommandNumber, 
				itsContext, kCanUndo, kCausesChange, itsContext);
			break;
			
		case cDrop:
			{
				Handle	 pictureHandle = NULL;
				TDragItem *firstItem = dragItemIterator.First();
				
				firstItem->FocusOnFlavor(kPictType_AC);
				pictureHandle = firstItem->GetDataAsHandle();
					
				returnCommand = TH_new TPictureCommand(kNoResource, (PicHandle)pictureHandle, this, 
					itsCommandNumber, itsContext, kCanUndo, kCausesChange, itsContext);
			}
			break;
		
		case cDragMove:	// doesn't do anything...will cause return value to be NULL
			break;
			
		default:
			returnCommand = Inherited::DoMakeDragDropCommand(itsCommandNumber, dragItemIterator);
			break;
	}
	
	return returnCommand;
}

//----------------------------------------------------------------------------------------
// TPicture::DoFulfillPromise
//----------------------------------------------------------------------------------------

void TPicture::DoFulfillPromise(TDragItem* promisedItem)
{
	switch(promisedItem->GetFlavorType())
	{
		case kPictType_AC:
			{
				if (IsAResource_AC((Handle)fDataHandle))
					::MacLoadResource((Handle)fDataHandle);
				::ThrowIfNULL_AC(fDataHandle);
				::ThrowIfNULL_AC(*fDataHandle);
				
				CTempHandleLock_AC tempHandleLock((Handle)fDataHandle, eDontMoveHi, eDontReleaseIt, eDontLockIt);
				
				HNoPurge((Handle)fDataHandle);
				promisedItem->SetDataFromHandle((Handle)fDataHandle);
			}
			break;
		
		default:
			Inherited::DoFulfillPromise(promisedItem);
			break;
	}
}

#endif // qDrag

//========================================================================================
// CLASS TPictureCommand
//========================================================================================
#undef Inherited
#define Inherited TCommand

//----------------------------------------------------------------------------------------
// TPictureCommand::TPictureCommand
//----------------------------------------------------------------------------------------

TPictureCommand::TPictureCommand(ResNumber newRsrcID,
								 PicHandle newPicHandle,
								 TPicture* itsPictureView,
								 CommandNumber itsCommandNumber,
								 TEventHandler* itsContext,
								 bool canUndo,
								 bool causesChange,
								 MDependable_AC* objectToNotify) :
	TCommand(itsCommandNumber, itsContext, canUndo, causesChange, objectToNotify),
	fPictureView(itsPictureView),
	fSavedDataHandle(newPicHandle),
	fSavedRsrcID(newRsrcID)
{
}

//----------------------------------------------------------------------------------------
// TPictureCommand::Free
//----------------------------------------------------------------------------------------

TPictureCommand::~TPictureCommand()
{
	if (fSavedDataHandle)
	{
		if (IsAResource_AC((Handle)fSavedDataHandle))
		{
			ReleaseResource((Handle)fSavedDataHandle);
			fSavedDataHandle = NULL;
		}
		else
			fSavedDataHandle = (PicHandle)::DisposeIfHandle_AC((Handle)fSavedDataHandle);
	}
}

//----------------------------------------------------------------------------------------
// TPictureCommand::DoIt
//----------------------------------------------------------------------------------------

void TPictureCommand::DoIt()
{
	PicHandle tempDataHandle = NULL;
	
	// prefer saving the resource ID.  If the resource ID is not valid, save the data handle
	ResNumber tempResID = fPictureView->fRsrcID;
	if ( tempResID == kNoResource)
	{
		tempDataHandle = fPictureView->fDataHandle;
		fPictureView->fDataHandle = NULL;
	}
	
	// prefer the resource ID over the data handle
	if (fSavedRsrcID != kNoResource)
		fPictureView->SetPictureRsrcID(fSavedRsrcID, kRedraw);
	else
		fPictureView->SetPicture(fSavedDataHandle, kRedraw);
		
	fSavedRsrcID = tempResID;
	fSavedDataHandle = tempDataHandle;
	
	if (fPictureView->IsDrawable())
	{
		CViewRect area(fPictureView->ControlArea());
		::EraseRect(fPictureView->ViewToQD(area));
		fPictureView->HandleDraw(area);
	}
}

//----------------------------------------------------------------------------------------
// TPictureCommand::UndoIt
//----------------------------------------------------------------------------------------

void TPictureCommand::UndoIt()
{
	DoIt();
}

//----------------------------------------------------------------------------------------
// TPictureCommand::TotalSize
//----------------------------------------------------------------------------------------

Size TPictureCommand::TotalSize(bool justLocked) const
{
	return GetHandleSizeIfLocked(reinterpret_cast<Handle>(fSavedDataHandle), justLocked);
}


//----------------------------------------------------------------------------------------
// End of UPicture.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/25/96	[1345531] Added missing includes for noload buids
		05/21/96	Cleanup to be single exit in TPicture::WillDrag/WillAcceptDrop.
		05/07/96	Use enums for parameters of CTempHandleLock_AC constructor.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/26/96	Made TControl::ControlArea/ControlQDArea non virtual. Made TView/TControl::GetAdornExtent
							return their CViewRect as function results
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitUPicture
		04/15/96	moved MDependable_AC from TObject
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
		
*/