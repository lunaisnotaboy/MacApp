//----------------------------------------------------------------------------------------
// USynchScroller.cpp
// Copyright © 1989-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/13/00	[PB] Change initialization order to match declaration. 
		11/11/00	Cosmetic.  Eliminated Inherited.
		09/11/00	GetClipRegion method should only be used on the view's port.
		09/01/00	Added embedded documentation - TPrimaryScroller::AddSecondaryScroller.
		12/27/99	Cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		08/09/99	Changed MA_REGISTER_CLASS to REGISTER_CLASS_AC.
		03/24/99	Update copyright notice.
		03/23/99	Go back to native Toolbox region calls.
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					UnionRgn_AC.  Include ImagingUtils_AC.h.
		10/27/98	Carbonize
*/

#ifndef __USYNCHSCROLLER__
#include "USynchScroller.h"
#endif

// ACS

#ifndef __CIterator__
#include "CIterator_AC.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

// MacApp

#ifndef __UCOMMAND__
#include "UCommand.h"
#endif

#ifndef __UDEBUG__
#include "UDebug.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UEVENT__
#include "UEvent.h"
#endif

#ifndef __UGEOMETRY__
#include "UGeometry.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UPATCH__
#include "UPatch.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

// Toolbox

#ifndef __DIALOGS__
#include <Dialogs.h>
#endif

// ANSI

#ifndef __STDIO__
#include <stdio.h>
#endif

#ifndef __STDLIB__
#include <stdlib.h>
#endif

//----------------------------------------------------------------------------------------
// InitUSynchScroller:
//----------------------------------------------------------------------------------------

void InitUSynchScroller()
{
#if qTemplateViews
	// Suppress Linker dead-stripping of these classes
	REGISTER_CLASS_AC(TPrimaryScroller);
	REGISTER_CLASS_AC(TSecondaryScroller);
#endif
}

//========================================================================================
// CLASS TPrimaryScroller
//========================================================================================

MA_DEFINE_CLASS(TPrimaryScroller);

//----------------------------------------------------------------------------------------
// TPrimaryScroller::Free:
//----------------------------------------------------------------------------------------

TPrimaryScroller::~TPrimaryScroller()
{
	for (TemplateIterator_AC<TSecondaryScroller*> iter(&fSecondaryScrollers); iter; ++iter)
		RemoveSecondaryScroller(iter);
}

//----------------------------------------------------------------------------------------
// TPrimaryScroller::AddSecondaryScroller:
//----------------------------------------------------------------------------------------

void TPrimaryScroller::AddSecondaryScroller(TSecondaryScroller*	itsSecondaryScroller,
											ViewCoordinate		itsHDependency,
											ViewCoordinate		itsVDependency)
// AddSecondaryScroller associates a TSecondaryScroller object with this TPrimaryScroller
// object. This method specifies a primary scroller and whether the secondary scroller is
// dependent on horizontal or vertical coordinates from the primary scroller.
//
// itsSecondaryScroller:	Specifies the instance of TSecondaryScroller that
// 							is to be dependent on this instance of TPrimaryScroller.
// itsHDependency:			Specifies whether this scroller mimics the primary scroller
//							in the horizontal axis.
// itsVDependency:			Specifies whether this scroller mimics the primary scroller
// 							in the vertical axis.
//
// Call?		As needed.
// Override?	Seldom.
{
	if (itsSecondaryScroller)
	{
		itsSecondaryScroller->fPrimaryScroller = this;
		itsSecondaryScroller->fDeltaFactor = CViewPoint(itsHDependency, itsVDependency).ToPoint();

		fSecondaryScrollers.Insert(itsSecondaryScroller);
	}
}

//----------------------------------------------------------------------------------------
// TPrimaryScroller::RemoveSecondaryScroller:
//----------------------------------------------------------------------------------------

void TPrimaryScroller::RemoveSecondaryScroller(TSecondaryScroller* itsSecondaryScroller)
{
	if (itsSecondaryScroller)
	{
		itsSecondaryScroller->fPrimaryScroller = NULL;
		fSecondaryScrollers.Delete(itsSecondaryScroller);
	}
}

//----------------------------------------------------------------------------------------
// TPrimaryScroller::DoScroll:
//----------------------------------------------------------------------------------------

void TPrimaryScroller::DoScroll(const CViewPoint& delta, bool redraw)
{
	{
		for (TemplateIterator_AC<TSecondaryScroller*> iter(&fSecondaryScrollers); iter; ++iter)
		{
			TSecondaryScroller* aSecondaryScroller = iter;

			CViewPoint itsDelta(delta);

			for (VHSelect vhs = vSel; vhs <= hSel; ++vhs)
				if (aSecondaryScroller->fDeltaFactor[vhs])	// kVDependent or kHDependent
				{
					if (itsDelta[vhs] < 0)
						itsDelta[vhs] = Max_AC(itsDelta[vhs], -aSecondaryScroller->GetTranslation()[vhs]);
					else if (itsDelta[vhs] > 0)
						itsDelta[vhs] = Min_AC(itsDelta[vhs], aSecondaryScroller->fMaxTranslation[vhs] - aSecondaryScroller->GetTranslation()[vhs]);

					CViewPoint itsTranslation(aSecondaryScroller->GetTranslation());
					itsTranslation[vhs] += itsDelta[vhs];
					aSecondaryScroller->SetTranslation(itsTranslation);
				}

			if (itsDelta != gZeroVPt)
			{
				aSecondaryScroller->InvalidateFocus();	// You never know who might call
				aSecondaryScroller->InvalidateCoordinates();
			}
		}
	}

	TScroller::DoScroll(delta, redraw);
}

//----------------------------------------------------------------------------------------
// TPrimaryScroller::ScrollDraw:
//----------------------------------------------------------------------------------------

void TPrimaryScroller::ScrollDraw(const CViewPoint& delta, bool invalidate)
{
	if (fSuperView->IsDrawable())
	{
		CTempRegion_AC scrollRgn;

		GetExtentRegion(scrollRgn);
		LocalToSuperView(scrollRgn);

		//CRect_AC superVisRect((*GetClipRegion(qd.thePort))->rgnBBox); // just test the clip, it's faster
		CRect_AC superVisRect(GetRegionBounds_AC(GetClipRegion())); // Carbonized

#if qDebug
		if (gIntenseDebugging)
			WriteFocus();
#endif

	    const CViewRect visVRect(superVisRect);
	    if (((visVRect - delta) & visVRect).Empty()) // too far to scrollrect
		{
			ForceRedraw();

			for (TemplateIterator_AC<TSecondaryScroller*> iter(&fSecondaryScrollers); iter; ++iter)
			{
				TSecondaryScroller* aScroller = iter;

				if (aScroller->IsShown ())
				{
					if (delta.v && (aScroller->fDeltaFactor.v == kVDependent))
						aScroller->ForceRedraw();
					else if (delta.h && (aScroller->fDeltaFactor.h == kHDependent))
						aScroller->ForceRedraw();
				}
			}
		}
		else		// Can use ScrollRect
		{
			CTempRegion_AC tempRgn;

#if qDebug
			fSuperView->AssumeFocused();
#endif

			{		// for correct failure handling
				for (TemplateIterator_AC<TSecondaryScroller*> iter(&fSecondaryScrollers); iter; ++iter)
				{
					TSecondaryScroller* aScroller = iter;
					if (aScroller->IsShown ())
					{
						CPoint_AC localDeltaFactor(aScroller->fDeltaFactor);

						CRect_AC frameRect(aScroller->GetSuperView()->ViewToQD(aScroller->GetFrame()));
						// main scroller is moving both directions but dependent can only move in v
						if (delta.h && delta.v && (localDeltaFactor.h == kNotHDependent) && (localDeltaFactor.v == kVDependent))
						{
							ScrollRect(frameRect, 0, static_cast<short>(-delta.v), tempRgn);
							aScroller->GetSuperView()->Invalidate(tempRgn);
						}
						// main scroller is moving both directions but dependent can only move in h
						else if (delta.h && delta.v && (localDeltaFactor.h == kHDependent) && (localDeltaFactor.v == kNotVDependent))
						{
							ScrollRect(frameRect, static_cast<short>(-delta.h), 0, tempRgn);
							aScroller->GetSuperView()->Invalidate(tempRgn);
						}
						// main scroller is moving in either direction and dependent can follow
						else if ((delta.h && (localDeltaFactor.h == kHDependent)) || (delta.v && (localDeltaFactor.v == kVDependent)))
						{
							aScroller->GetExtentRegion(tempRgn);
							aScroller->LocalToSuperView(tempRgn);
							::MacUnionRgn(scrollRgn, tempRgn, scrollRgn);
						}
					}
				}
			}

#if qDebug
			fSuperView->AssumeFocused();
#endif

			// Now, we've either scrolled any dependent scrollers that can't scroll with
			// us or we've accumulated their frames in scrollRgn.  By clipping to the
			// accumulated region we can just scroll the entire superview and the right
			// stuff should happen. (Cross fingers)
#if !qCarbon
			SectRgn(scrollRgn, GetGrafPtr_AC()->clipRgn, scrollRgn);
#else
			{
				CTempRegion_AC clipRegion;
				::GetPortClipRegion(GetCGrafPtr_AC(), clipRegion);
				SectRgn(scrollRgn, clipRegion, scrollRgn);
			}
#endif

			// Get clip so we can restore it later and keep from having
			// to invalidate the superview's focus
			GetClip(tempRgn);

			SetClip(scrollRgn);
			ScrollRect(superVisRect, static_cast<short>(-delta.h), static_cast<short>(-delta.v), scrollRgn);

			// restore the clip so we don't have to invalidate the focus
			SetClip(tempRgn);

			fSuperView->Invalidate(scrollRgn);
		}

		if (!invalidate)
			fSuperView->Update();
	}
}

//========================================================================================
// CLASS TSecondaryScroller
//========================================================================================

MA_DEFINE_CLASS(TSecondaryScroller);

//----------------------------------------------------------------------------------------
// TSecondaryScroller constructor
//----------------------------------------------------------------------------------------

TSecondaryScroller::TSecondaryScroller(const CViewPoint&	itsLocation,
									   const CViewPoint&	itsSize,
									   SizeDeterminer		itsHSizeDet,
									   SizeDeterminer		itsVSizeDet,
									   const CViewPoint&	itsMax,
									   bool					wantHorzSBar,
									   bool					wantVertSBar)
	:	TScroller(itsLocation, itsSize,
				  itsHSizeDet, itsVSizeDet, itsMax,wantHorzSBar, wantVertSBar),
		fDeltaFactor(kNotHDependent, kNotVDependent),
		fPrimaryScroller(NULL)
{
}

//----------------------------------------------------------------------------------------
// TSecondaryScroller::Free:
//----------------------------------------------------------------------------------------

TSecondaryScroller::~TSecondaryScroller()
{
	if (fPrimaryScroller)
		fPrimaryScroller->RemoveSecondaryScroller(this);	// sets fPrimaryScroller to NULL
}

//----------------------------------------------------------------------------------------
// TSecondaryScroller::DoScroll:
//----------------------------------------------------------------------------------------

void TSecondaryScroller::DoScroll(const CViewPoint& delta, bool redraw)
{
	if (fPrimaryScroller)
		fPrimaryScroller->ScrollBy(CViewPoint(fDeltaFactor.h * delta.h, fDeltaFactor.v * delta.v), redraw);
}

//----------------------------------------------------------------------------------------
// End of USynchScroller.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		 4/26/96	Made C/CViewPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/CViewPoint/Rects.
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		 3/26/96	Condition WriteFocus calls under qDebug
		 3/18/96	Made better use of TView calls that return CRect_AC/CViewPoint/CViewRect
		----- 3.3b1 -----
		07/31/95	Use GetClipRegion
		 4/12/95	Use #if instead of if qDebug.
		03/13/95	1162017	ScrollRect crash
		 3/13/95	Change Free methods to destructors.
		  3/6/95	Fix conflict between iterating and freeing in TPrimaryScroller::Free
							and RemoveSecondaryScroller.
		 2/28/95	Use MA_REGISTER_CLASS instead of macroDontDeadStrip.
*/