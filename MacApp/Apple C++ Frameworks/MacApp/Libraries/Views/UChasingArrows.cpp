//----------------------------------------------------------------------------------------
// UChasingArrows.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/21/00	Conditionalize controls based on whether they require the
					Appearance Manager and/or an emulated control. 
		06/01/00	Remove any idler in TChasingArrows dtor.
		03/17/00	CodeWarrior can't tell both sides of ? expression have a
					common base class. 
		03/16/00	Respect the idle phase and the shown and enabled states. 
					Add a method to stop the animating. 
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __UCHASINGARROWS__
#include "UChasingArrows.h"
#endif

#if qAppearance || qEmulateStandardControls

// ACS

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __CStream_AC__
#include "CStream_AC.h"
#endif

#if qEmulateStandardControls

	#ifndef __CChasingArrows_AC__
	#include "CChasingArrows_AC.h"
	#endif

#endif // qEmulateStandardControls

#ifndef __ToolboxControls_AC__
#include "ToolboxControls_AC.h"
#endif

// MacApp

#ifndef __UCONTROL__
#include "UControl.h"
#endif

#ifndef __UVIEWIDLER__
#include "UViewIdler.h"
#endif

// Toolbox

#ifndef __APPEARANCE__
#include <Appearance.h>
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// InitUChasingArrows
//----------------------------------------------------------------------------------------

void InitUChasingArrows()
{
	static bool UChasingArrowsInitialized;

	if (!UChasingArrowsInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TChasingArrows, kStdChasingArrows);
		}
		UChasingArrowsInitialized = true;
	}
}

//========================================================================================
// CLASS TChasingArrows
//========================================================================================

#undef Inherited
#define Inherited TCtlMgr

MA_DEFINE_CLASS(TChasingArrows);

//----------------------------------------------------------------------------------------
// TChasingArrows constructor
//----------------------------------------------------------------------------------------

TChasingArrows::TChasingArrows(const CViewPoint& itsLocation,
							   const CViewPoint& itsSize,
							   SizeDeterminer itsHSizeDet,
							   SizeDeterminer itsVSizeDet) :
	TCtlMgr(itsLocation, itsSize, itsHSizeDet, itsVSizeDet, gEmptyString)
{
}

//----------------------------------------------------------------------------------------
// TChasingArrows copy constructor
//----------------------------------------------------------------------------------------

TChasingArrows::TChasingArrows(const TChasingArrows& inTChasingArrows)
	:	TCtlMgr(inTChasingArrows)
{	
}

//----------------------------------------------------------------------------------------
// TChasingArrows destructor
//----------------------------------------------------------------------------------------

TChasingArrows::~TChasingArrows()
{
	TViewIdler::DeleteIdler(this);
}

//----------------------------------------------------------------------------------------
// TChasingArrows::GetStandardSignature
//----------------------------------------------------------------------------------------

IDType TChasingArrows::GetStandardSignature() const
{
	return kStdChasingArrows;
}

//----------------------------------------------------------------------------------------
// TChasingArrows::CreateControl
//----------------------------------------------------------------------------------------

void TChasingArrows::CreateControl()
{
	Inherited::CreateControl();

	if (IsEnabled())
		StartAutoAnimate();
}

//----------------------------------------------------------------------------------------
// TChasingArrows::DoIdle
//----------------------------------------------------------------------------------------

bool TChasingArrows::DoIdle(IdlePhase phase)
{
	if ((phase == idleContinue) && IsEnabled() && IsShown())
		IdleControl();
	
	return false;	// did not free self
}

//----------------------------------------------------------------------------------------
// TChasingArrows::StartAutoAnimate
//----------------------------------------------------------------------------------------

void TChasingArrows::StartAutoAnimate()
{
	SetIdleFreq(2);		// idle reasonably often
	SetEnable(true);	// we won't get idle time if we're disabled!

	// This creates an idler behavior for the dispatcher, so we always get idle time.
	TViewIdler::DeleteIdler(this);
	TH_new TViewIdler(this);
}

//----------------------------------------------------------------------------------------
// TChasingArrows::StopAutoAnimate
//----------------------------------------------------------------------------------------

void TChasingArrows::StopAutoAnimate()
{
	SetIdleFreq(kMaxIdleTime);
	TViewIdler::DeleteIdler(this);
}

//----------------------------------------------------------------------------------------
// TChasingArrows::DoMakeControl
//----------------------------------------------------------------------------------------

CControl_AC* TChasingArrows::DoMakeControl(WindowRef theWindow, 
										   const CRect_AC& boundsRect, 
										   bool isVisible, bool isEnabled, 
										   const CStr255_AC& /*itsTitle*/)
{
#if qEmulateStandardControls
	if (::EmulateControls_AC())
		return TH_new CChasingArrows_AC(boundsRect, isEnabled);
	else
#endif // qEmulateStandardControls
		return CreateChasingArrows_AC(theWindow, boundsRect, isVisible, isEnabled);
}

#endif // qAppearance || qEmulateStandardControls


//----------------------------------------------------------------------------------------
// End of UChasingArrows.cpp
