//----------------------------------------------------------------------------------------
// UTabBehaviors.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		03/24/99	Update copyright notice.
*/

#ifndef __UTABBEHAVIORS__
#include "UTabBehaviors.h"
#endif

// MacApp

#ifndef __UEVENT__
#include "UEvent.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

//========================================================================================
// CLASS TTabber
//========================================================================================
#undef Inherited
#define Inherited TBehavior


MA_DEFINE_CLASS(TTabber);

//----------------------------------------------------------------------------------------
// TTabber constructor
//----------------------------------------------------------------------------------------


TTabber::TTabber(bool recursive) :
	TBehavior(kTabBehavior),

	fNext(NULL),
	fFirst(NULL),
	fRecursive(recursive),
	fFoundCurrent(false)
{
}

//----------------------------------------------------------------------------------------
// TTabber destructor
//----------------------------------------------------------------------------------------


TTabber::~TTabber()
{
}

//----------------------------------------------------------------------------------------
// TTabber::ReadFrom: 
//----------------------------------------------------------------------------------------


void TTabber::ReadFrom(CStream_AC* aStream)				// override 
{
	Inherited::ReadFrom(aStream);

	fRecursive = aStream->ReadBoolean();
}

//----------------------------------------------------------------------------------------
// TTabber::WriteTo: 
//----------------------------------------------------------------------------------------


void TTabber::WriteTo(CStream_AC* aStream) const				// override 
{
	Inherited::WriteTo(aStream);

	aStream->WriteBoolean(fRecursive);
}

//----------------------------------------------------------------------------------------
// TTabber::DoKeyEvent: 
//----------------------------------------------------------------------------------------


void TTabber::DoKeyEvent(TToolboxEvent* event)
{
	if (event && event->GetText() == chTab)
		Tab(event->IsShiftKeyPressed());
	else
		Inherited::DoKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// TTabber::Tab: 
//----------------------------------------------------------------------------------------


void TTabber::Tab(bool tabBackward)
{
	Reset();

	FindTargets(tabBackward);
	
	if (!fNext)
	    fNext = fFirst;
	
	if (fNext)
	{
		if (fNext->BecomeTarget())
			fNext->SetTargetSelection(kRedraw);
	}
}

//----------------------------------------------------------------------------------------
// TTabber::Reset: 
//----------------------------------------------------------------------------------------


void TTabber::Reset()
{
	fFirst = NULL;
	fNext = NULL;
	fFoundCurrent = false;
}

//----------------------------------------------------------------------------------------
// TTabber::FindSubViewTargets: 
//----------------------------------------------------------------------------------------


void TTabber::FindSubViewTargets(TView* parent,
								 bool tabBackward)
// FindSubViewTargets locates the next subview that can become the current target.
//
// parent:		Specifies the view from which the search starts.
// tabBackward:	True if the user pressed Shift-Tab, so that the search for the subviews
//				is to proceed backward through the list of subviews from the parent.
{
	for (CSubViewIterator iter(parent,!tabBackward); iter; ++iter)
	{
		bool canBeTarget = iter->IsEnabled() && iter->IsShown() && iter->WantsToBeTarget();

		if (!fFirst && canBeTarget)
			fFirst = iter;

		if (TEventHandler::GetTarget() == iter.Current())
			fFoundCurrent = true;
		else if (fFoundCurrent && !fNext && canBeTarget)
		{
			fNext = iter;
			break;
		}

		if (fRecursive)
			FindSubViewTargets(iter,tabBackward);
	}
}

//----------------------------------------------------------------------------------------
// TTabber::FindTargets: 
//----------------------------------------------------------------------------------------


void TTabber::FindTargets(bool /* tabBackward */)
{
	SubClassResponsibility();
}

//----------------------------------------------------------------------------------------
// TTabber::GetStandardSignature:
//----------------------------------------------------------------------------------------


IDType TTabber::GetStandardSignature() const
{
	return kTabBehavior;
}

//========================================================================================
// CLASS TMultiWindowTabber
//========================================================================================
#undef Inherited
#define Inherited TTabber


MA_DEFINE_CLASS(TMultiWindowTabber);

//----------------------------------------------------------------------------------------
// TMultiWindowTabber destructor
//----------------------------------------------------------------------------------------


TMultiWindowTabber::~TMultiWindowTabber()
{
}

//----------------------------------------------------------------------------------------
// TMultiWindowTabber::FindTargets: 
//----------------------------------------------------------------------------------------


void TMultiWindowTabber::FindTargets(bool tabBackward)
// FindTargets locates the next eligible target for multiple windows in any window
// of the application.
//
// tabBackward: true if the user pressed Shift-Tab indicating that the previous
//				eligible target should be chosen.
{
	TWindow* theFrontWindow = TWindow::WMgrToWindow(FrontWindow());
	
	if (theFrontWindow)	
		if (theFrontWindow->IsModal())
			FindSubViewTargets(theFrontWindow,tabBackward);
		else
			for (CWMgrIterator iter(!tabBackward); iter; ++iter)
			{
				TWindow* aWindow = TWindow::WMgrToWindow(iter);
			
				if (aWindow && aWindow->IsShown() && aWindow->IsActive())
					FindSubViewTargets(aWindow,tabBackward);
			}
}


//========================================================================================
// CLASS TViewTabber
//========================================================================================
#undef Inherited
#define Inherited TTabber


MA_DEFINE_CLASS(TViewTabber);

//----------------------------------------------------------------------------------------
// TViewTabber destructor
//----------------------------------------------------------------------------------------


TViewTabber::~TViewTabber()
{
}

//----------------------------------------------------------------------------------------
// TViewTabber::FindTargets: 
//----------------------------------------------------------------------------------------


void TViewTabber::FindTargets(bool tabBackward)	// Override
{
	FindSubViewTargets( dynamic_cast_or_throw_AC(TView*,fOwner), tabBackward);
}


//----------------------------------------------------------------------------------------
// End of UTabBehaviors.cpp



/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use more "while" style iteration
		04/15/96	Use "while" style iteration for subviews
		----- R10 -----
		03/25/96	TToolboxEvent::fCharacter is obsolete
							Made empty UAdorners constructors inline
		12/08/95	Split up includes for modular MacApp. 
		----- 3.3 -----
		10/11/95	Add TTabbler::GetStandardSignature. (N.Nallick)
		----- 3.3b1 -----
		08/23/95	Cosmetic.
		05/16/95	WindowRef
		05/15/95	Remove support for pre-system 7. 
		03/13/95	Change Free methods to destructors. 
*/