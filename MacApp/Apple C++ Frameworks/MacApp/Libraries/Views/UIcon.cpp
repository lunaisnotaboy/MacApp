//----------------------------------------------------------------------------------------
// UIcon.cpp
// Copyright � 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/26/00	[W] Plot now works.  ReleaseIconSuite not needed.
					SetIconSuiteRsrcID and ContainsMouse is implemented.
		11/09/00	[PB] Change initialization order to match declaration. 
					[PB] Suppress GCC warnings about unused return variables. 
		07/27/00	iconRect was being offset by botRightPoint in GetIconRect for
					some strange reason.
		06/14/00	Eliminate unnecessary GetRegionCode calls.  Include CMultiLocal.h.
		06/06/00	[2478013] Changed TIcon::Activate so fTransform is calculated
					correctly.
		06/06/00	[2477976] Changed GetIconRect to return offset rather than QD
					rect.  Don�t offset IconRect in TIcon::Plot.
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
		03/22/99	[W] PlotIconSuite, DisposeIconSuite, GetIconSuite and
					IconSuiteToRgn not available.
		03/18/99	Removed '&' on parms to a variety of Toolbox calls.
		10/29/98	[W] It is no longer necessary to include QTMLMapNames.h.  Use
					LoadResource_AC.  Include ResourceUtils_AC.h.
*/

#ifndef __UICON__
#include "UIcon.h"
#endif

// ACS

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

#ifndef __ResourceUtils_AC__
#include "ResourceUtils_AC.h"
#endif

// MacApp

#ifndef __UCOREUTILITIES__
#include "UCoreUtilities.h"
#endif

#ifndef __UICONSUITE__
#include "UIconSuite.h"
#endif

#ifndef __MACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __USMALLICON__
#include "USmallIcon.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

void InitUIcon(bool InitAllIcons)
{
	if (qTemplateViews)
	{
		REGISTER_SIGNATURE_AC(TIcon, kStdIcon);
		
		if(InitAllIcons)
		{
			InitUIconSuite();
			InitUSmallIcon();
		}	
	}
}

//========================================================================================
// CLASS TIcon
//========================================================================================
#undef Inherited
#define Inherited TControl


MA_DEFINE_CLASS(TIcon);


//----------------------------------------------------------------------------------------
// TIcon constructor
//----------------------------------------------------------------------------------------


TIcon::TIcon(const CViewPoint& itsLocation,
				const CViewPoint& itsSize,
				SizeDeterminer itsHSizeDet,
				SizeDeterminer itsVSizeDet,
				ResNumber itsRsrcID,
				eIconSelectorFlag loadFlag)
	:	TControl(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),
		fIconSuite(NULL),
		fRsrcID(kNoResource),
		fAlign(kNoAlignment),
		fTransform(kNoTransform),
		fLabel(kNoLabel_AC)
{
	fEventNumber = mIconHit;

	SetIconSuiteRsrcID(itsRsrcID, kDontRedraw, loadFlag);
	SetEnable(false);							// Default is to not enable hit testing
}

//----------------------------------------------------------------------------------------
// TIcon copy constructor 
//----------------------------------------------------------------------------------------


TIcon::TIcon(const TIcon& inIcon)
	:	TControl(inIcon),
		fIconSuite(NULL),
		fRsrcID(kNoResource),
		fAlign(inIcon.fAlign),
		fTransform(inIcon.fTransform),
		fLabel(inIcon.fLabel)
{
	if (inIcon.fIconSuite)
		SetIconSuiteRsrcID(inIcon.fRsrcID, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TIcon::~TIcon: 
//----------------------------------------------------------------------------------------


TIcon::~TIcon()
{
	ReleaseIconSuite();
}

//----------------------------------------------------------------------------------------
// TIcon::GetStandardSignature: 
//----------------------------------------------------------------------------------------


IDType TIcon::GetStandardSignature() const
{
	return kStdIcon;
}

//----------------------------------------------------------------------------------------
// TIcon::ReadFields: 
//----------------------------------------------------------------------------------------


void TIcon::ReadFields(CStream_AC* aStream)
{
	Inherited::ReadFields(aStream);

	bool wantsColor = aStream->ReadBoolean();
#if qProjectBuilder
	(void) wantsColor;
#endif
		// read it to remain compatible with old TIcon, but
		// we're ignoring the value.
		
	ResNumber itsRsrcID = aStream->ReadInteger();
	
	SetIconSuiteRsrcID(itsRsrcID, kDontRedraw);
}

//----------------------------------------------------------------------------------------
// TIcon::WriteFields: 
//----------------------------------------------------------------------------------------


void TIcon::WriteFields(CStream_AC* aStream) const
{
	Inherited::WriteFields(aStream);
		
	bool wantsColor = true;
	aStream->WriteBoolean(wantsColor);
		// write it to remain compatible with old TIcon

#if qDebugMsg
	if (fRsrcID == kNoResource)
		ProgramReport_AC("Writing a TIcon with no resource ID.");
#endif

	aStream->WriteInteger(fRsrcID);
}

//----------------------------------------------------------------------------------------
// TIcon::Plot: 
//----------------------------------------------------------------------------------------


void TIcon::Plot()
{
#if qMSWindows
	if (fRsrcID != kNoResource)
	{
		CRect_AC theDestRect = GetIconRect();		// Prevent scaling
		//::PlotIconID(theDestRect, (IconAlignmentType) fAlign, (IconTransformType) fTransform | fLabel, fRsrcID);
		#pragma message("TIcon::Plot: PlotIconID crashes under Windows.")
	}
#else
#if qDebug
	AssumeFocused();
#endif

	if(fIconSuite)
	{
		if(IsAResource_AC(fIconSuite))
		{
			::LoadResource_AC(fIconSuite);
		}
	
		if(*fIconSuite)
		{
			// prevent scaling
			CRect_AC theDestRect = GetIconRect();
			
			::PlotIconSuite(theDestRect, 
							(IconAlignmentType) fAlign, 
							(IconTransformType) fTransform | fLabel, 
							fIconSuite);
				// This will do the right thing in regards to screen depth
				// and plotting the right icon based on the imaging area.
				
		}
	}
#endif
}

//----------------------------------------------------------------------------------------
// TIcon::Draw: 
//----------------------------------------------------------------------------------------



void TIcon::Draw(const CViewRect& area)				
{
	Plot();
	Inherited::Draw(area);
}

//----------------------------------------------------------------------------------------
// TIcon::ReleaseIcon: 
//----------------------------------------------------------------------------------------


void TIcon::ReleaseIconSuite()
{
#if !qMSWindows
	fRsrcID = kNoResource;
	
	if(fIconSuite)
	{
		::DisposeIconSuite(fIconSuite, true);
		fIconSuite = NULL;
	}
#endif
}

//----------------------------------------------------------------------------------------
// TIcon::SetIcon: 
//----------------------------------------------------------------------------------------


void TIcon::SetIconSuite(Handle theIconSuite,bool redraw)
{
	ReleaseIconSuite();

	// Make sure the resource is loaded since it may have been purged and we
	// want to be sure that we can get the size to determine the correct type
	// of icon.
	if(IsAResource_AC(theIconSuite))
	{
		::LoadResource_AC(theIconSuite);
		::ThrowIfResError_AC();
	
		// get the rsrc id (this will only work for b&w icons)
		ResNumber		theID;
		ResType			theType;
		CStr255_AC		name;
		// ���  This might better be a plain GetResInfo.
		CMultiLocale_AC::GetReverseMappedResInfo(theIconSuite, &theID, &theType, name);
		if (ResError() == noErr)
			fRsrcID = theID;
	}
	fIconSuite = theIconSuite;

	if (redraw)
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TIcon::SetIconSuiteRsrcID: 
//----------------------------------------------------------------------------------------


void TIcon::SetIconSuiteRsrcID(ResNumber itsRsrcID, bool redraw, eIconSelectorFlag loadFlag)
{
#if qMSWindows
	#pragma unused (loadFlag)

	fRsrcID = itsRsrcID;
	if (redraw)
		ForceRedraw();
#else
	ReleaseIconSuite();

	fRsrcID = itsRsrcID;

	if (fRsrcID != kNoResource)
	{
		// there needs to be a b/w icon either small or large for this to work.
		short theID = CMultiLocale_AC::GetExistingResourceID('ics#', fRsrcID);
		if (theID == fRsrcID)
			theID = CMultiLocale_AC::GetExistingResourceID('icl#', fRsrcID);

		OSErr err = ::GetIconSuite(&fIconSuite, theID, (IconSelectorValue) loadFlag);
		::ThrowIfOSErr_AC(err);
	}
	
	if (redraw)
		ForceRedraw();
#endif
}

//----------------------------------------------------------------------------------------
// TIcon::HiliteState: 
//----------------------------------------------------------------------------------------


void TIcon::HiliteState(bool state, bool redraw)
{
	
	if (state != fHilite)
	{
		fHilite = state;
				
		if(fHilite)
		{
			fTransform |= kSelected;
		}
		else
		{
			fTransform &= ~kSelected;
		}

		if (redraw && IsDrawable())
			Hilite();
	}
}
//----------------------------------------------------------------------------------------
// TIcon::HiliteState: 
//----------------------------------------------------------------------------------------


void TIcon::Hilite()
{
	Plot();
}

//----------------------------------------------------------------------------------------
// TIcon::Dim: 
//----------------------------------------------------------------------------------------


void TIcon::Dim()
{
	Plot();
}

//----------------------------------------------------------------------------------------
// TIcon::Activate: 
//----------------------------------------------------------------------------------------


void TIcon::Activate(bool entering)
{
    TIconBitmask    transformWas = fTransform;

    if (entering)
        fTransform &= ~kDisabled;
    else
        fTransform |= kDisabled;

    if (transformWas != fTransform && Focus() && IsVisible())
        ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TIcon::GetIconRect
//----------------------------------------------------------------------------------------

CRect_AC TIcon::GetIconRect()
{
	// Return a rect that will cause the similarly sized icon to be retrieved
	// and displayed without any stretching. It will be clipped, however.

	CPoint_AC	botRightPoint;

	if (fSize.h <= 16 && fSize.v <= 12)
		botRightPoint.Set(16, 12);
	else if (fSize.h <= 16 && fSize.v <= 16)
		botRightPoint.Set(16, 16);
	else
		botRightPoint.Set(32, 32);

	// Get our imaging area
	CRect_AC	iconRect(ControlQDArea());

	return iconRect;
}

//----------------------------------------------------------------------------------------
// TIcon::GetIconSuite
//----------------------------------------------------------------------------------------

Handle TIcon::GetIconSuite() const
{
	return fIconSuite;
}


//----------------------------------------------------------------------------------------
// TIcon::ContainsMouse
//----------------------------------------------------------------------------------------

bool TIcon::ContainsMouse(const CViewPoint& theMouse)
{
#if qMSWindows
	// The two Icon to region methods don't work under Windows
	// so just revert to using the contol area.
	return TControl::ContainsMouse(theMouse);
#else
	if (fIconSuite)
	{
		CTempRegion_AC iconRgn;
		::IconSuiteToRgn(iconRgn, GetIconRect(), fAlign, fIconSuite);
		
		return (IsShown() && PtInRgn(ViewToQD(theMouse), iconRgn));
	}
	else
		return TControl::ContainsMouse(theMouse);
#endif
}

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		06/20/96	mwf 	Fixed bug where icons wouldn't draw right with adorners. Made
							it so clicks are tested against icons' mask, not views extent.
							Made it so plot pays attention to rect of icon, i.e. prevent
							unwanted scaling. Ripped out GetExtentRegion. Added ContainsMouse
							override.
		06/19/96	Cosmetic changes. Changed calll to fprintf to DebugStr.
		06/18/96	Removed extra release marker.
		06/18/96	mwf 	[62661, 64363] Reimplemented as IconSuite.
		06/11/96	Yanked out previous bogus fix.
		06/11/96	[1351362] Made sure resource is loaded in if it's purgable.
		05/07/96	Use enums for parameters of CTempHandleLock_AC constructor.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/17/96	InitUIcon
		04/15/96	Changed TIconSuite::ReleaseIcon to ReleaseIconSuite so it can be
							called from the destructor. Made all Releasexxx methods non-virtual
							since they were already called from destructors.
		----- Release 10 -----
		03/27/96	Switch last remaining Str255s to CStr255s_AC
		03/26/96	Cleanup references to gEmptyString
		03/26/96	CStr255_AC doesn't need to be set to empty.
		03/18/96	Remove compatibility hacks.
		03/11/96	Moved TIcon, TIconSuite and TSmallIcon to UDialog.more.cp
							from UDialog.cp to better balance the quantity of object code in each
		 12/8/95	Don't need to include UApplication. 
		----- 3.3 -----
		----- 3.3b1 -----
		 3/22/95	Add compatibility hacks for 2.0f1 headers. 
		 3/13/95	Change Free methods to destructors. 
*/