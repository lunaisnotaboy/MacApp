//----------------------------------------------------------------------------------------
// UFloatingTEManager.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/11/00	Cosmetic.
		08/30/00	Added embedded documentation.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef __UFLOATINGTEMGR__
#include "UFloatingTEManager.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

//========================================================================================
// CLASS TFloatingTEManager
//========================================================================================

//----------------------------------------------------------------------------------------
// TFloatingTEManager constructor
//----------------------------------------------------------------------------------------

TFloatingTEManager::TFloatingTEManager()
	:	fCache(NULL)
{
}

//----------------------------------------------------------------------------------------
// TFloatingTEManager destructor
//----------------------------------------------------------------------------------------

TFloatingTEManager::~TFloatingTEManager()
{
}

//----------------------------------------------------------------------------------------
// TFloatingTEManager::AcquireFloatingTE:
//----------------------------------------------------------------------------------------

TDialogTEView* TFloatingTEManager::AcquireFloatingTE()
// See TFloatingTEManager.
{
	return fCache ? fCache.release() : MakeDialogTEView();
}

//----------------------------------------------------------------------------------------
// TFloatingTEManager::MakeDialogTEView:
//----------------------------------------------------------------------------------------

TDialogTEView* TFloatingTEManager::MakeDialogTEView()
{
	TDialogTEView * aDialogTEView = NULL;

	if (qTemplateViews)
	{
		if (gDispatcher)
			aDialogTEView = dynamic_cast_AC(TDialogTEView*,TViewServer::fgViewServer->DoCreateViews(NULL, NULL, kDialogTEViewID, gZeroVPt));
		if (!aDialogTEView)
		{
#if qDebugMsg
			ProgramBreak_AC("Message from TFloatingTEManager::MakeDialogTEView. Did you forget to include Dialog.rsrc?\n");
#endif
		}
		else
			aDialogTEView->fMinAhead = 1;		// Don't _jump_ the view ahead when
												// autoscrolling for scrollselectionintoview
	}
	else	// !qTemplateViews
	{
		aDialogTEView = TH_new TDialogTEView(gZeroVPt, gZeroVPt, sizeRelSuperView, sizeVariable, gZeroVRect,
											 gSystemStyle, teFlushDefault, false);	// no autoWrap
	}
	aDialogTEView->AddToScroller();

	return aDialogTEView;
}

//----------------------------------------------------------------------------------------
// TFloatingTEManager::ReleaseFloatingTE:
//----------------------------------------------------------------------------------------

void TFloatingTEManager::ReleaseFloatingTE(TDialogTEView* aDialogTEView)
{
	fCache = aDialogTEView;
}

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/25/96	[1345531] Added missing includes for noload buids
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----

*/