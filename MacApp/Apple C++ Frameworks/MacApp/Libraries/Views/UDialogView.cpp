//----------------------------------------------------------------------------------------
// UDialogView.cp 
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		08/09/99	Changed MA_REGISTER_SIGNATURE to REGISTER_SIGNATURE_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __UDIALOGVIEW__
#include "UDialogView.h"
#endif

#ifndef __UMACAPPUTILITIES__
#include "UMacAppUtilities.h"
#endif

#ifndef __USTREAM__
#include "UStream.h"
#endif

#ifndef __UVIEW__
#include "UView.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UDIALOGBEHAVIOR__
#include "UDialogBehavior.h"
#endif

//========================================================================================
// GLOBAL Procedures
//========================================================================================
//----------------------------------------------------------------------------------------
// InitUDialogView: 
//----------------------------------------------------------------------------------------
void InitUDialogView()
{
	static bool UDialogViewInitialized;
	if (!UDialogViewInitialized)
	{	
		if (qTemplateViews)
		{
			REGISTER_SIGNATURE_AC(TDialogView, kStdDialogView);
			REGISTER_SIGNATURE_AC(TDialogBehavior, kStdDialogBehavior);
		}
	
		UDialogViewInitialized = true;
	}
}

//========================================================================================
// CLASS TDialogView
//========================================================================================
MA_DEFINE_CLASS(TDialogView);

//----------------------------------------------------------------------------------------
// TDialogView constructor
//----------------------------------------------------------------------------------------


TDialogView::TDialogView(const CViewPoint& itsLocation,
							  const CViewPoint& itsSize,
							  SizeDeterminer itsHSizeDet,
							  SizeDeterminer itsVSizeDet,
							  IDType itsDefItemID,
							  IDType itsCancelItemID) :
	TView(itsLocation, itsSize, itsHSizeDet, itsVSizeDet),

	fDefaultItem(itsDefItemID),
	fCancelItem(itsCancelItemID)
{
}

//----------------------------------------------------------------------------------------
// TDialogView destructor
//----------------------------------------------------------------------------------------


TDialogView::~TDialogView()
{
}

//----------------------------------------------------------------------------------------
// TDialogView::DoPostCreate: 
//----------------------------------------------------------------------------------------


void TDialogView::DoPostCreate(TDocument *itsDocument)	// Override
{
	TView::DoPostCreate(itsDocument);
	
	TWindow* theWindow = GetWindow();
	if (theWindow)
		theWindow->SetDialogItems(fDefaultItem,fCancelItem);
	
}

//----------------------------------------------------------------------------------------
// TDialogView::GetStandardSignature: 
//----------------------------------------------------------------------------------------


IDType TDialogView::GetStandardSignature() const	// Override 
{
	return kStdDialogView;
}

//----------------------------------------------------------------------------------------
// TDialogView::ReadFields: 
//----------------------------------------------------------------------------------------


void TDialogView::ReadFields(CStream_AC* aStream)	// Override 
{
	TView::ReadFields(aStream);

	fDefaultItem = aStream->ReadIDType();
	fCancelItem = aStream->ReadIDType();
}

//----------------------------------------------------------------------------------------
// TDialogView::WriteFields: 
//----------------------------------------------------------------------------------------


void TDialogView::WriteFields(CStream_AC* aStream) const	// Override 
{
	TView::WriteFields(aStream);

	aStream->WriteIDType(fDefaultItem);
	aStream->WriteIDType(fCancelItem);
}


/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	[1345531] Added missing includes for noload buids
		06/25/96	[1345531] Added missing includes for noload buids
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/15/96	Phase 1 of View Breakup changes
		----- Release 10 -----
		
*/