//----------------------------------------------------------------------------------------
// UWindowMenuBehavior.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/02/01	In UpdateWindowMenu, use a constant string instead of constructing
					a CStr2_AC. 
		01/11/01	Accomodate change to CString_AC in ShouldBeIncluded and
					UpdateWindowMenu.
		01/02/01	Update copyright.
		11/13/00	[PB] Change initialization order to match declaration. 
		04/21/00	Add logic to TWindowSortedList so it can be unsorted or sorted. 
					The old approach of making different list classes broke because
					CList_AC is not a CSortedList_AC anymore. 
		03/20/00	[2446400] Change iter.CurrentIndex test to == 1 in BuildWindowList.
		02/22/00	[W] Do not call MAGetMenu in TWindowMenuBehavior.  Implementations 
					not needed under Windows: DoMenuCommand, DoSetupMenus and
					UpdateWindowMenu.
		11/19/99	Use ::MacCheckMenuItem, not CheckMenuItem.
		10/25/99	Found one more occurance of AppendMenu_AC(); replaced with toolbox equivalent.
		10/21/99	Replace EnableItem and DisableItem with Enable/DisableMenuItems_AC().
		10/20/99	Replace AppendMenu_AC() with MacAppendMenu().
		09/29/99	Carbon:EnableMenuItem now MacEnableMenuItem.
		07/23/99	User CountMenuItems and CheckMenuItem instead of CountMItems
					and CheckItem.
		03/24/99	Update copyright notice.
		10/29/98	Use AppendMenu_AC.  Include MenuUtils_AC.h.  Use minPt and maxPt
					instead of min and max in GetMinMaxSize (it confused the compiler).
		10/27/98	Carbonize
*/

#ifndef __UWINDOWMENUBEHAVIOR__
#include "UWindowMenuBehavior.h"
#endif

// ACS

#ifndef __MenuUtils_AC__
#include "MenuUtils_AC.h"
#endif

// MacApp

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UDOCUMENT__
#include "UDocument.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

//================================================================================
// TWindowSortedList
//================================================================================

#undef Inherited
#define Inherited CSortedList_AC


MA_DEFINE_CLASS(TWindowSortedList);

//--------------------------------------------------------------------------------
// ~TWindowSortedList
//--------------------------------------------------------------------------------

TWindowSortedList::~TWindowSortedList()
{
}

//--------------------------------------------------------------------------------
// TWindowSortedList
//--------------------------------------------------------------------------------

TWindowSortedList::TWindowSortedList(bool sortByDocument) :
	fSortByDocument(sortByDocument)
{
}

//----------------------------------------------------------------------------------------
// Compare
//----------------------------------------------------------------------------------------

CompareResult_AC TWindowSortedList::Compare(const void* item1, const void* item2) const // override
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;
	//
	// Sort the windows alphabetically by title
	//
	const TWindow * window1 = static_cast<const TWindow*>(item1);
	const TWindow * window2 = static_cast<const TWindow*>(item2);

	CStr255_AC title1(window1->GetTitle());
	CStr255_AC title2(window2->GetTitle());

	if (fSortByDocument)
	{
		TDocument * doc1 = window1->GetDocument();
		TDocument * doc2 = window2->GetDocument();

		CStr255_AC docTitle1;
		CStr255_AC docTitle2;

		if (doc1)
			docTitle1 = doc1->GetTitle();

		if (doc2)
			docTitle2 = doc2->GetTitle();

		returnVal = ::RelString(docTitle1, docTitle2, false, true);
		if (returnVal == kItem1EqualItem2_AC)
			returnVal = RelString(title1, title2, false, true);
	}
	else
		returnVal = ::RelString(title1, title2, false, true);

	return returnVal;
}

//----------------------------------------------------------------------------------------
// DoSearchElement
//----------------------------------------------------------------------------------------

bool TWindowSortedList::DoSearchElement(CompareIndexType_AC testItem, void* yourDataPtr,
										ArrayIndex_AC& index) const // override
{
	if (fSortByDocument)
		return Inherited::DoSearchElement(testItem, yourDataPtr, index);
	else
		return CDynamicArray_AC::DoSearchElement(testItem, yourDataPtr, index);
}

//----------------------------------------------------------------------------------------
// InsertElementInOrder
//----------------------------------------------------------------------------------------

void TWindowSortedList::InsertElementInOrder(const void* elementPtr) // override
{
	if (fSortByDocument)
		Inherited::InsertElementInOrder(elementPtr);
	else
		CDynamicArray_AC::InsertElementInOrder(elementPtr);
}


//================================================================================
//	Class TWindowMenuBehavior
//================================================================================

#undef Inherited
#define Inherited TBehavior


MA_DEFINE_CLASS(TWindowMenuBehavior);

//--------------------------------------------------------------------------------
// TWindowMenuBehavior::TWindowMenuBehavior
//--------------------------------------------------------------------------------

TWindowMenuBehavior::TWindowMenuBehavior(IDType itsIdentifier,
										 ResNumber itsMenuNo,
										 EventNumber itsInvalidateEvent,
										 bool sortByDocument,
										 bool documentSeparators,
										 bool includeHidden)
	:	TBehavior(itsIdentifier),
		fWindowList(sortByDocument),
		fMenuNo(itsMenuNo),
		fInvalidateEvent(itsInvalidateEvent),
		fReserveMenuItems(0),
		fIncludeHidden(includeHidden),
		fDocumentSeparators(documentSeparators),
		fWindowMenuInvalid(true)
{
#if !qMSWindows
	//
	// Automatically reserve any pre-existing menu items so they don't get deleted
	//
	MenuHandle theMenu = MAGetMenu(fMenuNo);
	if (theMenu)
		fReserveMenuItems = CountMenuItems(theMenu);
#endif
}

//--------------------------------------------------------------------------------
// TWindowMenuBehavior::~TWindowMenuBehavior
//--------------------------------------------------------------------------------

TWindowMenuBehavior::~TWindowMenuBehavior()
{
}

//--------------------------------------------------------------------------------
// TWindowMenuBehavior::DoMenuCommand
//--------------------------------------------------------------------------------

void TWindowMenuBehavior::DoMenuCommand(CommandNumber aCommandNumber)
{
	//
	// Handle the Window Menu
	//
	bool tookIt = false;

#if qMSWindows
#pragma message ("TWindowMenuBehavior::DoMenuCommand: Is this needed under Windows?")
#else
	if (aCommandNumber < 0)
	{
		//
		// It must be from a non-MacApp menu so most likely the window menu
		//
		short menu;
		short item;
		CommandToMenuItem(aCommandNumber, menu, item);

		if (menu == fMenuNo)
			if ((item > fReserveMenuItems) && (item <= fReserveMenuItems + fWindowList.GetSize()))
			{
				tookIt = true;
				TWindow * aWindow = static_cast<TWindow*>(fWindowList.At((ArrayIndex_AC)(item) - fReserveMenuItems));
				aWindow->Show(true, kRedraw);
				aWindow->Select();
			}

	}
#endif

	if (!tookIt)
		Inherited::DoMenuCommand(aCommandNumber);
}


//--------------------------------------------------------------------------------
// TWindowMenuBehavior::DoSetupMenus
//--------------------------------------------------------------------------------

void TWindowMenuBehavior::DoSetupMenus()
{
	Inherited::DoSetupMenus();

#if qMSWindows
#pragma message ("TWindowMenuBehavior::DoSetupMenus: Is this needed under Windows?")
#else
	//
	// Handle the Window Menu if it needs updating
	//
	UpdateWindowMenu();

	//
	// Enable/Check all the appropriate items
	//
	MenuHandle theMenu = TMenuBarManager::GetMenuHandle(fMenuNo);
	if (theMenu)
		for (TemplateIterator_AC<TWindow *> iter(&fWindowList); iter.CurrentIndex(); ++iter)
			if (iter) // NULL items are for separators
			{
				short itemNumber = static_cast<short>(iter.CurrentIndex() + fReserveMenuItems);

				EnableMenuItems_AC(theMenu, itemNumber);

				::MacCheckMenuItem(theMenu, itemNumber, (*iter).IsActive());
			}
#endif
}


//--------------------------------------------------------------------------------
// TWindowMenuBehavior::InvalidateWindowMenu
//--------------------------------------------------------------------------------

void TWindowMenuBehavior::InvalidateWindowMenu()
{
	//
	// Set the flag to indicate if the window menu needs updating
	//
	fWindowMenuInvalid = true;

	//
	// Make sure the menu title stays in synch
	//
	TMenuBarManager::InvalidateMenus();
}

//--------------------------------------------------------------------------------
// TWindowMenuBehavior::ShouldBeIncluded
//--------------------------------------------------------------------------------

bool TWindowMenuBehavior::ShouldBeIncluded(TWindow* theWindow) const
{
	bool returnVal = true;

	if ((theWindow->IsShown() || fIncludeHidden) && !theWindow->GetFloats())
	{
		if (theWindow->GetTitle().empty())					// skip blank titles
			returnVal = false;
	}
	else
		returnVal = false;

	return returnVal;
}

//--------------------------------------------------------------------------------
// TWindowMenuBehavior::BuildWindowList
//--------------------------------------------------------------------------------

void TWindowMenuBehavior::BuildWindowList()
{
	fWindowList.DeleteAll();

	if (fDocumentSeparators)
	{
		for (CDocumentIterator iter(gDispatcher); iter; ++iter)
		{
			if (iter.CurrentIndex() == 1 && (*iter).GetWindowList()->GetSize() >= 1)
				fWindowList.Insert(NULL);			//  Placeholder for menu list section separator.

			// Add all the windows for this DSP.
			CWindowIterator winIter(iter);
			for (TWindow * theWindow = winIter; winIter.Current(); theWindow = ++winIter)
				if (theWindow && ShouldBeIncluded(theWindow))
					fWindowList.Insert(theWindow);
		}
	}
	else
	{
		CWMgrIterator iter;
		for (WindowPtr aWindowPtr = iter.FirstWMgrWindow(); iter.Current(); aWindowPtr = iter.NextWMgrWindow())
		{
			TWindow * theWindow = TWindow::WMgrToWindow(aWindowPtr);
			if (theWindow && ShouldBeIncluded(theWindow))
				fWindowList.Insert(theWindow);
		}
	}
}

//--------------------------------------------------------------------------------
// TWindowMenuBehavior UpdateWindowMenu
//--------------------------------------------------------------------------------

void TWindowMenuBehavior::UpdateWindowMenu()
{
#if qMSWindows
#pragma message ("TWindowMenuBehavior::UpdateWindowMenu: Is this needed under windows?")
#else
	if (IsWindowMenuInvalid())
	{
		MenuHandle theMenu = TMenuBarManager::GetMenuHandle(fMenuNo);
		if (theMenu)
		{
			//
			// reconstruct the window list. It is composed of the window manager's window list,
			// Filter the list while constructing it
			//
			//
			// clear the menu from the list
			//
			for (short loop = static_cast<short>(fWindowList.GetSize() + fReserveMenuItems); loop > fReserveMenuItems; --loop)
				DeleteMenuItem(theMenu, loop);

			BuildWindowList();

			//
			// rebuild the menu from the new list
			//
			for (TemplateIterator_AC<TWindow *> iter2(&fWindowList); iter2.CurrentIndex() != kEmptyIndex_AC; ++iter2)
				if (iter2)
				{
					// Put a blank string so as to handle special characters
					::MacAppendMenu(theMenu, "\p ");
					
					short itemNumber = static_cast<short>(iter2.CurrentIndex() + fReserveMenuItems);

					SetMenuItemText(theMenu, itemNumber, CStr255_AC((*iter2).GetTitle()));
				}
				else
					::MacAppendMenu(theMenu, CStr2_AC("-"));		//  Add separator between window groups in menu.

			ValidateWindowMenu();					// We just updated it so it's clean
		}
	}
#endif
}


//--------------------------------------------------------------------------------
// TWindowMenuBehavior DoToolboxEvent
//--------------------------------------------------------------------------------

bool TWindowMenuBehavior::DoToolboxEvent(TToolboxEvent* event)
{
	if (event->GetWhat() == activateEvt)
		InvalidateWindowMenu();

	return Inherited::DoToolboxEvent(event);
}


//--------------------------------------------------------------------------------
// TWindowMenuBehavior DoEvent
//--------------------------------------------------------------------------------

void TWindowMenuBehavior::DoEvent(EventNumber eventNumber,
											TEventHandler* source,
											TEvent* event)
{
	if (eventNumber == fInvalidateEvent)
		InvalidateWindowMenu();
	else if ((eventNumber == mBecameTarget || eventNumber == mResignedTarget) && source == fOwner)
		InvalidateWindowMenu();
	else
		Inherited::DoEvent(eventNumber, source, event);
}


// -----------------------------------------------------------------------------------------
//	TWindowBehavior::GetMinMaxSize
// -----------------------------------------------------------------------------------------

void TWindowMenuBehavior::GetMinMaxSize(CLongPoint_AC& minSize,
										   CLongPoint_AC& maxSize,
										   CSortedList_AC* windowList)
{
	//
	// return in minSize: the largest minimum window size
	//		  in maxSize: the smallest maximum window size
	//
	maxSize.Set(kMaxLong, kMaxLong);
	minSize.Clear();
	for (TemplateIterator_AC<TWindow *>iter(windowList); iter; ++iter)
		if (ShouldBeIncluded(iter))
		{
			CLongPoint_AC minPt((*iter).GetResizeLimits()[topLeft]);
			if (minPt > minSize)
				minSize = minPt;
	
			CLongPoint_AC maxPt((*iter).GetResizeLimits()[botRight]);
			if (maxPt < maxSize)
				maxSize = maxPt;
		}
}
