//----------------------------------------------------------------------------------------
// TokenTools.cpp
// Copyright © 1996-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		10/14/99	Added SkipPastCRLF and SkipToCRLF.  Added some consts.
		10/13/99	Adopted by MacApp.

	Originally written by:	the cyberdogs
*/

#ifndef __TokenTools__
#include "TokenTools.h"
#endif

// Network

#ifndef __ASCII__
#include "ASCII.h"
#endif

// Toolbox

#include <OSUtils.h>

// ANSI

#ifndef _CTYPE_H
#include <ctype.h>
#endif

#ifndef _STDLIB_H
#include <stdlib.h>
#endif

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STRING_H
#include <string.h>
#endif


//----------------------------------------------------------------------------------------
// IsSingleByteType
//----------------------------------------------------------------------------------------

static bool IsSingleByteType(const CConstTextToken& textToken, ScriptCode script)
{
	Ptr text = (Ptr) textToken.get();
	return CharacterByteType(text, 0, script) == smSingleByte;
}


//----------------------------------------------------------------------------------------
// IsToken
//----------------------------------------------------------------------------------------

static bool IsToken(char c, const char* tokens)
{
	const char* t = tokens;
	while (*t && (c != *t))
		++t;
	
	return *t;
}

//----------------------------------------------------------------------------------------
// FindToken
//----------------------------------------------------------------------------------------

CConstTextToken FindToken(CConstTextToken text, const char* tokens)
{
	char c;
	while (((c = *text) != 0) && !IsToken(c, tokens))
		++text;
	
	return text;
}

//----------------------------------------------------------------------------------------
// FindTokenWS
//----------------------------------------------------------------------------------------

CConstTextToken FindTokenWS(CConstTextToken text, const char* tokens, ScriptCode sc)
{
	char c;
	while ((c = *text) != 0)
	{
		bool isSingle = IsSingleByteType(text, sc);
		if (isSingle && IsToken(c, tokens))
			break;

		text += isSingle ? 1 : 2;
	}
	
	return text;
}

//----------------------------------------------------------------------------------------
// FindTokenInBuffer
//----------------------------------------------------------------------------------------

CConstTextToken FindTokenInBuffer(CConstTextToken text, char token)
{
	char c;
	while (((c = *text) != 0) && (c != token))
		++text;
		
	return text;
}

//----------------------------------------------------------------------------------------
// FindNoSpacePrintASCIIToken
//----------------------------------------------------------------------------------------

CConstTextToken FindNoSpacePrintASCIIToken(CConstTextToken text)
{
	char c;
	while (((c = *text) != 0) && (c < 0x21))
		++text;

	return text;
}

//----------------------------------------------------------------------------------------
// FindHexDigit
//----------------------------------------------------------------------------------------

CConstTextToken FindHexDigit(CConstTextToken text)
{
	char c;
	while (((c = *text) != 0) && !isxdigit(c))
		++text;
	
	return text;
}

//----------------------------------------------------------------------------------------
// SkipSpaceAndTabs
//----------------------------------------------------------------------------------------

CConstTextToken SkipSpaceAndTabs(CConstTextToken text)
{
	char c;
	while (((c = *text) == ' ') || (c == '\t'))
		++text;
	
	return text;
}

//----------------------------------------------------------------------------------------
// SkipSpaceAndTabsWS
//----------------------------------------------------------------------------------------

CConstTextToken SkipSpaceAndTabsWS(CConstTextToken text, ScriptCode sc)
{
	char c;
	while ((((c = *text) == ' ') || (c == '\t')) && IsSingleByteType(text, sc))
		++text;

	return text;
}

//----------------------------------------------------------------------------------------
// SkipSpaceAndTabsAndReturns
//----------------------------------------------------------------------------------------

CConstTextToken SkipSpaceAndTabsAndReturns(CConstTextToken text)
{
	char c;
	while (((c = *text) == ' ') || (c == '\t') || (c == 13))
		++text;

	return text;
}


//----------------------------------------------------------------------------------------
// SkipReturnsAndLineFeeds
//----------------------------------------------------------------------------------------

CConstTextToken SkipReturnsAndLineFeeds(CConstTextToken text)
{
	char c;
	while (((c = *text) == kLFChar) || (c == 13))
		++text;

	return text;
}


//----------------------------------------------------------------------------------------
// SkipToSpaceOrTab
//----------------------------------------------------------------------------------------

CConstTextToken SkipToSpaceOrTab(CConstTextToken text)
{
	return FindToken(text, " \t");
}

//----------------------------------------------------------------------------------------
// SkipToSpaceOrTabOrReturn
//----------------------------------------------------------------------------------------

CConstTextToken SkipToSpaceOrTabOrReturn(CConstTextToken text)
{
	return FindToken(text, " \t\13");
}

//----------------------------------------------------------------------------------------
// SkipToSpaceOrTabOrReturnWS
//----------------------------------------------------------------------------------------

CConstTextToken SkipToSpaceOrTabOrReturnWS(CConstTextToken text, ScriptCode sc)
{
	return FindTokenWS(text, " \t\13", sc);
}

//----------------------------------------------------------------------------------------
// SkipToEndOfLine
//----------------------------------------------------------------------------------------

CConstTextToken SkipToEndOfLine(CConstTextToken text)
{
	return FindToken(text, "\13\10");
}

//----------------------------------------------------------------------------------------
// SkipPastCRLF
//----------------------------------------------------------------------------------------

CConstTextToken SkipPastCRLF(CConstTextToken text)
{
	text = SkipToCRLF(text);

	if ((text[0] == 13) && (text[1] == 10))
		text += 2;

	return text;
}

//----------------------------------------------------------------------------------------
// SkipToCRLF
//----------------------------------------------------------------------------------------

CConstTextToken SkipToCRLF(CConstTextToken text)
{
	char c;
	while (((c = *text) != 0) && ((c != 13) || (text[1] != 10)))
		++text;

	return text;
}

//----------------------------------------------------------------------------------------
// SkipControlChars
//----------------------------------------------------------------------------------------

CConstTextToken SkipControlChars(CConstTextToken text)
{
	char c;
	while (((c = *text) != 0) && (c < kSpace))
		++text;

	return text;
}

//----------------------------------------------------------------------------------------
// ParseSymbol
//----------------------------------------------------------------------------------------

CConstTextToken ParseSymbol(CConstTextToken text, CConstTextToken* symbol)
{
	// now we've got the symbol start
	*symbol = text;

	char c;
	while ((((c = *text) >= 'A') && (c <= 'Z')) || ((c >= 'a') && (c <= 'z')) ||
		   ((c >= '0') && (c <= '9')) || (c == '.') || (c == '-'))
		++text;

	symbol->SetLength(text - *symbol);

	return text;
}

//----------------------------------------------------------------------------------------
// ParseValue
//----------------------------------------------------------------------------------------

CConstTextToken ParseValue(CConstTextToken text, CConstTextToken* value,
						   const char* except, bool quoteLiteral)
{
	char quoteChar = '\0';

	char c = *text;

	// check if we're a quoted value
	if ((c == '\"') || (c == '\''))
	{
		quoteChar = c;	// save quote char
		c = *(++text);	// value starts at next character
	}

	// now we've got the value start
	*value = text;

	// if we're quoted, the value ends at the closing quote,
	// else it ends at the first character that'c less than or equal to a space or in except.
	if (quoteChar != '\0')
	{
		if (except && !quoteLiteral)
		{
			while (c && (c != quoteChar) && !strchr(except, c))
				c = *(++text);
		}
		else
		{
			while (c && (c != quoteChar))
				c = *(++text);
		}
	}
	else if (except)
	{
		while ((c > ' ') && !strchr(except, c))
			c = *(++text);
	}
	else
	{
		while (c > ' ')
			c = *(++text);
	}

	value->SetLength(text - *value);

	// Skip the closing quote, if there was one.
	if (quoteChar && (c == quoteChar))
		++text;

	return text;
}

//----------------------------------------------------------------------------------------
// ParseInteger
//----------------------------------------------------------------------------------------

CConstTextToken ParseInteger(CConstTextToken text, unsigned long* result)
{
	long number = 0;
	
	char c;
	while (isdigit(c = *text))
	{
		number = number * 10 + (c - '0');
		++text;
	}
	
	*result = number;
	return text;
}

//----------------------------------------------------------------------------------------
// ParseHexDigits
//----------------------------------------------------------------------------------------

CConstTextToken ParseHexDigits(CConstTextToken text, unsigned long* result)
{
	unsigned long number = 0;

	char c;
	while ((c = *text) != 0)
	{
		int digit = c - '0';
		if (digit < 0)
			break;
		
		if (digit > 9)
		{
			digit = c - 'A' + 10;
			if (digit < 0)
				break;
			
			if (digit > 15)
			{
				digit = c - 'a' + 10;
				if ((digit < 0) || (digit > 15))
					break;
			}
		}

		number = (number << 4) + digit;
		++text;
	}
	
	*result = number;
	return text;
}

//----------------------------------------------------------------------------------------
// IsAllWhiteSpace
//----------------------------------------------------------------------------------------

bool IsAllWhiteSpace(CConstTextToken text)
{
	char c;
	while (isspace(c = *text))
		++text;
	
	return !c;
}


//----------------------------------------------------------------------------------------
// End of TokenTools.cpp
