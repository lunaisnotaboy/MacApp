/*
	File:		CharsetUtils.cp

	Contains:	xxx put contents here xxx

	Written by:	the cyberdogs

	Copyright © 1996-2000 by Apple Computer, Inc., all rights reserved.

	Change History (most recent first):

		 <1>	 8/22/96	SKO		Move to 1.2
		 <3>	 3/18/96	jse		move some stuff to Decoders.h/.cpp
		 <2>	 1/28/96	pvc		Add shift-jis and mac-roman to understood charsets

	To Do:
*/

#ifndef __CharsetUtils__
#include "CharsetUtils.h"
#endif

IndexTableEntry gMIMECharsetIndexTable[] =
				  {{"ISO-8859-1",		kMIMEISO88591Charset},
				   {"ISO-8859-2",		kMIMEISO88592Charset},
				   {"ISO-8859-3",		kMIMEISO88593Charset},
				   {"ISO-8859-4",		kMIMEISO88594Charset},
				   {"ISO-8859-5",		kMIMEISO88595Charset},
				   {"ISO-8859-6",		kMIMEISO88596Charset},
				   {"ISO-8859-7",		kMIMEISO88597Charset},
				   {"ISO-8859-8",		kMIMEISO88598Charset},
				   {"ISO-8859-9",		kMIMEISO88599Charset},
				   {"US-ASCII",			kMIMEASCIICharset},
				   {"X-SJIS",			kMIMEShiftJISCharset},
				   {"X-MAC-ROMAN",		kMIMEMacRomanCharset} };

const short gMIMECharsetIndexTableSize = sizeof(gMIMECharsetIndexTable) / sizeof(IndexTableEntry);

const char gLatinOneToMacRomanTable[] = "•™≠∞≥∑∫Ω√≈…—‘Ÿ⁄∂∆Œ‚„‰ˆ˜˘˙˚˝˛ˇıƒ ¡¢£€¥œ§¨©ª«¬–®¯°±”“´µ¶·¸’º»π∏≤¿ÀÁÂÃÄÅÆÇÈÉÊËÌÍÎÏ‹ÑÒÓÔÕÖ◊ØÙÚÛÜ†ﬁßàáâãäåæçèéêëìíîï›ñòóôõö÷øùúûü‡ﬂÿ";
const char gMacRomanToLatinOneTable[] = "ƒ≈«…—÷‹·‡‚‰„ÂÁÈËÍÎÌÏÓÔÒÛÚÙˆı˙˘˚¸›∞¢£ßÄ∂ﬂÆ©Å¥®Ç∆ÿÉ±æÑ•µèÖΩºÜ™∫áÊ¯ø°¨àüâê´ªä†¿√’ë¶≠ã≥≤åπ˜◊ˇçé§–ﬁ˛˝∑íìî¬ ¡À»ÕŒœÃ”‘ï“⁄€ŸûñóØòôö∏õúù";


//===========================================================
// Main charset utils
//===========================================================

void
ConvertLatinOneToMacRoman( char * data, long len )
	{
	unsigned char * ptr = (unsigned char *) data;
	
	while ( len > 0 )
		{
		if ( (*ptr) >= 128 )
			{
			*ptr =  gLatinOneToMacRomanTable[*ptr - 128];
			}
		ptr++;
		len--;
		}
	}
	
void
ConvertMacRomanToLatinOne( char * data, long len )
	{
	unsigned char * ptr = (unsigned char *) data;
	
	while ( len > 0 )
		{
		if ( (*ptr) >= 128 )
			{
			*ptr =  gMacRomanToLatinOneTable[*ptr - 128];
			}
		ptr++;
		len--;
		}
	}
	
Boolean
CharsetHasPreferredScript( short charset, short * script )
	{
	switch ( charset )
		{
		case kMIMEISO88591Charset:
		case kMIMEMacRomanCharset:
			*script = smRoman;
			return true;
			
		case kMIMEShiftJISCharset:
			*script = smJapanese;
			return true;

		}

	*script = smRoman; // just to have some value here
	return false;
	}


