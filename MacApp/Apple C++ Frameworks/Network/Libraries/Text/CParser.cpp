//----------------------------------------------------------------------------------------
// CParser.cpp
// Copyright � 1999-2000 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		10/13/00	CWP6 support: namespacing. 
		04/20/00	Move CTerm and CToken back here. 
		04/18/00	Remove CTypeCatcherTerm and CTypeCatcherToken. The type catcher
							was not being used and it was the only token that changed its 
							identifier. 
							Remove parse namespace. 
		04/17/00	Rename nodes to terms. Remove string versions of Parse. 
							Move CTerm and CToken to their own units. 
		12/02/99	Remove all the subterms and make a set without any 
							duplicates before deleting. 
							Un-inline the destructors so it will be easier to debug them. 
		11/30/99	Fixed FirstSubToken so it doesn't crash if there
							are no sub-tokens. 
		11/29/99	Dump tokens. 
		11/03/99	Do not declare sfDebugID if non-debug.
		10/29/99	Added FindNextSiblingToken.  Tuned GetSiblingToken.
		10/26/99	Rework to handle cycles.  Changed fActSubMatch to a
							local variable of the Parse function, actSubMatch.
							Save and restore fActualMatch in Parse functions.
							Added FindSiblingToken.
		10/20/99	Added CParseNub which is a generic parse term that
							can create a generic token in the resulting tree.
		10/18/99	Added NthSubToken.
		10/13/99	Add CTextPtr-style parsing.
		10/08/99	Add ordered processing option for subterms in
							CTerm::Parse.  Moved in implementation of
							AddSubTerm and set min/max matching values.
		10/05/99	Start all enums with 'e' rather than 'sc'.
		10/01/99	Added GetSiblingToken.  Added some additional guard
							checks before processing a parse term.  Test localOffset
							against string size as well as string::npos in 
							CLiteralTerm::Parse.
		09/27/99	Yet another major modification in approach.
		09/22/99	Changed include of CReporter_AC.h to CStdReporter_AC.h.
		09/16/99	Added a new case in CParseStream::Receive for debugging.
		09/08/99	Created.
*/

#ifndef __CParser__
#include "CParser.h"
#endif

// Network

// ACS

#ifndef __CStdReporter_AC__
#include "CStdReporter_AC.h"
#endif

#if qDebug && qMacApp
	#ifndef __CCharOutputSink_AC__
	#include "CCharOutputSink_AC.h"
	#endif
#endif

#ifndef __ParseTools__
#include "ParseTools.h"
#endif



//----------------------------------------------------------------------------------------
// Static Instantiation
//----------------------------------------------------------------------------------------

#if qDebug
unsigned short	CTerm::sfDebugID	= 42;	// The static holder of the next debug id.
#endif

//----------------------------------------------------------------------------------------
// NotFulfilled
//----------------------------------------------------------------------------------------

class NotFulfilled
// NotFulfilled is an iterator helper class which tests a 
// subterm to see if it considers itself as completely satisfied.
{
public:
	NotFulfilled() { }
	
	bool operator()(CTerm* aSubTerm)
		{ return !aSubTerm->Fulfilled(); }
};

//----------------------------------------------------------------------------------------
// NotSatisfied
//----------------------------------------------------------------------------------------

class NotSatisfied
// NotSatisfied is an iterator helper class which tests a 
// subterm to see if it considers itself as unsatisfied.
{
public:
	NotSatisfied() { }
	
	bool operator()(CTerm* aSubTerm)
		{ return !aSubTerm->Satisfied(); }
};


//========================================================================================
// ResetSubTerm
//========================================================================================

class ResetSubTerm
// ResetSubTerm is an iterator helper class which resets a subterm.
{
public:
	ResetSubTerm() { }
	void operator()(CTerm* aSubTerm) const;
};

//----------------------------------------------------------------------------------------
// ResetSubTerm::operator()
//----------------------------------------------------------------------------------------

void ResetSubTerm::operator()(CTerm* aSubTerm) const
{
	aSubTerm->Reset();
}

//========================================================================================
// CTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// ctor
//----------------------------------------------------------------------------------------

CTerm::CTerm(	unsigned short	minimumMatch,
				unsigned short	maximumMatch,
				IDType			identifier,
				unsigned short	minSubMatch,
				unsigned short	maxSubMatch,
				IDType			notifyID,
				ParseOrdering	ordered,
				WhiteSpace		skipWhiteSpace)
	:	fMinimumMatch(minimumMatch),
		fMaximumMatch(maximumMatch),
		fActualMatch(0),
		fIdentifier(identifier),
		fMinSubMatch(minSubMatch),
		fMaxSubMatch(maxSubMatch),
		fNotifyID(notifyID),
		fOrdered(ordered),
		fSkipWhiteSpace(skipWhiteSpace)
#if qDebug
		, fDebugID(sfDebugID++)
#endif
		//, fParent(NULL)
{
}

CTerm::CTerm(	IDType			identifier,
				IDType			notifyID,
				ParseOrdering	ordered,
				WhiteSpace		skipWhiteSpace)
	:	fMinimumMatch(1),
		fMaximumMatch(1),
		fActualMatch(0),
		fIdentifier(identifier),
		fMinSubMatch(0),
		fMaxSubMatch(32767),
		fNotifyID(notifyID),
		fOrdered(ordered),
		fSkipWhiteSpace(skipWhiteSpace)
#if qDebug
		, fDebugID(sfDebugID++)
#endif
		//, fParent(NULL)
{
}

CTerm::CTerm()
	:	fMinimumMatch(1),
		fMaximumMatch(1),
		fActualMatch(0),
		fIdentifier(kNoIdentifier_AC),
		fMinSubMatch(0),
		fMaxSubMatch(32767),
		fNotifyID(kNoIdentifier_AC),
		fOrdered(eNotOrdered),
		fSkipWhiteSpace(eSkipWhiteSpace)
#if qDebug
		, fDebugID(sfDebugID++)
#endif
		//, fParent(NULL)
{
}

//----------------------------------------------------------------------------------------
// dtor
//----------------------------------------------------------------------------------------

CTerm::~CTerm()
{
	if (!fSubTerms.empty())
	{
		// Move all the subterms to a list that excludes duplicates. 
		CTermSet terms;
		ReleaseSubTerms(terms);

		// Now we can really delete them. 
		for (CTermSet::iterator iter = terms.begin(); iter != terms.end(); ++iter)
		{
			if (*iter != this)
				delete *iter;
		}
	}
}

//----------------------------------------------------------------------------------------
// ReleaseSubTerms
//----------------------------------------------------------------------------------------

void CTerm::ReleaseSubTerms(CTermSet& terms)
{
	while (!fSubTerms.empty())
	{
		CTerm* aTerm = fSubTerms.back();
		fSubTerms.pop_back();
		terms.insert(aTerm);
		aTerm->ReleaseSubTerms(terms);
	}
}

//----------------------------------------------------------------------------------------
// AddSubTerm
//----------------------------------------------------------------------------------------

void CTerm::AddSubTerm(CTerm* 	aSubTerm, 
						unsigned short	minimumMatch, 
						unsigned short	maximumMatch)
// AddSubTerm adds the given subterm to this subterm at the end of
// the current list of subterms.  Also set the fMinimumMatch and fMaximumMatch
// value if both are not zero.
//
// aSubTerm:		The subterm to be added to the end of our list of subterms.
// minimumMatch:	The minimum number of times the subterm must be matched
//					for the parse to be successful.
// maximumMatch:	The maximum number of times the subterm can be matched
//					for the parse to be successful.
{ 
#if qDebug
	ThrowIfNULL_AC(aSubTerm);
#endif
	if (aSubTerm)
	{
		fSubTerms.push_back(aSubTerm);
		
		// Have to detect cycles before setting parent.
		//aSubTerm->SetParent(this);
		
		if (minimumMatch != 0 || maximumMatch != 0)
		{
			aSubTerm->SetMinimumMatch(minimumMatch);
			aSubTerm->SetMaximumMatch(maximumMatch);
		}
	}
}

//----------------------------------------------------------------------------------------
// Parse
//----------------------------------------------------------------------------------------

bool CTerm::Parse(	CTextPtr&	textPtr,
					CToken*		parentToken)
{
	bool			success = true;				// Default to return true if no subterms.
	CTextPtr		localTextPtr = textPtr;
	unsigned short	actSubMatch;				// Actual number of subs which matched.
	unsigned short	actualMatch = fActualMatch;	// Save in case of cycles.
	
	if (fSubTerms.size())						// Don't do anything if there are no subnoes.
	{
		success = false;
		bool				done = false;
		
		// Reset all of our subterms.
		ResetSubTerms();
		actSubMatch = 0;	// Reset our count.
		
		if (fOrdered)
		{
			// This is an ordered scan of subterms (which is not the default case).

			// We iterate through the subterms but it's not just a simple iteration
			// because we have to allow each subterm a chance to match multiple times
			// if their match parameters so indicate.  So we repeat each subterm until
			// it either doesn't match or it has been matched the maximum number of
			// times.  We can tell if the parse has failed if we try to move off of a
			// subterm which has not been satisfied or if we have any subterms not
			// parsed yet which are not satisfied (i.e. they are optional).
			bool						subTermMatched = false;
			bool						scanning = true;
			CTermList::iterator	iSubTerm = fSubTerms.begin();
			
			success = true;

			while (success && iSubTerm != fSubTerms.end() && !localTextPtr.AtEnd())
			{
				if ((*iSubTerm)->Parse(localTextPtr, parentToken))
				{
					// If this subterm is satisfied then we'll move on to the next subterm.
					if ((*iSubTerm)->Fulfilled())
						iSubTerm++;
				}
				else
				{
					// The current subterm didn't parse so we've failed if the
					// current subterm wasn't satisfied.
					if ((*iSubTerm)->Satisfied())
						iSubTerm++;
					else
						success = false;
				}
			}
			
			// If there are subterms left which are not satisfied then we failed.
			while (success && iSubTerm != fSubTerms.end())
			{
				success = ((*iSubTerm)->Satisfied());
				iSubTerm++;
			}
		
		}
		else
		{
			// This is an unordered scan of subterms (which is the default case).
			while (!done)
			{
				// Start with the first subterm which isn't fulfilled and scan
				// through them until we find one that matches -- or dont'.
				bool						subTermMatched = false;
				bool						scanning = true;
				CTermList::iterator	iSubTerm;
				iSubTerm = find_if(fSubTerms.begin(), fSubTerms.end(), NotFulfilled());
				
				while (scanning)
				{
					if (iSubTerm != fSubTerms.end())
					{
						subTermMatched = (*iSubTerm)->Parse(localTextPtr, parentToken);
						if (subTermMatched)
						{
							scanning = false;
							actSubMatch++;		// Count this match.
						}
						else
						{
							iSubTerm++;
							iSubTerm = find_if(iSubTerm, fSubTerms.end(), NotFulfilled());
						}
					}
					else
						scanning = false;
				}
		
				// We are done if we found a spot which doesn't match any subterm, we 
				// are at the end of the input string, or we've matched the maximum
				// number of subterms.  This is not an error unless some required
				// subterms were not satisfied.
				done = (iSubTerm == fSubTerms.end()
						|| localTextPtr.AtEnd()
						|| actSubMatch >= fMaxSubMatch);
			}
		}
	
		// Have all requires subterms been satisfied and have the required number
		// of subterms been satisfied?
#if qDebug
		// A little debugging aid here so that we can discover which term is not
		// satisfied when we expected it to be.
		CTermList::iterator	unsatisfiedIter = find_if(fSubTerms.begin(), fSubTerms.end(), NotSatisfied());
		if (unsatisfiedIter != fSubTerms.end() || actSubMatch < fMinSubMatch)
		{
			// Inspect unsatisfiedTerm and actSubMatch and fMinSubMatch.
			CTerm*		unsatisfiedTerm = *unsatisfiedIter;
		}
		else
			success = true;
#else
		if (find_if(fSubTerms.begin(), fSubTerms.end(), NotSatisfied())
			  == fSubTerms.end()
			&& actSubMatch >= fMinSubMatch)
			// Yes, everything is cool.
			success = true;
#endif
	}
	
	fActualMatch = actualMatch;		// Restore our state regardless of success.

	if (success)
	{
		// Yes, we're satisfied and succeeded.  If our token has a notifier ID
		// then we want to send out a notification.
		success = true;
		fActualMatch++;
		textPtr = localTextPtr;
		if (fNotifyID != kNoIdentifier_AC && parentToken)
			parentToken->DoNotification();
	}
	
	return success;
}

//----------------------------------------------------------------------------------------
// SkipWhiteSpace
//----------------------------------------------------------------------------------------

bool CTerm::SkipWhiteSpace(CTextPtr& textPtr) const
// SkipWhiteSpace simply skips over any whitespace beginning at textPtr.  A
// true is returned if any whitespace was actually skipped.
{
	CTextPtr	oldTextPtr = textPtr;

	if (!textPtr.AtEnd())		// Make sure there's something to skip.
	{
		const string whiteSpace(" \t");
		char*	nonWhitespace = SkipSpaceAndTabs(textPtr);
		textPtr = textPtr + (nonWhitespace - textPtr.get());
	}
	
	return (textPtr != oldTextPtr);
}

//----------------------------------------------------------------------------------------
// ResetSubTerms
//----------------------------------------------------------------------------------------

void CTerm::ResetSubTerms()
{
	for_each(fSubTerms.begin(), fSubTerms.end(), ResetSubTerm());
}


//========================================================================================
// DeleteToken
//========================================================================================

class DeleteToken
// DeleteToken is an iterator helper class which deletes a Token.
{
public:
	DeleteToken() { }
	void operator()(CToken* aToken) const;
};

//----------------------------------------------------------------------------------------
// CToken::FindParentToken
//----------------------------------------------------------------------------------------

void DeleteToken::operator()(CToken* aToken) const
{
	delete aToken;
}

//========================================================================================
// CToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CToken::ctor
//----------------------------------------------------------------------------------------

CToken::CToken(CToken* parent, CTerm* term)
	:	fParent(parent),
		fParseTerm(term),
		//fIdentifier(kNoIdentifier_AC),
		//fNotifyID(kNoIdentifier_AC),
		fThrowAway(false)
{
	if (parent)
		parent->AddSubToken(this);
}

//----------------------------------------------------------------------------------------
// CToken::dtor
//----------------------------------------------------------------------------------------

CToken::~CToken()
{
	if (fParent)
		fParent->RemoveSubToken(this);
	
	// Delete subtokens in reverse order so that other iterators
	// don't get messed up.
	for_each(fTokens.rbegin(), fTokens.rend(), DeleteToken());
}

//----------------------------------------------------------------------------------------
// CToken::GetNotifyID
//----------------------------------------------------------------------------------------

IDType CToken::GetNotifyID() const
{
	return fParseTerm ? fParseTerm->GetNotifyID() : kNoIdentifier_AC;
}

//----------------------------------------------------------------------------------------
// CToken::GetIdentifier
//----------------------------------------------------------------------------------------

IDType CToken::GetIdentifier() const
{
	return fParseTerm ? fParseTerm->GetIdentifier() : kNoIdentifier_AC;
}

//----------------------------------------------------------------------------------------
// CToken::DoNotification
//----------------------------------------------------------------------------------------

void CToken::DoNotification()
// DoNotification determines if notification should be performed (by checking
// to see if there is an fNotifyID) and notifies the parent token.
{
	if (fParent)
		fParent->HandleNotification(this);
	// ���  I suspect more must be done here.  I.e. determine if the term
	// ought to be kept.
}

//----------------------------------------------------------------------------------------
// CToken::FindParentToken
//----------------------------------------------------------------------------------------

CToken* CToken::FindParentToken(const IDType tokenID) const
// FindParentToken locates the our parent token with the given identifier.
//
// tokenID:	The identifier of the token which we desire to locate.
{
	CToken*		aParentToken = fParent;
	
	while (aParentToken && aParentToken->GetIdentifier() != tokenID)
		aParentToken = aParentToken->GetParentToken();
	
	return aParentToken;
}
		
//----------------------------------------------------------------------------------------
// CToken::NthSubToken
//----------------------------------------------------------------------------------------

CToken* CToken::NthSubToken(unsigned short n) const
// NthSubToken locates a subtoken by index.
//
// n:	The index of the token which we desire.  The index
//		is zero based.
{
	CToken*		aSubToken = NULL;

	CConstTokenListIterator	aSubTokenIter = fTokens.begin();
	while (n && aSubTokenIter != fTokens.end())
	{
		aSubTokenIter++;
		--n;
	}
	if (aSubTokenIter != fTokens.end())
		aSubToken = *aSubTokenIter;
	
	return aSubToken;
}
		
//----------------------------------------------------------------------------------------
// CToken::FindSubToken
//----------------------------------------------------------------------------------------

CToken* CToken::FindSubToken(const IDType tokenID, bool recurse) const
// FindSubToken locates the subtoken with the given identifier.
//
// tokenID:	The identifier of the token which we desire to locate.
// recurse:	True if the search is to go through all levels of the tree.
{
	CToken*					aSubToken = NULL;
	CConstTokenListIterator	aSubTokenIter = fTokens.begin();
	while (aSubToken == NULL && aSubTokenIter != fTokens.end())
	{
		if ((*aSubTokenIter)->GetIdentifier() == tokenID)
			aSubToken = *aSubTokenIter;
		else if (recurse)
			aSubToken = (*aSubTokenIter)->FindSubToken(tokenID, true);
		aSubTokenIter++;
	}
	
	return aSubToken;
}
		
//----------------------------------------------------------------------------------------
// CToken::AddSubToken
//----------------------------------------------------------------------------------------

void CToken::AddSubToken(CToken* aToken)
{ 
#if qDebug
	ThrowIfNULL_AC(aToken);
#endif
	if (aToken)
	{
		fTokens.push_back(aToken);
		aToken->SetParent(this);
	}
}
		
//----------------------------------------------------------------------------------------
// CToken::RemoveSubToken
//----------------------------------------------------------------------------------------

void CToken::RemoveSubToken(CToken* theSubToken)
// RemoveSubToken locates and removes the given subtoken but does not delete it.
{
	CTokenListIterator theEnd = remove(fTokens.begin(), fTokens.end(), theSubToken);
	fTokens.erase(theEnd, fTokens.end());
}
		
//----------------------------------------------------------------------------------------
// CToken::FirstSubToken
//----------------------------------------------------------------------------------------

CToken* CToken::FirstSubToken() const
// Return the first subtoken.
{
	CTokenList::const_iterator begin = fTokens.begin();
	return (begin != fTokens.end()) ? *begin : NULL;
}
		
//----------------------------------------------------------------------------------------
// CToken::HandleNotification
//----------------------------------------------------------------------------------------

void CToken::HandleNotification(CToken* notifier)
// HandleNotification receives a 'TYPE' notification and sets its token ID
// to that of the token sending the notification.
{
	if (fParent)
		fParent->HandleNotification(notifier);
}

#if qDebug
//----------------------------------------------------------------------------------------
// CToken::Dump
//----------------------------------------------------------------------------------------

class PutIDType
{
	IDType	fIdentifier;
public:
	PutIDType(IDType id) : fIdentifier(id) {}
	~PutIDType() {}

	operator unsigned long() const { return fIdentifier; }
	operator const char*() const { return reinterpret_cast<const char*>(&fIdentifier); }
};

static ostream& operator<<(ostream& toStream, const PutIDType& id)
{
	if (id >= '    ')
	{
		const char* c = id;
		toStream << '\'' << c[0] << c[1] << c[2] << c[3] << '\'';
	}
	else
	{
		toStream << "0x" << hex << static_cast<unsigned long>(id) << dec;
	}
	return toStream;
}

void CToken::Dump(ostream& toStream, short level) const
{
	for (short i = 0; i < level; ++i) toStream << "    ";

	IDType identifier = GetIdentifier();
	toStream << PutIDType(identifier);

	IDType notifyID = GetNotifyID();
	if (notifyID != kNoIdentifier_AC)
		toStream << ", notify(" << PutIDType(notifyID) << ')';

	if (fThrowAway)
		toStream << ", thrown away";

	DumpContents(toStream, level);

	if (fTokens.size() > 0)
	{
		toStream << ", " << fTokens.size() << " sub-token";
		if (fTokens.size() > 1)
			toStream << "s";
		toStream << ":";
	}

	toStream << '\n';

	for (CTokenList::const_iterator iter = fTokens.begin(); iter != fTokens.end(); ++iter)
	{
		(*iter)->Dump(toStream, level + 1);
	}
}

//----------------------------------------------------------------------------------------
// CToken::Dump
//----------------------------------------------------------------------------------------

void CToken::DumpContents(ostream& toStream, short level) const
{
#pragma unused (toStream, level)
}
#endif // qDebug


//========================================================================================
// Globals
//========================================================================================

//----------------------------------------------------------------------------------------
// InsensitiveCompare
//----------------------------------------------------------------------------------------

bool InsensitiveCompare(const char c1, const char c2)
	{ return toupper(c1) == toupper(c2); }


//========================================================================================
// CParseStream
//========================================================================================

//----------------------------------------------------------------------------------------
// CParseStream::dtor
//----------------------------------------------------------------------------------------

CParseStream::~CParseStream()
{
}

#if 0
	//----------------------------------------------------------------------------------------
	// CParseStream::GetNextLine
	//----------------------------------------------------------------------------------------

	bool CParseStream::GetNextLine()
	{
		char	newLine[256];
		fParseStream->getline((char*)&newLine, 255);
		bool	success = fParseStream->good();
		if (success)
			fResponseString = newLine;
		else
			fResponseString = "";

		fOffset = 0;					// Reset the string position.

		return success;
	}
#endif // 0

//----------------------------------------------------------------------------------------
// CParseStream::ParseStream
//----------------------------------------------------------------------------------------

bool CParseStream::ParseStream(CToken* baseToken)
// ParseStream scans the fParseStream, breaks it down into individual
// lines and processes all associated rules.
{
	bool success = true;

	fParseSucceeded = false;

	// Parse either a CTextPtr or a stream.
//	if (fUseTextPtr)
//	{
	while (success && !fParsePtr->AtEnd())
		success = CTerm::Parse(*fParsePtr, baseToken);
//	}
//	else
//	{
//		// Get the first line.  All subsequent lines will be requested.
//		bool		lineParsed;
//		while (!fParseDone && GetNextLine())
//		{
//			lineParsed = CTerm::Parse(fResponseString, fOffset, baseToken);
//		}
//
//		// If we didn't get the 'DONE' indication then we must have failed.
//		if (!fParseDone)
//		{
//			success = false;
//#if qDebug
//			ProgramBreak_AC("CParseStream::ParseStream: No input lines found in input stream.");
//#endif
//		}
//	}
	

	// Do our wrap-up.	
	if (success)
	{
		fActualMatch++;
		fParseSucceeded = true;
	}
#if qDebug
	else
	{
		string	failedString("Input string: �");
		ProgramReport_AC("CParseStream::ParseStream: Parsing failed.");
//		if (fUseTextPtr)
//			failedString += string(*fParsePtr, fParsePtr->length() > 50 ? 50 : fParsePtr->length());
//		else
		failedString += fResponseString;
		failedString += "�.";
		ProgramBreak_AC(failedString);
	}
#endif
	
	return success;		// Final notification as to if the parse was successful.
}

//========================================================================================
// CParseNub
//========================================================================================

//----------------------------------------------------------------------------------------
// CParseNub::dtor
//----------------------------------------------------------------------------------------

CParseNub::~CParseNub()
{
}

//----------------------------------------------------------------------------------------
// CParseNub::Parse
//----------------------------------------------------------------------------------------

bool CParseNub::Parse(	CTextPtr&	textPtr,
						CToken*		parentToken)
// Parse skips whitespace if required, creates a generic token, and continues
// the parsing.
//
// textPtr:		A pointer to the string being parsed.
// parentToken:	The token to which new tokens we create should be added.
{
	bool		success = false;
	
	if (!textPtr.AtEnd())		// Make sure there's something to compare.
	{
		CTextPtr	localTextPtr = textPtr;
		
		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
		
		// We always succeed.  Create a token object and then
		// then process any subterms, update the offset, and send
		// any notifications.
		CAutoPtr_AC<CToken> aTokenAP(TH_new CToken(parentToken, this));
		
		if (CTerm::Parse(localTextPtr, aTokenAP))
		{
			textPtr = localTextPtr;
			success = true;
			if (!aTokenAP->ThrowAway())
				aTokenAP.release();
		}
	}
	
	return success;
}

//========================================================================================
// CLiteralTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CLiteralTerm::dtor
//----------------------------------------------------------------------------------------

CLiteralTerm::~CLiteralTerm()
{
}

//----------------------------------------------------------------------------------------
// CLiteralTerm::Parse
//----------------------------------------------------------------------------------------

bool CLiteralTerm::Parse(	CTextPtr&	textPtr,
							CToken*		parentToken)
// Parse scans to see if a specific literal is present in the string.
//
// theString:	The string being parsed.
// offset:		The offset from which we are to start parsing.
// parentToken:	The token to which new tokens we create should be added.
{
	bool		success = false;
	
	if (!textPtr.AtEnd())		// Make sure there's something to compare.
	{
		CTextPtr	localTextPtr = textPtr;
		
		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
		
		string	tempString(localTextPtr, fLiteral.size());
		if (localTextPtr.length() >= fLiteral.size()
			&& equal(tempString.begin(), tempString.end(), fLiteral.begin(), InsensitiveCompare))
		{
			// We matched the literal.  Create a token object and then
			// then process any subterms, update the offset, and send
			// any notifications.
			CAutoPtr_AC<CLiteralToken> aTokenAP(TH_new CLiteralToken(parentToken, this));
			localTextPtr += fLiteral.size();
			if (localTextPtr.AtEnd())
				localTextPtr += localTextPtr.length();
			
			if (CTerm::Parse(localTextPtr, aTokenAP))
			{
				textPtr = localTextPtr;
				success = true;
				if (!aTokenAP->ThrowAway())
					aTokenAP.release();
			}
		}
	}
	
	return success;
}

//========================================================================================
// CIntegerTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CIntegerTerm::dtor
//----------------------------------------------------------------------------------------

CIntegerTerm::~CIntegerTerm()
{
}

//----------------------------------------------------------------------------------------
// CIntegerTerm::Parse
//----------------------------------------------------------------------------------------

bool CIntegerTerm::Parse(	CTextPtr&	textPtr,
							CToken*		parentToken)
// Parse scans for an integer consisting of at least one digit.
//
// theString:	The string being parsed.
// offset:		The offset from which we are to start parsing.
// parentToken:	The token to which new tokens we create should be added.
{
	bool	success = false;

	if (!textPtr.AtEnd())		// Make sure there's something to compare.
	{
		CTextPtr	localTextPtr = textPtr;
		
		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
			
		UInt32		theInteger = 0;
		CTextPtr	originalTextPtr = localTextPtr;
		while (!localTextPtr.AtEnd() && isdigit(*localTextPtr))
			theInteger = (theInteger * 10) + (*(localTextPtr++) - '0');

		if (localTextPtr != originalTextPtr)
		{
			// We found an integer.  Create a token object and then
			// then process any subterms, update the offset, and send
			// any notifications.
			CAutoPtr_AC<CIntegerToken> aTokenAP(TH_new CIntegerToken(parentToken, this, theInteger));

			if (localTextPtr.AtEnd())
				localTextPtr += localTextPtr.length();

			if (CTerm::Parse(localTextPtr, aTokenAP))
			{
				textPtr = localTextPtr;
				success = true;
				if (!aTokenAP->ThrowAway())
					aTokenAP.release();
			}
		}
	}

	return success;
}

//========================================================================================
// CKeywordTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CKeywordTerm::dtor
//----------------------------------------------------------------------------------------

CKeywordTerm::~CKeywordTerm()
{
}

//----------------------------------------------------------------------------------------
// CKeywordTerm::Parse
//----------------------------------------------------------------------------------------

bool CKeywordTerm::Parse(	CTextPtr&	textPtr,
							CToken*		parentToken)
// Parse grabs one token.
//
// theString:	The string being parsed.
// offset:		The offset from which we are to start parsing.
// parentToken:	The token to which new tokens we create should be added.
{
	bool				success = false;

	if (!textPtr.AtEnd())		// Make sure there's something there.
	{
		CTextPtr	localTextPtr = textPtr;
		
		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
			
		CTextPtr	endOfToken = FindToken(localTextPtr, fDelimeters.c_str());
		if (endOfToken != localTextPtr)
		{
			// We found a token.  Create a token object and then
			// then process any subterms, update the offset, and send
			// any notifications.
			
			CAutoPtr_AC<CKeywordToken> aTokenAP(TH_new CKeywordToken(parentToken,
														 this,
														 string(localTextPtr, endOfToken - localTextPtr)));

			if (CTerm::Parse(endOfToken, aTokenAP))
			{
				textPtr = endOfToken;
				success = true;
				if (!aTokenAP->ThrowAway())
					aTokenAP.release();
			}
		}
	}

	return success;
}

//========================================================================================
// CRestOfLineTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CRestOfLineTerm::dtor
//----------------------------------------------------------------------------------------

CRestOfLineTerm::~CRestOfLineTerm()
{
}

//----------------------------------------------------------------------------------------
// CRestOfLineTerm::Parse
//----------------------------------------------------------------------------------------

bool CRestOfLineTerm::Parse(CTextPtr&	textPtr,
							CToken*		parentToken)
// Parse simply grabs the remainder of the string.
//
// theString:	The string being parsed.
// offset:		The offset from which we are to start parsing.
// parentToken:	The token to which new tokens we create should be added.
{

	bool				success = false;

	if (!textPtr.AtEnd())		// Make sure there's something to skip.
	{
		CTextPtr	localTextPtr = textPtr;

		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
			
		char*		endOfLine = SkipToCRLF(localTextPtr);
		CAutoPtr_AC<CRestOfLineToken> aTokenAP(TH_new CRestOfLineToken(parentToken,
														this,
														string(localTextPtr, endOfLine - localTextPtr.get())));
		if (*endOfLine)
			endOfLine += 2;		// Skip the CRLF.
		localTextPtr += (endOfLine - localTextPtr.get());

		if (CTerm::Parse(localTextPtr, aTokenAP))
		{
			textPtr = localTextPtr;
			success = true;
			if (!aTokenAP->ThrowAway())
				aTokenAP.release();
		}
	}
		
	return success;
}


//========================================================================================
// CParseStreamToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CParseStreamToken::dtor
//----------------------------------------------------------------------------------------

CParseStreamToken::~CParseStreamToken()
{
}

//----------------------------------------------------------------------------------------
// CParseStreamToken::HandleNotification
//----------------------------------------------------------------------------------------

void CParseStreamToken::HandleNotification(CToken* notifier)
// HandleNotification receives a 'DONE' notification and tells its parseterm
// that parsing is done.
{
	if (fParseStream && notifier && (notifier->GetNotifyID() == eDoneID))
		fParseStream->SetDone();
	CToken::HandleNotification(notifier);
}

//========================================================================================
// CLiteralToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CLiteralToken::dtor
//----------------------------------------------------------------------------------------

CLiteralToken::~CLiteralToken()
{
}

#if qDebug && qMacApp
//----------------------------------------------------------------------------------------
// CLiteralToken::DumpContents
//----------------------------------------------------------------------------------------

void CLiteralToken::DumpContents(ostream& toStream, short level) const
{
#pragma unused (level)

	toStream << ", literal: \"" << fLiteral.c_str() << '\"';
}
#endif
		

//========================================================================================
// CIntegerToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CIntegerToken::dtor
//----------------------------------------------------------------------------------------

CIntegerToken::~CIntegerToken()
{
}

#if qDebug && qMacApp
//----------------------------------------------------------------------------------------
// CIntegerToken::DumpContents
//----------------------------------------------------------------------------------------

void CIntegerToken::DumpContents(ostream& toStream, short level) const
{
#pragma unused (level)

	toStream << ", integer: " << fInteger;
}
#endif
		

//========================================================================================
// CKeywordToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CKeywordToken::dtor
//----------------------------------------------------------------------------------------

CKeywordToken::~CKeywordToken()
{
}

#if qDebug && qMacApp
//----------------------------------------------------------------------------------------
// CKeywordToken::DumpContents
//----------------------------------------------------------------------------------------

void CKeywordToken::DumpContents(ostream& toStream, short level) const
{
#pragma unused (level)

	toStream << ", keyword: \"" << fKeyword.c_str() << '\"';
}
#endif
		

//========================================================================================
// CRestOfLineToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CRestOfLineToken::dtor
//----------------------------------------------------------------------------------------

CRestOfLineToken::~CRestOfLineToken()
{
}

#if qDebug && qMacApp
//----------------------------------------------------------------------------------------
// CRestOfLineToken::DumpContents
//----------------------------------------------------------------------------------------

void CRestOfLineToken::DumpContents(ostream& toStream, short level) const
{
#pragma unused (level)

	toStream << ", rest of line: \"" << fString.c_str() << '\"';
}
#endif
		

//----------------------------------------------------------------------------------------
// End of CParser.cpp
