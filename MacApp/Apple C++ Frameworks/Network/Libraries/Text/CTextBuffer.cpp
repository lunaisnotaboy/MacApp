//----------------------------------------------------------------------------------------
// CTextBuffer.cpp
// Copyright © 1996-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/31/00	Need to include MemoryUtils_AC. 
		02/07/00	Revised for new threads implementation. 
		12/07/99	Add SetSize. 
		10/14/99	Fix off-by-one in AssureData.
		10/13/99	Adopted by MacApp.

	Originally written by:	the cyberdogs
*/


#ifndef __CTextBuffer__
#include "CTextBuffer.h"
#endif

// ACS

#ifndef _MEMMGR_
#include "MemMgr.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif


//========================================================================================
// class CTextBuffer
//========================================================================================

//----------------------------------------------------------------------------------------
// CTextBuffer constructor
//----------------------------------------------------------------------------------------

CTextBuffer::CTextBuffer(size_type blockSize)
	:	fBuffer(NULL),
		fBlockSize(Max_AC(blockSize, 1)),
		fPhysicalSize(0),
		fLogicalSize(0),
		fStatus(kReady)
{
}


//----------------------------------------------------------------------------------------
// CTextBuffer copy constructor
//----------------------------------------------------------------------------------------

CTextBuffer::CTextBuffer(CTextBuffer& from)
	:	fBuffer(from.fBuffer),
		fBlockSize(from.fBlockSize),
		fLogicalSize(from.fLogicalSize),
		fPhysicalSize(from.fPhysicalSize),
		fStatus(from.fStatus)
{
	from.release();
}


//----------------------------------------------------------------------------------------
// CTextBuffer destructor
//----------------------------------------------------------------------------------------

CTextBuffer::~CTextBuffer()
{
	// fBuffer will auto-destruct
	fLogicalSize = fPhysicalSize = 0;
}

//----------------------------------------------------------------------------------------
// CTextBuffer::release
//----------------------------------------------------------------------------------------

CTextBuffer::pointer CTextBuffer::release()
{
	pointer old = fBuffer.release();
	fLogicalSize = fPhysicalSize = 0;
	return old;
}

//----------------------------------------------------------------------------------------
// CTextBuffer::reset
//----------------------------------------------------------------------------------------

void CTextBuffer::reset(pointer toBlock)
{
	fBuffer.reset(toBlock);
	fLogicalSize = fPhysicalSize = fBuffer.BlockSize();
}

//----------------------------------------------------------------------------------------
// CTextBuffer::reset
//----------------------------------------------------------------------------------------

void CTextBuffer::reset(CTextBuffer& from)
{
	if ((this != &from) && (fBuffer != from.fBuffer))
	{
		fBuffer.reset(from.fBuffer);
		fBlockSize = from.fBlockSize;
		fLogicalSize = from.fLogicalSize;
		fPhysicalSize = from.fPhysicalSize;
		from.release();
	}
}

//----------------------------------------------------------------------------------------
// CTextBuffer::reallocate
//----------------------------------------------------------------------------------------

CTextBuffer& CTextBuffer::reallocate(size_type newSize)
{
	fBuffer.reallocate(newSize);
	fPhysicalSize = newSize;
	if (fLogicalSize >= fPhysicalSize)
	{
		fLogicalSize = fPhysicalSize - 1;
		if (fLogicalSize < 0)
			fLogicalSize = 0;

		fBuffer[fLogicalSize] = 0;
	}

	return *this;
}

//----------------------------------------------------------------------------------------
// CTextBuffer::SetSize
//----------------------------------------------------------------------------------------

void CTextBuffer::SetSize(size_type position)
{
	difference_type needed = position - fLogicalSize;
	if (needed > 0)
		grow(needed);

	fLogicalSize = position;
}

//----------------------------------------------------------------------------------------
// CTextBuffer::grow
//----------------------------------------------------------------------------------------

void CTextBuffer::grow(difference_type needed)
{
	size_type newSize = fLogicalSize + needed + 1;
	if (newSize > fPhysicalSize)
	{
		newSize = ((newSize + fBlockSize - 1) / fBlockSize) * fBlockSize;
#if qDebug
		Assertion_AC(newSize >= fLogicalSize + needed + 1, NULL);
#endif
		reallocate(newSize);
	}
}

//----------------------------------------------------------------------------------------
// CTextBuffer::append
//----------------------------------------------------------------------------------------

void CTextBuffer::append(const void* src, difference_type length)
{
	grow(length);
	if (src)
		BlockMove_AC(src, get() + fLogicalSize, length);
	fLogicalSize += length;
	fBuffer[fLogicalSize] = 0;
}

//----------------------------------------------------------------------------------------
// CTextBuffer::AssureData
//----------------------------------------------------------------------------------------

bool CTextBuffer::AssureData(long assure) const
{
	return (assure < fLogicalSize);
}


//========================================================================================
// class CThreadedTextBuffer
//========================================================================================

//----------------------------------------------------------------------------------------
// CThreadedTextBuffer constructor
//----------------------------------------------------------------------------------------

CThreadedTextBuffer::CThreadedTextBuffer(ThreadID dataSource, size_type blockSize)
	:	CTextBuffer(blockSize),
		fDataSource(dataSource)
{
}

//----------------------------------------------------------------------------------------
// CThreadedTextBuffer copy constructor
//----------------------------------------------------------------------------------------

CThreadedTextBuffer::CThreadedTextBuffer(CThreadedTextBuffer& from)
	:	CTextBuffer(from),
		fDataSource(from.fDataSource)
{
}

//----------------------------------------------------------------------------------------
// CThreadedTextBuffer destructor
//----------------------------------------------------------------------------------------

CThreadedTextBuffer::~CThreadedTextBuffer()
{
}

//----------------------------------------------------------------------------------------
// CThreadedTextBuffer::AssureData
//----------------------------------------------------------------------------------------

bool CThreadedTextBuffer::AssureData(long assure) const
{
	// See if the data has already arrived

	while (assure > fLogicalSize)
	{
		if (IsComplete())
		{
			if (assure > fLogicalSize)
			{
				return false;
			}
		}
		if (IsAborted())
		{
			return false;
		}
		YieldToThread(fDataSource);
	}

	return true;
}


//----------------------------------------------------------------------------------------
// End of CTextBuffer.cpp
