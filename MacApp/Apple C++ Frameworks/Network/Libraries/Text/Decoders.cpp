/*
	File:		Decoders.cpp

	Contains:	xxx put contents here xxx

	Written by:	the cyberdogs

	Copyright © 1996-2000 by Apple Computer, Inc., all rights reserved.

	Change History (most recent first):

		 <6>	 3/12/97	cc™		[1624018] fix problems with TEC converting partial chars
		 <5>	 2/28/97	cc™		[1632477], [1629291] EUC problems in header fields (not encoding
									when we need them encoded)
		 <4>	 2/11/97	cc™		[1600856] fixing header encoding, make sure we encode ALL
									headers
		 <3>	12/10/96	jse		(1606427) Use same skanky latin-1 -> macroman conversions that
									we use in MIMEBlock.cpp (forceLatin1)
		 <2>	11/01/96	cc™		Merge 1.2 changes
		 					From SLH Project, jcr		(1398221) Don't add whitespace chars to the end of encoded
									headers
		 					cc™		[1378208] fixing when we should or should not encode into MIME2
									headers
		 <3>	 9/23/96	jcr		(1386259) Make sure intl. headers appear on single line.
		 <2>	 9/11/96	tjb		(1379865) DecodeMessageHeader clears inBLength after appending
									in-between text.
		 <1>	 8/22/96	SKO		Move to 1.2
		<14>	 8/05/96	cc™		[1374191] add the final escape sequence in japanese MIME2
									headers
		<13>	 8/04/96	jse		(1375452) don't encode shift-JIS header fields
		<12>	 8/02/96	jse		(1365604) break headers on character boundries
		<11>	 8/01/96	cc™		fix decoding headers problem
		<10>	 7/30/96	jse		(1372975) extra goop at end of decoded string
		 <9>	 7/24/96	cc™		[1365604] international headers
		 <8>	 7/24/96	jse		(1371071) In TECConvert, make sure TEC is installed
		 <7>	 7/21/96	cc™		setting defaults values for a decoded string
		 <6>	 7/19/96	bct		Optimizations
		 <5>	 7/03/96	jse		add anyEncoding boolean to DecodeMessageHeader
		 <4>	 6/27/96	JR		Use new TextEncodingUtils names
		 <3>	 6/25/96	jse		use prefs in EncodeMessageHeader()
		 <2>	 6/19/96	cc™		mail internationalization fixes

	To Do:
*/

//#include "PseudoDog.h"

#ifndef __Decoders__
#include "Decoders.h"
#endif

// Internet

#ifndef __ASCII__
#include "ASCII.h"
#endif

#ifndef __CharsetUtils__
#include "CharsetUtils.h"
#endif

//#include "Debug.h"
//#include "IString.h"

#ifndef __ParseTools__
#include "ParseTools.h"
#endif

//#include "TextEncodingUtils.h"
//#include "TempObj.h"
//#include "MoreTextUtils.h"
//#include "MemoryUtils.h"
//#include "MoreScripts.h"
//#include "MoreTypes.h"
//#include "MoreTEC.h"

#if qDebug
#define ASSERT(condition) 	DebugAssert_AC((condition), NULL, __FILE__, __LINE__ )
#else
#define ASSERT(condition) 	{ if (!(condition)) ThrowError_AC(minErr); }
#endif

//===========================================================
// Internal Utilities
//===========================================================

//===========================================================
// Decoders
//===========================================================

void DecodeQuotedPrintable( const char *data, long dataLen, char* newData, long* newLen, short *extras )
{
	const char *src = data;
	const char *srcEnd = data + dataLen;
	char *dst = newData;
	
	while ( src < srcEnd )
	{
		if ( extras && srcEnd - src < 3 )
		{
			*extras = srcEnd - src;
			break;
		}
			
		if ( *src == '=' )
		{
			if ( *(src + 1) == kCRChar )
			{
				// soft line break; ignore
				
				src += 2;
				
				if ( *src == kLFChar )
				{
					// ignore CRLF's LF, too
					
					src++;
				}
			}
			else if ( *(src + 1) == kLFChar )
			{
				// soft line break; ignore

				src += 2;
			}
			else
			{
				src++;
				char c = ( CharToHex( *src++ ) << 4 );
				c += CharToHex( *src++ );
				*dst++ = c;
			}
		}
		else if ( *src == 0x09 || *src == ' ' )
		{
			// ignore white space at the end of a line
			
			const char *next = SkipSpaceAndTabs( const_cast<char *>(src) );
			
			if ( *next == kCRChar || *next == kLFChar )
			{
				src = next;
			}
			else
			{
				*dst++ = *src++;
			}
		}
		else if ( *src == kLFChar )
		{
			*dst++ = kCRChar;
			src++;
		}
		else if ( *src == kCRChar && (src + 1) < srcEnd && *(src + 1) == kLFChar )
		{
			*dst++ = kCRChar;
			src += 2;
		}
		else
		{
			*dst++ = *src++;
		}
	}
		
	*newLen = (dst - newData);
}



#define	kOnlyOneByteBit	0x80000000
#define kOnlyTwoBytesBit 0x40000000

void DecodeBase64( const char *data, long dataLen, char* newData, long* newLen, short *extras )
{
	unsigned long	bitHolder = nil;
	const char *	src = data;
	char *			dst = newData;
	short			curCount = 0;
	
	*newLen = dataLen;
	
	while ( (*newLen) > 0 )
	{
		// If we're at the end of the current bit of data but we AREN'T at the end of the
		// whole data block, we don't want to end up half-way through a base64 4-byte unit.
		// Since there may be spaces, CRLFs, etc. as padding, stop way ahead of time
		
		if ( extras && !curCount && (*newLen) < 40 )
		{
			*extras = *newLen;
			break;
		}
		
		// Store everything but white space in our bit holder
		
		char bitByte = Base64ToBits( *src );
		switch ( bitByte )
		{
			case kInvalidByteByte:
				// fall thru - just ignore invalid things for now
			case kOkButIgnoreByteByte:
				break;
				
			case kEqualSignByte:
				ASSERT( curCount > 1 );
				if ( curCount == 2 )
				{
					bitHolder += kOnlyOneByteBit;
				}
				else
				{
					bitHolder += kOnlyTwoBytesBit;
				}
				curCount++;
				break;
				
				
			default:
				bitHolder += ( Base64ToBits( *src ) << ((3 - curCount) * 6) );
				curCount++;
				break;
		}
			
		src++;
		(*newLen)--;
		
		// when we get 24 bits, dump them out
		
		if ( curCount == 4 )
		{
			*dst = ((bitHolder >> 16) & 0xFF);
			dst++;
			
			if ( bitHolder & kOnlyOneByteBit )
			{
				// don't add second or third bytes
				
				// •!• Must have two equals signs at the end for only one byte
				ASSERT( bitHolder & kOnlyTwoBytesBit );
			}
			else
			{
				*dst = ((bitHolder >> 8) & 0xFF);
				dst++;
				
				if ( bitHolder & kOnlyTwoBytesBit )
				{
					// don't add third byte
				}
				else
				{
					*dst = (bitHolder & 0xFF);
					dst++;
				}
			}
				
			curCount = 0;
			bitHolder = nil;
		}
	}
		
	if ( curCount )
	{
		ProgramReport_AC("Base64 needs data in even multiples of 4");
	}
		
	*newLen = dst - newData;	
}



void DecodeUU( const char *data, long dataLen, char* newData, long* newLen, short *extras )
{
	unsigned long	bitHolder = nil;
	const char *	src = data;
	char *			dst = newData;
	long			dataLineLen = 0;
	long			codedLineLen = 0;

	short			curCount = 0;
	bool			checkForFinish = false;
	bool			onNewLine = true;
	bool			couldBeFirstPass = ( extras == nil || (*extras) == 0 );
	bool			onFirstLine = false;
	
	*newLen = dataLen;
	
	while ( (*newLen) > 0 )
	{						
		// Store everything but white space in our bit holder - if we aren't at the end of the line!
		
		char bitByte = UUEncodeToBits( *src );
		if ( onFirstLine && bitByte != kOnNewLineByte )
		{
			// reading past first line
		}
		else if ( bitByte == kInvalidByteByte )
		{
			// just ignore invalid things for now

			ASSERT( codedLineLen == 0 );
			
			if ( onNewLine && checkForFinish )
			{
				ASSERT( !extras );
				ASSERT( *newLen >= 3 && *newLen < 10 );
				ASSERT( src[0] == 'e' );
				ASSERT( src[1] == 'n' );
				ASSERT( src[2] == 'd' );
				
				// all done
				
				break;
			}
				
			if ( onNewLine && couldBeFirstPass )
			{
				if ( src[0] == 'b' )
				{
					if ( extras && *newLen < 80 )
					{
						// better wait!
						*extras = *newLen;
						break;
					}
					else
					{
						ASSERT( src[1] == 'e' );
						ASSERT( src[2] == 'g' );
						ASSERT( src[3] == 'i' );
						ASSERT( src[4] == 'n' );
						
						onFirstLine = true;
					}
				}
			}

			onNewLine = false;
		}
		else if ( bitByte == kOkButIgnoreByteByte )
		{
			// Ignore!
			
			ASSERT( codedLineLen == 0 );

			onNewLine = false;
		}
		else if ( bitByte == kOnNewLineByte )
		{
			// Ignore - but get ready!
			
			ASSERT( codedLineLen == 0 );
			
			onNewLine = true;
			onFirstLine = false;
		}
		else
		{	
			couldBeFirstPass = false;
			
			if ( codedLineLen == 0 )	// not currently in a line
			{				
				if ( !onNewLine )
				{
					// must be checksums on the previous line - or something bad - ignore
				}
				else
				{
					dataLineLen = bitByte;
					codedLineLen = (dataLineLen * 4 + 2) / 3;
					
					if ( dataLineLen == 0 )
					{
						// We're done!
						
						if ( extras )
						{
							// we're done but wait for final call
							*extras = *newLen;
							break;
						}
						else
						{
							checkForFinish = true;
						}
					}
					else if ( extras && codedLineLen + 10 > (*newLen) )
					{
						// Can't get the whole line - wait 'til next pass
						
						*extras = *newLen;
						break;
					}
				}
			}
			else
			{
				bitHolder += ( UUEncodeToBits( *src ) << ((3 - curCount) * 6) );
				curCount++;
				codedLineLen--;
			}
				
			onNewLine = false;
		}
			
		src++;
		(*newLen)--;
		
		// when we get 24 bits or to the end of the line, dump them out
		
		if ( curCount == 4 || ( curCount > 0 && codedLineLen == 0 && dataLineLen > 0 ) )
		{
			*dst = ((bitHolder >> 16) & 0xFF);
			dst++;
			dataLineLen--;
			
			if ( dataLineLen )
			{
				*dst = ((bitHolder >> 8) & 0xFF);
				dst++;
				dataLineLen--;
			}
				
			if ( dataLineLen )
			{
				*dst = (bitHolder & 0xFF);
				dst++;
				dataLineLen--;
			}
				
			curCount = 0;
			bitHolder = nil;
			
			ASSERT( codedLineLen > 0 || dataLineLen == 0 );
		}
	}
		
	if (curCount != 0)
		ProgramReport_AC("UUEncode needs data in even multiples of 4");
		
	*newLen = dst - newData;	
}


//===========================================================
// Encoders…
//===========================================================

short EncodeBase64(const char *data, long dataLen, bool flush, char* newData, long* newLen)
{
	short	extraChars = 0;

	long	bufferLen = 0;
	char*	buffer = (char*) newData;
	long	maxBuffer = *newLen - 10;
	
	// Encode until we're either out of data, or out of buffer…
	while ((dataLen > 2) && (bufferLen < maxBuffer))
	{
		long srcHolder = ((*((long *) data)) >> 8 ) & 0xFFFFFF;
		buffer[bufferLen++] = BitsToBase64( srcHolder >> 18 );
		buffer[bufferLen++] = BitsToBase64( (srcHolder >> 12) & 0x3F );
		buffer[bufferLen++] = BitsToBase64( (srcHolder >> 6) & 0x3F );
		buffer[bufferLen++] = BitsToBase64( (srcHolder) & 0x3F );
		
		dataLen -= 3;
		data += 3;
	}

	// Multiples of three work very well; here are the leftovers - which should
	// only appear at the very end
	
	if ( flush )
	{
		if ( dataLen == 2 )
		{
			long srcHolder = ((*((long *) data)) >> 8) & 0x00FFFF00;
			buffer[bufferLen++] = BitsToBase64( srcHolder >> 18 );
			buffer[bufferLen++] = BitsToBase64( (srcHolder >> 12) & 0x3F );
			buffer[bufferLen++] = BitsToBase64( (srcHolder >> 6) & 0x3F );
			buffer[bufferLen++] = '=';
		}
		else if ( dataLen == 1 )
		{
			long srcHolder = ((*((long *) data)) >> 8) & 0x00FF0000;
			buffer[bufferLen++] = BitsToBase64( srcHolder >> 18 );
			buffer[bufferLen++] = BitsToBase64( (srcHolder >> 12) & 0x3F );
			buffer[bufferLen++] = '=';
			buffer[bufferLen++] = '=';
		}	
		extraChars = 0;
	}
	else
	{
		extraChars = dataLen;
	}
	
	*newLen = bufferLen;	
	
	return extraChars;
}



short EncodeQuotedPrintable(const char *data, long dataLen, bool convertToISO, char* newData, long* newLen)
{		
	long	qpBufferLen = 0;
	short	qpLineLen = 0;
	char*	qpBuffer = newData;
	long	maxBuffer = *newLen - 10;
	
	while ((dataLen > 0) && (qpBufferLen < maxBuffer))
	{
		if ( (*data >= 33 && *data <= 60) ||
			 (*data >= 62 && *data <= 126) ||
			 *data == 9 || *data == 32 )
		{
			qpBuffer[qpBufferLen++] = *data;
			qpLineLen++;
		}
		else if ( *data == kCRChar )
		{
			qpBuffer[qpBufferLen++] = kCRChar;
			qpLineLen = 0;
		}
		else
		{
			char encodeData = *data;
			if ( convertToISO )
			{
				ConvertMacRomanToLatinOne( &encodeData, 1 );
			}
				
			qpBuffer[qpBufferLen++] = '=';
			qpBuffer[qpBufferLen++] = HexToChar( ((unsigned char) encodeData) >> 4 );
			qpBuffer[qpBufferLen++] = HexToChar( encodeData & 0x0F );
			qpLineLen += 3;
		}
		
		dataLen--;
		data++;
	}

	*newLen = qpBufferLen;
	return dataLen;
}


//===========================================================
// Basic Converters
//===========================================================

char CharToHex( char asciiChar )
{
	if ( asciiChar >= '0' && asciiChar <= '9' )
	{
		return ( asciiChar - '0' );
	}
	else if ( asciiChar >= 'A' && asciiChar <= 'F' )
	{
		return ( asciiChar - 'A' + 10 );
	}
	else if ( asciiChar >= 'a' && asciiChar <= 'f' )
	{
		return ( asciiChar - 'a' + 10 );
	}
	else
	{
		ProgramReport_AC("Invalid CharToHex Char %c", asciiChar);
		return 0;
	}
}
	
char HexToChar( char hexDigit )
{
	if ( hexDigit >= 0 && hexDigit <= 9 )
	{
		return ( '0' + hexDigit );
	}
	else
	{
		return ( 'A' + (hexDigit - 10) );
	}
}


long Base64ToBits( char base64Char )
{
	if ( base64Char >= 'A' && base64Char <= 'Z' )
	{
		return ( base64Char - 'A' );
	}
	else if ( base64Char >= 'a' && base64Char <= 'z' )
	{
		return ( base64Char - 'a' + 26 );
	}
	else if ( base64Char >= '0' && base64Char <= '9' )
	{
		return ( base64Char - '0' + 52 );
	}
	else if ( base64Char == '+' )
	{
		return 62;
	}
	else if ( base64Char == '/' )
	{
		return 63;
	}
	else if ( base64Char == '=' )
	{
		return kEqualSignByte;
	}
	else if ( base64Char == kTab ||	base64Char == kCRChar || base64Char == kLFChar || base64Char == kSpace )
	{
		return kOkButIgnoreByteByte;
	}
	else
	{
		ProgramReport_AC("Invalid Base64ToBits Char %c", base64Char);
		return kInvalidByteByte;
	}
}

long UUEncodeToBits( char uuChar )
{
	if ( uuChar == '`' || uuChar == kSpace )
	{
		return ( 0 );
	}
	else if ( uuChar == kCRChar || uuChar == kLFChar )
	{
		return ( kOnNewLineByte );
	}	
	else if ( uuChar >= 0x21 && uuChar < 0x60 )
	{
		return ( uuChar - 0x20 );
	}
	else if ( uuChar == kTab )
	{
		return kOkButIgnoreByteByte;
	}
	else
	{
		return kInvalidByteByte;
	}
}

char BitsToUUEncode( char bits )
{
	if ( bits == 0 )
	{
		return ( '`' );
	}
	else if ( bits > 0 && bits < 64 )
	{
		return ( kSpace + bits );
	}
	else
	{
		ProgramReport_AC("Illegal bits");
		return 0;
	}
}
		
long BinHexToBits( char binHexChar )
{
	if ( binHexChar >= '!' && binHexChar <= '-' )
	{
		return ( binHexChar - '!' );
	}
	else if ( binHexChar >= '0' && binHexChar <= '6' )
	{
		return ( binHexChar - '0' + 13 );
	}
	else if ( binHexChar >= '8' && binHexChar <= '9' )
	{
		return ( binHexChar - '8' + 20 );
	}
	else if ( binHexChar >= '@' && binHexChar <= 'N' )
	{
		return ( binHexChar - '@' + 22 );
	}
	else if ( binHexChar >= 'P' && binHexChar <= 'V' )
	{
		return ( binHexChar - 'P' + 37 );
	}
	else if ( binHexChar >= 'X' && binHexChar <= '[' )
	{
		return ( binHexChar - 'X' + 44 );
	}
	else if ( binHexChar >= '`' && binHexChar <= 'f' )
	{
		return ( binHexChar - '`' + 48 );
	}
	else if ( binHexChar >= 'h' && binHexChar <= 'm' )
	{
		return ( binHexChar - 'h' + 55 );
	}
	else if ( binHexChar >= 'p' && binHexChar <= 'r' )
	{
		return ( binHexChar - 'p' + 61 );
	}
	else if ( binHexChar == kTab ||	binHexChar == kCRChar || binHexChar == kLFChar || binHexChar == kSpace )
	{
		return kOkButIgnoreByteByte;
	}
	else if ( binHexChar == ':' )
	{
		return kAllDoneByte;
	}
	else
	{
		ProgramReport_AC("Invalid Base64ToBits Char %c", binHexChar);
		return kInvalidByteByte;
	}
}
	
	