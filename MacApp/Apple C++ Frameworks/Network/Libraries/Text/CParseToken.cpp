//----------------------------------------------------------------------------------------
// CParseToken.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		10/13/00	CWP6 support: namespacing. 
		04/25/00	Add a GetString accessor. 
		04/18/00	Remove fIdentifier and fNotifyID. They are always the same as
							the term's, except for CTypeCatcherToken which wasn't used. 
							Change Dump and DumpContents to work with an ostream. 
							Remove parse namespace. 
		04/17/00	Rename nodes to terms. Remove string versions of Parse. 
							Move CParseTerm and CParseToken to their own units. 
							Remove sibling token accessors. 
*/

#ifndef __CParseToken__
#include "CParseToken.h"
#endif

// Network

#ifndef __CParseTerm__
#include "CParseTerm.h"
#endif

#ifndef __CTextBuffer__
#include "CTextBuffer.h"
#endif

// ACS

#ifndef __ParseTools__
//#include "ParseTools.h"
#endif


//========================================================================================
// CParseTokenList
//========================================================================================

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CParseTokenList::~CParseTokenList()
{
}

//----------------------------------------------------------------------------------------
// FreeAll
//----------------------------------------------------------------------------------------

void CParseTokenList::FreeAll()
{
	CWhileShrinking(this);

	while (fSize > 0)
	{
		CParseToken* token = Pop();
		if (token)
		{
			token->fParent = NULL;
			delete token;
		}
	}
}


//========================================================================================
// CParseTokenAutoList
//========================================================================================

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CParseTokenAutoList::~CParseTokenAutoList()
{
	FreeAll();
}


//========================================================================================
// CParseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CParseToken::CParseToken(const CParseTerm* term, const CTextBuffer& buffer) :
	fText(&buffer),
	fParseTerm(term),
	fParent(NULL),
	fTokens(),
	fThrowAway(false)
{
}

CParseToken::CParseToken(const CParseTerm* term, const CConstTextToken& text) :
	fText(text),
	fParseTerm(term),
	fParent(NULL),
	fTokens(),
	fThrowAway(false)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CParseToken::~CParseToken()
{
	if (fParent)
		fParent->RemoveSubToken(this);
}

//----------------------------------------------------------------------------------------
// GetString
//----------------------------------------------------------------------------------------

std::string CParseToken::GetString() const
{
	return fText.GetString();
}

//----------------------------------------------------------------------------------------
// GetIdentifier
//----------------------------------------------------------------------------------------

IDType CParseToken::GetIdentifier() const
{
	return fParseTerm ? fParseTerm->GetIdentifier() : kNoIdentifier_AC;
}

//----------------------------------------------------------------------------------------
// AddSubToken
//----------------------------------------------------------------------------------------

void CParseToken::AddSubToken(CParseToken* token)
{ 
#if qDebug
	ThrowIfNonObject_AC(token);
#endif
	if (token)
	{
		if (token->ThrowAway())
		{
			delete token;
		}
		else
		{
			fTokens.Insert(token);
			token->fParent = this;
			token->Added();
		}
	}
}

//----------------------------------------------------------------------------------------
// RemoveSubToken
//----------------------------------------------------------------------------------------

void CParseToken::RemoveSubToken(CParseToken* token)
// RemoveSubToken locates and removes the given subtoken but does not delete it.
{
	if (token)
	{
		token->fParent = NULL;
		fTokens.Delete(token);
	}
}

//----------------------------------------------------------------------------------------
// Added
//----------------------------------------------------------------------------------------

void CParseToken::Added()
// Added gives a token an opportunity to do something when it's been added to the tree. 
{
}


//----------------------------------------------------------------------------------------
// End of CParseToken.cpp
