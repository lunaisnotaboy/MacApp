//----------------------------------------------------------------------------------------
// ParseTools.cpp
// Copyright © 1996-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		10/14/99	Added SkipPastCRLF and SkipToCRLF.  Added some consts.
		10/13/99	Adopted by MacApp.

	Originally written by:	the cyberdogs
*/

#ifndef __ParseTools__
#include "ParseTools.h"
#endif

// Network

#ifndef __ASCII__
#include "ASCII.h"
#endif

// Toolbox

#include <OSUtils.h>

// ANSI

#ifndef _CTYPE_H
#include <ctype.h>
#endif

#ifndef _STDLIB_H
#include <stdlib.h>
#endif

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STRING_H
#include <string.h>
#endif


//----------------------------------------------------------------------------------------
// IsSingleByteType
//----------------------------------------------------------------------------------------

static bool IsSingleByteType(const char* textBuf, short textOffset, ScriptCode script)
{
	return CharacterByteType((Ptr)textBuf, textOffset, script) == smSingleByte;
}


//----------------------------------------------------------------------------------------
// FindToken
//----------------------------------------------------------------------------------------

// Find first occurrance of any character in "tokens" in "string" and return a
// pointer to it. Both "string" and "tokens" must be null-terminated.
char* FindToken(const char* string, const char* tokens)
{
	const char* stringPosition = string;
	const char* tokenPosition = tokens;
	
	while (*stringPosition != *tokenPosition)
	{
		if (*tokenPosition == '\0')
		{
			tokenPosition = tokens;
			++stringPosition;
		}
		else
		{
			++tokenPosition;
		}
	}
	
	return (char*) stringPosition;
}

//----------------------------------------------------------------------------------------
// FindTokenWS
//----------------------------------------------------------------------------------------

char* FindTokenWS(const char* string, const char* tokens, ScriptCode sc)
{
	const char* stringPosition = string;
	const char* tokenPosition = tokens;
	short loc = 0;
	
	Boolean isSingle = IsSingleByteType( stringPosition, loc, sc );
	while (stringPosition[loc] != *tokenPosition || !isSingle)
	{
		if (!isSingle)
		{
			// skip the double byte char
			loc++;
			loc++;
			isSingle = (IsSingleByteType( stringPosition, loc, sc ) );	
		}
		else
		{
			if (*tokenPosition == '\0')
			{
				tokenPosition = tokens;
				loc++;
				isSingle = (IsSingleByteType( stringPosition, loc, sc ) );	
			}
			else
			{
				++tokenPosition;
			}
		}
				
	}
	
	return (char*) &stringPosition[loc];
}


//----------------------------------------------------------------------------------------
// FindNoSpacePrintASCIIToken
//----------------------------------------------------------------------------------------

// Find first occurrance of any printable character (e.g. >= 0x20) and is not
// a space (e.g. 0x20) in "string" and return a pointer to it. "string" must be
// null-terminated.
char* FindNoSpacePrintASCIIToken(const char* string)
{
	while ((*string < 0x21) && (*string > 0))
		++string;
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipSpaceAndTabs
//----------------------------------------------------------------------------------------

// Find first occurrance of any character that is not a space or tab and return
// a pointer to it.  "string" must be null-terminated.
char* SkipSpaceAndTabs(const char* string)
{
	while ((*string == ' ') || (*string == '\t'))
		++string;
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipSpaceAndTabsWS
//----------------------------------------------------------------------------------------

char* SkipSpaceAndTabsWS(const char* string, ScriptCode sc)
{
	short loc = 0;
	Boolean isSingle = IsSingleByteType( string, loc, sc );
	
	while (((string[loc] == ' ') || (string[loc] == '\t')) && isSingle)
	{
		loc++;
		isSingle = IsSingleByteType( string, loc, sc );
	}
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipSpaceAndTabsAndReturns
//----------------------------------------------------------------------------------------

char* SkipSpaceAndTabsAndReturns(const char* string)
{
	while ((*string == ' ') || (*string == '\t') || (*string == kCRChar))
		++string;
	
	return (char*) string;
}


//----------------------------------------------------------------------------------------
// SkipReturnsAndLineFeeds
//----------------------------------------------------------------------------------------

char* SkipReturnsAndLineFeeds(const char* string)
{
	while ((*string == kLFChar) || (*string == kCRChar))
		++string;
	
	return (char*) string;
}


//----------------------------------------------------------------------------------------
// SkipToSpaceOrTab
//----------------------------------------------------------------------------------------

// Skip over any "normal" characters until we reach either a space or tab character
char* SkipToSpaceOrTab(const char* string)
{
	while ((*string != ' ') && (*string != '\t') && (*string != 0))
		++string;
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipToSpaceOrTabOrReturn
//----------------------------------------------------------------------------------------

// Skip over any "normal" characters until we reach either a space, tab, or return character
char* SkipToSpaceOrTabOrReturn(const char* string)
{
	while ((*string != ' ') && (*string != '\t') && (*string != 0) && (*string != kCRChar))
		++string;
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipToSpaceOrTabOrReturnWS
//----------------------------------------------------------------------------------------

char* SkipToSpaceOrTabOrReturnWS(const char* string, ScriptCode sc)
{
	short loc = 0;
	Boolean isSingle = IsSingleByteType( string, loc, sc );
	while (((string[loc] != ' ') && (string[loc] != '\t') && (string[loc] != 0) && (string[loc] != kCRChar)) || (!isSingle))
	{
		if (isSingle)
		{
			loc++;
		}
		else
		{
			loc++;
			loc++;
		}
			
		isSingle = IsSingleByteType( string, loc, sc );
	}
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipToEndOfLine
//----------------------------------------------------------------------------------------

char* SkipToEndOfLine(const char* string)
{
	while ((*string != 0) && (*string != kCRChar) && (*string != kLFChar))
		++string;
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipPastCRLF
//----------------------------------------------------------------------------------------

char* SkipPastCRLF(const char* string)
{
	while ((*string != 0) && ((*string != kCRChar) || (*(string+1) != kLFChar)))
		++string;
	if (*string != 0)		// If it's not a terminating null then we've found what we're looking for.
		++string;
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipToCRLF
//----------------------------------------------------------------------------------------

char* SkipToCRLF(const char* string)
{
	while ((*string != 0) && ((*string != kCRChar) || (*(string+1) != kLFChar)))
		++string;
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// SkipControlChars
//----------------------------------------------------------------------------------------

char* SkipControlChars(const char* string)
{
	while ((*string > 0) && (*string < kSpace))
		++string;
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// MakeUpperCase
//----------------------------------------------------------------------------------------

// Convert the next length characters pointed to by chars to upper case.
void MakeUpperCase(char* chars, long length)
{
	Assertion_AC((chars != nil) && (length > 0), NULL);
	if (chars == nil)
		return;
		
	while (length > 0)
	{
		if ((*chars >= 'a') && (*chars <= 'z'))
		{
			*chars -= 32;	// 32 = 'a' - 'A'
		}
		--length;
		++chars;
	}
}

//----------------------------------------------------------------------------------------
// MakeLowerCase
//----------------------------------------------------------------------------------------

// Convert the next length characters pointed to by chars to lower case.
void MakeLowerCase(char* chars, long length)
{
	Assertion_AC((chars != nil) && (length > 0), NULL);
	if (chars == nil)
		return;
		
	while (length > 0)
	{
		if ((*chars >= 'A') && (*chars <= 'Z'))
		{
			*chars += 32;	// 32 = 'a' - 'A'
		}
		--length;
		++chars;
	}
}

//----------------------------------------------------------------------------------------
// ParseSymbol
//----------------------------------------------------------------------------------------

// Parse a symbol.  Symbols only contain the characters in the set [A-Z, a-z, 0-9, ., -]
// parse must point to the first character of the symbol.
// Returns a pointer to the first character after the symbol.
char* ParseSymbol(const char* parse, char** symbol, long* length)
{
	// now we've got the symbol start
	*symbol = (char*) parse;

	while (((*parse >= 'A') && (*parse <= 'Z'))
		|| ((*parse >= 'a') && (*parse <= 'z'))
		|| ((*parse >= '0') && (*parse <= '9'))
		|| (*parse == '.')
		|| (*parse == '-'))
	{
		++parse;
	}

	*length = parse - *symbol;

	return (char*) parse;
}

//----------------------------------------------------------------------------------------
// ParseValue
//----------------------------------------------------------------------------------------

// Parse a value (which may be quoted).
// parse must point to the first character of the (possibly quoted) value.
// except is string of characters which cannot appear in a value (must be null-terminated)
// if quoteLiteral is true, except does not apply to quoted values, otherwise it does.
// Returns a pointer to the first character after the value (or endquote).
char* ParseValue(const char* parse, char** value, long* length, const char* except, Boolean quoteLiteral)
{
	char quoteChar = '\0';

	// check if we're a quoted value
	if ((*parse == '\"') || (*parse == '\''))
	{
		quoteChar = *parse;	// save quote char
		++parse;			// value starts at next character
	}

	// now we've got the value start
	*value = (char*) parse;

	// if we're quoted, the value ends at the closing quote,
	// else it ends at the first character that's less than or equal to a space or in except.
	if (quoteChar != '\0')
	{
		while ((*parse != quoteChar) && (*parse != '\0') && (quoteLiteral || (except == nil) || (strchr(except, *parse) == nil)))
			++parse;
	}
	else
	{
		while ((*parse > ' ') && ((except == nil) || (strchr(except, *parse) == nil)))
			++parse;
	}

	*length = parse - *value;

	// Skip the closing quote, if there was one.
	if ((quoteChar != '\0') && (*parse == quoteChar))
		++parse;

	return (char*) parse;
}

//----------------------------------------------------------------------------------------
// LookupToken
//----------------------------------------------------------------------------------------

// Look up a token in the table.  Returns the entry if there's a match, otherwise returns nil.
const TokenEntry* LookupToken(const char* token, long tokenLength, const TokenEntry* table, long tableLength, long entrySize)
{
	register long low = 0;
	register long high = tableLength;
	
	// Use binary search
	while (low < high)
	{
		register long middle = (low + high - 1) >> 1;
		const TokenEntry* guess = (const TokenEntry*)((const char*)table + middle * entrySize);
		
		short compareResult = strncmp(token, guess->key, tokenLength);
		if (compareResult == 0)
			compareResult = tokenLength - guess->keyLength;
		
		if (compareResult == 0)
			return guess;
			
		if (compareResult < 0)
			high = middle;
		else
			low = middle + 1;
	}

	// Didn't find it.
	return nil;
}

//----------------------------------------------------------------------------------------
// ParseInteger
//----------------------------------------------------------------------------------------

// Parse an integer.  If there isn't at least one digit, we return -1 to indicate
// that there was an error…

long ParseInteger(char** string)
{
	long number = 0;
	long count = 0;
	
	while (isdigit(**string))
	{
		count++;
		number = number * 10 + (**string - '0');
		(*string)++;
	}
	
	// If there weren't any digits, then return -1 to indicate an error condition
	if (count == 0)
		number = -1;
		
	return number;
}

//----------------------------------------------------------------------------------------
// FindInteger
//----------------------------------------------------------------------------------------

// Find the next numeric token in buffer.  Terminate the search on any character in the 
// terminators string. Returns the number in result. Its return value is a pointer to
// the character it stopped at, until it hits a  terminator, in which case it returns 
// NULL. non-destructive

char* FindInteger(const char* buffer, const char* terminators, long* result)
{
	if (!buffer)
	{
		*result=0;		// garbage in, garbage out
		return NULL;
	}
	
	long number = 0;
	int count = 0;
	
	const char* end = terminators ? strpbrk(buffer, terminators) : NULL;
	
	while (buffer)
	{	
		while (buffer && (isdigit(*buffer)))
		{
			count++;
			number = number * 10 + (*buffer - '0');
			buffer++;
		}
		
		if (count)				// we got a number in the above while loop
		{
			break;
		}

		if ((buffer == end) || (*buffer == '\0'))		// we've hit a terminator.
		{
			buffer = NULL;
			break;
		}
		
		buffer++;		
	}
	
	*result = number;
	return (char*) buffer;
}

//----------------------------------------------------------------------------------------
// CharToHex
//----------------------------------------------------------------------------------------

// Read and compute the (positive) hex number that *string currently points to, 
// and advance string past the hex number.  If *string doesn't point to an hex number, 
// -1 is returned and the string is untouched.

static char CharToHex( char asciiChar )
{
	if ( asciiChar >= '0' && asciiChar <= '9' )
	{
		return ( asciiChar - '0' );
	}
	else if ( asciiChar >= 'A' && asciiChar <= 'F' )
	{
		return ( asciiChar - 'A' + 10 );
	}
	else if ( asciiChar >= 'a' && asciiChar <= 'f' )
	{
		return ( asciiChar - 'a' + 10 );
	}
	else
	{
		Assertion_AC( false, "Invalid CharToHex Char" );
		return 0;
	}
}
	
//----------------------------------------------------------------------------------------
// ParseHexDigits
//----------------------------------------------------------------------------------------

long ParseHexDigits(char** string)
{
	long number = 0;

	if (isxdigit(**string) == 0)
		return -1;

	while (isxdigit(**string))
	{
		number = number * 16 + CharToHex(**string);
		(*string)++;
	}
	
	return number;
}

//----------------------------------------------------------------------------------------
// FindTokenInBuffer
//----------------------------------------------------------------------------------------

char* FindTokenInBuffer(const char* buffer, short length, char token)
{
	const char* tokenPtr = nil;
	const char* endPtr = buffer + length;
	
	while (buffer < endPtr)
	{
		if (*buffer == token)
		{
			tokenPtr = buffer;
			break;
		}
		++buffer;
	}
		
	return (char*) tokenPtr;
}

//----------------------------------------------------------------------------------------
// BitsToBase64
//----------------------------------------------------------------------------------------

char BitsToBase64( char bits )
{
	if ( bits >= 0 && bits < 26 )
	{
		return ( 'A' + bits );
	}
	else if ( bits >= 26 && bits < 52 )
	{
		return ( 'a' + (bits - 26) );
	}
	else if ( bits >= 52 && bits < 62 )
	{
		return( '0' + (bits - 52) );
	}
	else if ( bits == 62 )
	{
		return '+';
	}
	else if ( bits == 63 )
	{
		return '/';
	}
	else
	{
		Assertion_AC( false, "Illegal bits" );
		return 0;
	}
}

//----------------------------------------------------------------------------------------
// FindHexDigit
//----------------------------------------------------------------------------------------

// Find first occurrance of a hex character ('a' - 'f', 'A' - 'F', '0' - '9')
// and return a pointer to it.  string must be null-terminated 
char* FindHexDigit(const char* string)
{
	while (isxdigit( *string) == 0)
		string++;
	
	return (char*) string;
}

//----------------------------------------------------------------------------------------
// IsAllWhiteSpace
//----------------------------------------------------------------------------------------

// Return whether the entire buffer consists of whitespace (CRLF, spaces, tabs, etc)
Boolean	IsAllWhiteSpace(const char* buffer, const long length)
{
	long i = 0;
	while (i < length)
	{
		if (!isspace(buffer[i]))
		{
			return false;
		}
		i++;	
	}
	
	return true;
}

//----------------------------------------------------------------------------------------
// IsAllWhiteSpace
//----------------------------------------------------------------------------------------

// Return whether the entire buffer consists of whitespace (CRLF, spaces, tabs, etc)
Boolean	IsAllWhiteSpace(const unsigned char* buffer, const long length)
{
	long i = 0;
	while (i < length)
	{
		if (!isspace(buffer[i]))
		{
			return false;
		}
		i++;	
	}
	
	return true;
}


//----------------------------------------------------------------------------------------
// End of ParseTools.cpp
