//----------------------------------------------------------------------------------------
// UCommandThread.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		02/07/00	Revised for new threads implementation. 
		06/14/99	Override RequestShutdown to resume the thread. 
		06/13/99	Initial version. 
*/

#ifndef __UCommandThread__
#include "UCommandThread.h"
#endif

// Network

#ifndef __UThreadedCommand__
#include "UThreadedCommand.h"
#endif

// MacApp

// ACS

//#ifndef __CWhileSynchronized_AC__
//#include "CWhileSynchronized_AC.h"
//#endif

// Toolbox

#ifndef __SOUND__
#include <Sound.h>
#endif


//========================================================================================
// TCommandThread
//========================================================================================

//----------------------------------------------------------------------------------------
// TCommandThread constructor 
//----------------------------------------------------------------------------------------

TCommandThread::TCommandThread() :
	CCooperativeThread_AC(),
	fLock(),
	fCommandList(1)
{
	fLock.Create();
}

//----------------------------------------------------------------------------------------
// TCommandThread destructor
//----------------------------------------------------------------------------------------

TCommandThread::~TCommandThread()
{
}

//----------------------------------------------------------------------------------------
// TCommandThread::Run
//----------------------------------------------------------------------------------------

void TCommandThread::Run() // override 
{
	DoInitialState();

	while (!ShutdownRequested())
	{
		fCurrent = RetrieveCommand();
		if (fCurrent)
		{
			fCurrent->RunCommand();
			Yield();
		}
		else
			Suspend();
	}

	Terminate();
}

//----------------------------------------------------------------------------------------
// TCommandThread::PostCommand
//----------------------------------------------------------------------------------------

void TCommandThread::PostCommand(TThreadedCommand* command)
{
	command->SetContext(this);
	{
		CWhileSynchronized entry(fLock);
		fCommandList.InsertFirst(command);
	}
	Resume();
}

//----------------------------------------------------------------------------------------
// TCommandThread::RequestShutdown
//----------------------------------------------------------------------------------------

void TCommandThread::RequestShutdown() // override
{
	CCooperativeThread_AC::RequestShutdown();
	Resume();
}

//----------------------------------------------------------------------------------------
// TCommandThread::DoInitialState
//----------------------------------------------------------------------------------------

void TCommandThread::DoInitialState()
{
}

//----------------------------------------------------------------------------------------
// TCommandThread::Terminate
//----------------------------------------------------------------------------------------

void TCommandThread::Terminate()
{
}

//----------------------------------------------------------------------------------------
// TCommandThread::RetrieveCommand
//----------------------------------------------------------------------------------------

TThreadedCommand* TCommandThread::RetrieveCommand()
{
	TThreadedCommand* command = NULL;

	CWhileSynchronized entry(fLock);

	if (fCommandList.GetSize() > 0)
		command = fCommandList.Pop();

	return command;
}


//----------------------------------------------------------------------------------------
// End of UCommandThread.cpp
