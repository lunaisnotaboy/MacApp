//----------------------------------------------------------------------------------------
// CConnectionLog.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		10/02/00	Removed inappropriate default argument from CConnectionTrace 
							and CConnectionLog ctors.
		05/23/00	Use \r and \n only internally. 
		05/18/00	Change to use TWEViewStream. 
		03/22/00	Add CASCIICodes. Dump unprintable characters. 
							Set color of sending and received text. 
							Split off CConnectionTrace from CConnectionLog. 
							CConnectionTrace can be used with any TTEViewStream. 
		01/13/00	Merge MConnectionTraceLeaf into MConnectionTrace. 
		11/29/99	Let others get at the log. 
		11/24/99	Delete the log window in our destructor. Works around problems
							with closing windows after the application object is gone. 
		08/16/99	Initial version. 
*/

#ifndef __CConnectionLog__
#include "CConnectionLog.h"
#endif

#if qDebug && qMacApp

// Network

#ifndef __ASCII__
#include "ASCII.h"
#endif

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __PrintSink__
#include "PrintSink.h"
#endif

#ifndef __ULogWindow__
#include "ULogWindow.h"
#endif

#ifndef __UWEViewStream__
#include "UWEViewStream.h"
#endif

// MacApp

// ACS

// Toolbox

// ANSI


//========================================================================================
// CASCIICodes
//========================================================================================

class CASCIICodes
{
public:
	CASCIICodes();
	~CASCIICodes() {}

	FourCharCode operator[](int i) const	{ return fCodes[i]; }

protected:
	FourCharCode	fCodes[256];
};

//----------------------------------------------------------------------------------------
// CASCIICodes constructor
//----------------------------------------------------------------------------------------

CASCIICodes::CASCIICodes()
{
	fCodes[0x00] = ' NUL';
	fCodes[0x01] = ' SOH';
	fCodes[0x02] = ' STX';
	fCodes[0x03] = ' ETX';
	fCodes[0x04] = ' EOT';
	fCodes[0x05] = ' ENQ';
	fCodes[0x06] = ' ACK';
	fCodes[0x07] = ' BEL';
	fCodes[0x08] = '  BS';
	fCodes[0x09] = '  HT';
	fCodes[0x0a] = '  LF';
	fCodes[0x0b] = '  VT';
	fCodes[0x0c] = '  FF';
	fCodes[0x0d] = '  CR';
	fCodes[0x0e] = '  SO';
	fCodes[0x0f] = '  SI';
	fCodes[0x10] = ' DLE';
	fCodes[0x11] = ' DC1';
	fCodes[0x12] = ' DC2';
	fCodes[0x13] = ' DC3';
	fCodes[0x14] = ' DC4';
	fCodes[0x15] = ' NAK';
	fCodes[0x16] = ' SYN';
	fCodes[0x17] = ' ETB';
	fCodes[0x18] = ' CAN';
	fCodes[0x19] = '  EM';
	fCodes[0x1a] = ' SUB';
	fCodes[0x1b] = ' ESC';
	fCodes[0x1c] = '  FS';
	fCodes[0x1d] = '  GS';
	fCodes[0x1e] = '  RS';
	fCodes[0x1f] = '  US';

	for (int i = 0x10; i < 0xFF; ++i)
		fCodes[i] = 0x20202000 | i;

	fCodes[0x7f] = ' DEL';
}


//========================================================================================
// CConnectionTrace
//========================================================================================

//----------------------------------------------------------------------------------------
// CConnectionTrace constructor
//----------------------------------------------------------------------------------------

CConnectionTrace::CConnectionTrace(MConnectionTraceComposite* parent)
	:	MConnectionTrace(parent),
		fLog(NULL),
		fSendColor(0x6666, 0x0000, 0x9999),		// violet
		fReceiveColor(0x0000, 0x0000, 0xCCCC)	// blue
{
}

//----------------------------------------------------------------------------------------
// CConnectionTrace destructor
//----------------------------------------------------------------------------------------

CConnectionTrace::~CConnectionTrace()
{
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Opening
//----------------------------------------------------------------------------------------

void CConnectionTrace::Opening(const char* path)
{
	if (fLog)
		*fLog << "Opening " << path << endl_AC;
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Connecting
//----------------------------------------------------------------------------------------

void CConnectionTrace::Connecting(const InetAddress& address)
{
	if (fLog)
		*fLog << "Connecting to " << address << endl_AC;
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Connecting
//----------------------------------------------------------------------------------------

void CConnectionTrace::Connecting(const DNSAddress& address)
{
	if (fLog)
		*fLog << "Connecting to " << address << endl_AC;
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Disconnecting
//----------------------------------------------------------------------------------------

void CConnectionTrace::Disconnecting()
{
	if (fLog)
		*fLog << "Disconnecting" << endl_AC;
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Closing
//----------------------------------------------------------------------------------------

void CConnectionTrace::Closing()
{
	if (fLog)
		*fLog << "Closing" << endl_AC;
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Sending
//----------------------------------------------------------------------------------------

void CConnectionTrace::Sending(const char* p, size_t n)
{
	if ((n > 0) && fLog)
	{
		// Skip the CRLF because we're adding an eol after every piece sent. 
		bool onlyCRLF = (n == 2) && (p[0] == kCRChar) && (p[1] == kLFChar);
		if (!onlyCRLF)
		{
			*fLog << "Sending:" << endl_AC;
			*fLog << fSendColor;
			Dump(p, n);
			*fLog << endl_AC;
			*fLog << CRGBColor_AC::kRGBBlack;
		}
	}
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Received
//----------------------------------------------------------------------------------------

void CConnectionTrace::Received(const char* p, size_t n)
{
	if ((n > 0) && fLog)
	{
		*fLog << "Received:" << endl_AC;
		*fLog << fReceiveColor;
		Dump(p, n);
		*fLog << endl_AC;
		*fLog << CRGBColor_AC::kRGBBlack;
	}
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Canceling
//----------------------------------------------------------------------------------------

void CConnectionTrace::Canceling(OSStatus error)
{
	if (fLog)
		*fLog << "Canceling " << error << endl_AC;
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::IsBinary
//----------------------------------------------------------------------------------------

bool CConnectionTrace::IsBinary(const char* p, size_t n) const
{
	bool nonprinting = false;
	for (size_t i = 0; i < n; ++i)
	{
		char c = p[i];
		if ((c > '~') || ((c < ' ') && (c != kCRChar) && (c != kLFChar)))
		{
			nonprinting = true;
			break;
		}
	}
	return nonprinting;
}

//----------------------------------------------------------------------------------------
// CConnectionTrace::Dump
//----------------------------------------------------------------------------------------

void CConnectionTrace::Dump(const char* p, size_t n)
{
	if (!IsBinary(p, n))
		fLog->WriteCharBytes(p, n);
	else
	{
		static CASCIICodes pCodes;
		const unsigned char* c = (const unsigned char*)p;
		while (n > 0)
		{
			*fLog << '\n';
			size_t len = Min_AC(16, n);
			const unsigned char* c2 = c;
			for (size_t i = 0; i < len; ++i)
			{
				print(*fLog, "  %02x", *c2++);
			}
			*fLog << '\n';
			
			for (size_t i = 0; i < len; ++i)
			{
				FourCharCode code = pCodes[*c++];
				fLog->WriteCharBytes((char *)&code, sizeof(code));
			}
			*fLog << '\n';
			n -= len;
		}
	}
}


//========================================================================================
// CConnectionLog
//========================================================================================

//----------------------------------------------------------------------------------------
// Global Variables
//----------------------------------------------------------------------------------------

CAutoPtr_AC<TLogWindow>	CConnectionLog::fgLogWindow;

//----------------------------------------------------------------------------------------
// CConnectionLog constructor
//----------------------------------------------------------------------------------------

CConnectionLog::CConnectionLog(MConnectionTraceComposite* parent)
	:	CConnectionTrace(parent)
{
	if (!fgLogWindow)
		fgLogWindow = TLogWindow::MakeLogWindow();

	fLog = fgLogWindow;
}

//----------------------------------------------------------------------------------------
// CConnectionLog destructor
//----------------------------------------------------------------------------------------

CConnectionLog::~CConnectionLog()
{
	fgLogWindow.reset();
	fLog = NULL;
}

//----------------------------------------------------------------------------------------
// CConnectionLog::GetLog
//----------------------------------------------------------------------------------------

CStream_AC* CConnectionLog::GetLog()
{
	return fgLogWindow;
}

#endif // qDebug && qMacApp

//----------------------------------------------------------------------------------------
// End of CConnectionLog.cpp
