//----------------------------------------------------------------------------------------
// UTEViewStream.cpp
// Copyright © 1985-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/22/00	Add SetColor. 
		03/13/00	Check for null teview. 
		06/15/99	Insert the text straight from the source instead of copying. 
					Skip LF if it is next to a CR. 
		03/24/99	Update copyright notice.
*/

#include "UTEViewStream.h"

#include "UWindow.h"
#include "CBufferedStreamRep_AC.h"
#include "UViewServer.h"
#include "UDispatcher.h"
#include "UTEView.h"

#define kDefaultSize 256


//========================================================================================
// class TViewStreamRep
//========================================================================================

class TViewStreamRep : public CBufferedStreamRep_AC
{
public:
	TViewStreamRep(TTEView* inTEView) :
		CBufferedStreamRep_AC(kDefaultSize),
		fTEView(inTEView),
		fColor(0, 0, 0)
	{}
	
	virtual ~TViewStreamRep();

	void SetTEView(TTEView* inView);

	TTEView* GetTEView() const	{ return fTEView; }

	void ReadTEViewFromResource(TWindow* inWindow, OSType viewID);
	
	void SetColor(const CRGBColor_AC& color)	{ fColor = color; }

protected:
	virtual void WriteBufferedBytes(const void* inBytes, long inAmt);
		
protected:
	TTEView*		fTEView;
	CRGBColor_AC	fColor;
};
	

//----------------------------------------------------------------------------------------
// TViewStreamRep destructor
//----------------------------------------------------------------------------------------

TViewStreamRep::~TViewStreamRep()
{
}

//----------------------------------------------------------------------------------------
// TViewStreamRep::SetTEView
//----------------------------------------------------------------------------------------

void TViewStreamRep::SetTEView(TTEView* inView)
{
	fTEView = inView;
	if (fTEView)
		fTEView->SetEnable(true);
}

//----------------------------------------------------------------------------------------
// TViewStreamRep::ReadTEViewFromResource
//----------------------------------------------------------------------------------------

void TViewStreamRep::ReadTEViewFromResource(TWindow* inWindow, OSType inID)
{
	::AssertNotNULL_AC (inWindow);

	fTEView = dynamic_cast_AC(TTEView*,inWindow->FindSubView(inID));
	if (fTEView)
		fTEView->SetEnable(true);
}

//----------------------------------------------------------------------------------------
// TViewStreamRep::WriteBufferedBytes
//----------------------------------------------------------------------------------------

void TViewStreamRep::WriteBufferedBytes(const void* inBytes, long inAmt)
{
	enum { chLineFeed = 10 };

	::AssertNotNULL_AC(fTEView);
	
	long textlen = inAmt;
	
	const char* text = static_cast<const char*>(inBytes);

	fTEView->SetSelection((*(fTEView->fHTE))->teLength, (*(fTEView->fHTE))->teLength, true);
	fTEView->SetActive(false);
	
	while (textlen > 0)
	{
		if ((*(fTEView->fHTE))->teLength + textlen < 32000)
		{
			// In the normal situation we have enough space to add the text, 
			// set the selection to the end.
			fTEView->SetSelection(	(*(fTEView->fHTE))->teLength, 
									(*(fTEView->fHTE))->teLength, true);
		}
		else
		{
			// Else there ain't enough room to insert the text. The new length would be longer than
			// 32k. So chop off the first half of the text. It's not pretty, I know. 
		
			fTEView->SetSelection(0, (*(fTEView->fHTE))->teLength / 2, true);
				// Set the selection to delete.

			fTEView->SynchView(true);
			fTEView->ScrollSelectionIntoView(true);

			::TEDelete(fTEView->fHTE);
				// this deletes the selection

			fTEView->RecalcText();
				// fix up the view
			
			fTEView->SetSelection(	(*(fTEView->fHTE))->teLength, 
									(*(fTEView->fHTE))->teLength, true);
				// Set the selection to the end.

			fTEView->SynchView(true);
			fTEView->ScrollSelectionIntoView(true);
				// scroll the end into view.
		}
		
		short oldLength = (*(fTEView->fHTE))->teLength;

		// Find the end of the line or the end of the text
		bool insertCR = false;
		const char* begin = text;
		short count = 0;
		while (textlen > 0)
		{
			if (*text == chLineFeed)
			{
				// If we have a linefeed with no return character before or after it,
				// then we need to insert a return in the TEView
				char previousChar = (count > 0) ? *(text-1) : 0;
				char nextChar = (textlen > 0) ? *(text+1) : 0;
				insertCR = (previousChar != chReturn) && (nextChar != chReturn);

				// Skip the linefeed in the text buffer, but don't add it to the count
				--textlen;
				++text;
				break;
			}

			++count;
			--textlen;
			++text;
		}

		if (count > 0)
			::TEInsert(begin, count, fTEView->fHTE);

		if (insertCR)
		{
			unsigned char cr = chReturn;
			::TEInsert(&cr, 1, fTEView->fHTE);
		}

		short teLength = (*(fTEView->fHTE))->teLength;
		if (teLength > oldLength)
		{
			CTextStyle_AC aStyle;
			aStyle.tsColor = fColor;
			fTEView->SetOneStyle(oldLength, teLength, doColor, aStyle, kDontRedraw);
		}
	}

	fTEView->SetSelection((*(fTEView->fHTE))->teLength, (*(fTEView->fHTE))->teLength, true);
	fTEView->SynchView(true);
	fTEView->SetActive(true);
}


//========================================================================================
// TTEViewStream
//========================================================================================

//----------------------------------------------------------------------------------------
// TTEViewStream::TTEViewStream
//----------------------------------------------------------------------------------------

TTEViewStream::TTEViewStream(TTEView* inTEView)
	: CCharOutputSink_AC( TH_new TViewStreamRep(inTEView))
{
}

//----------------------------------------------------------------------------------------
// TTEViewStream::~TTEViewStream
//----------------------------------------------------------------------------------------

TTEViewStream::~TTEViewStream()
{
}

//----------------------------------------------------------------------------------------
// TTEViewStream::SetTEView
//----------------------------------------------------------------------------------------

void TTEViewStream::SetTEView(TTEView* inView)
{	
	TViewStreamRep* rep = dynamic_cast_AC(TViewStreamRep*,GetStreamRep());
	rep->SetTEView(inView);
}

//----------------------------------------------------------------------------------------
// TTEViewStream::GetTEView
//----------------------------------------------------------------------------------------

TTEView* TTEViewStream::GetTEView() const
{
	TViewStreamRep* rep = dynamic_cast_AC(TViewStreamRep*,GetStreamRep());
	return rep->GetTEView();
}

//----------------------------------------------------------------------------------------
// TTEViewStream::SetColor
//----------------------------------------------------------------------------------------

void TTEViewStream::SetColor(const CRGBColor_AC& color)
{
	TViewStreamRep* rep = dynamic_cast_AC(TViewStreamRep*,GetStreamRep());
	rep->SetColor(color);
}

//----------------------------------------------------------------------------------------
// TTEViewStream::ReadTEViewFromResource
//----------------------------------------------------------------------------------------

void TTEViewStream::ReadTEViewFromResource(TWindow* inWindow, OSType inID)
{
	TViewStreamRep* rep = dynamic_cast_AC(TViewStreamRep*,GetStreamRep());
	rep->ReadTEViewFromResource(inWindow, inID);
}

//----------------------------------------------------------------------------------------
// End of UTEViewStream.cpp
