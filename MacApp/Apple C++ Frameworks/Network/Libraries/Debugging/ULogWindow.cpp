//----------------------------------------------------------------------------------------
// ULogWindow.cpp
// Copyright © 1985-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/18/00	Change to use TWEViewStream. 
					Open the log behind the last window. 
		11/24/99	Keep track of when the window goes away. 
					Make sure the window gets closed and deleted. 
		06/14/99	Add MakeLogWindow. 
		03/24/99	Update copyright notice.
*/

#ifndef __ULogWindow__
#include "ULogWindow.h"
#endif

#ifndef __UWindow__
#include "UWindow.h"
#endif

#include "UViewServer.h"
#include "UDispatcher.h"

//----------------------------------------------------------------------------------------
// TLogWindow::MakeLogWindow
//----------------------------------------------------------------------------------------

TLogWindow* TLogWindow::MakeLogWindow(short windowResID, OSType viewID)
{
	CAutoPtr_AC<TLogWindow> log = TH_new TLogWindow;
	log->ReadViewsFromResource(windowResID, viewID);
//	log->GetWindow()->SetFrame(frame, false);
//	log->GetWindow()->SetTitle(title);
	log->Show();
	return log.release();
}

//----------------------------------------------------------------------------------------
// TLogWindow::TLogWindow
//----------------------------------------------------------------------------------------

TLogWindow::TLogWindow()
	:	TWEViewStream(NULL),
		fWindow(NULL)
{
}

//----------------------------------------------------------------------------------------
// TLogWindow::~TLogWindow
//----------------------------------------------------------------------------------------

TLogWindow::~TLogWindow()
{
	if (fWindow)
	{
		Flush();
		fWindow->Close();
		delete fWindow;
		fWindow = NULL;
	}
}

//----------------------------------------------------------------------------------------
// TLogWindow::ReadViewsFromResource
//----------------------------------------------------------------------------------------

void TLogWindow::ReadViewsFromResource(short windowResID, OSType viewID)
{
	if(!gViewServer)
		gDispatcher->DoMakeViewServer();

	fWindow = gViewServer->NewTemplateWindow(windowResID, NULL);
	::ThrowIfNULL_AC(fWindow);

	SetView(fWindow, viewID);
}

//----------------------------------------------------------------------------------------
// TLogWindow::Show
//----------------------------------------------------------------------------------------

void TLogWindow::Show()
{
	if (fWindow)
	{
		WindowRef lastWindow = TWindow::GetLastDocumentWindowPtr();
		if (lastWindow)
			SendBehind(fWindow->GetWindowRef(), lastWindow);

		fWindow->Open();
	}
}

//----------------------------------------------------------------------------------------
// TLogWindow::DoUpdate
//----------------------------------------------------------------------------------------

void TLogWindow::DoUpdate(ChangeID_AC theChange, 
						  MDependable_AC* changedObject,
						  void* changeData,
						  CDependencySpace_AC* dependencySpace)
{
#pragma unused (changeData, dependencySpace)

	if ((theChange == mClosed) && (changedObject == fWindow))
		fWindow = NULL;
}


//----------------------------------------------------------------------------------------
// End of ULogWindow.cpp
