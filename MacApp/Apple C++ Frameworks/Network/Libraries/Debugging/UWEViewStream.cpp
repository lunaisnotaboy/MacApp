//----------------------------------------------------------------------------------------
// UWEViewStream.cpp
// Copyright © 2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/18/00	Based on TTEViewStream. 
*/

#ifndef __UWEViewStream__
#include "UWEViewStream.h"
#endif

// MacApp

#ifndef __UWINDOW__
#include "UWindow.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UDISPATCHER__
#include "UDispatcher.h"
#endif

#ifndef __UWEVIEW__
#include "UWEView.h"
#endif

// ACS

#ifndef __CBufferedStreamRep_AC__
#include "CBufferedStreamRep_AC.h"
#endif

// WASTE

#ifndef _WASTE_
#include "WASTE.h"
#endif


//========================================================================================
// class TWEViewStreamRep
//========================================================================================

class TWEViewStreamRep : public CBufferedStreamRep_AC
{
public:
	enum { kDefaultSize = 256 };

	TWEViewStreamRep(TWEView* inWEView) :
		CBufferedStreamRep_AC(kDefaultSize),
		fWEView(inWEView),
		fColor(0, 0, 0)
	{}
	
	virtual ~TWEViewStreamRep();

	TWEView* GetView() const	{ return fWEView; }

	void SetView(TWEView* inView);
	void SetView(TWindow* inWindow, OSType viewID);
	
	void SetColor(const CRGBColor_AC& color)	{ fColor = color; }

protected:
	virtual void WriteBufferedBytes(const void* inBytes, long inAmt);
		
protected:
	TWEView*		fWEView;
	CRGBColor_AC	fColor;
};
	

//----------------------------------------------------------------------------------------
// TWEViewStreamRep destructor
//----------------------------------------------------------------------------------------

TWEViewStreamRep::~TWEViewStreamRep()
{
}

//----------------------------------------------------------------------------------------
// TWEViewStreamRep::SetView
//----------------------------------------------------------------------------------------

void TWEViewStreamRep::SetView(TWEView* inView)
{
	fWEView = inView;
	if (fWEView)
		fWEView->SetEnable(true);
}

//----------------------------------------------------------------------------------------
// TWEViewStreamRep::SetView
//----------------------------------------------------------------------------------------

void TWEViewStreamRep::SetView(TWindow* inWindow, OSType inID)
{
	::AssertNotNULL_AC(inWindow);

	fWEView = dynamic_cast_AC(TWEView*,inWindow->FindSubView(inID));
	if (fWEView)
		fWEView->SetEnable(true);
}

//----------------------------------------------------------------------------------------
// TWEViewStreamRep::WriteBufferedBytes
//----------------------------------------------------------------------------------------

void TWEViewStreamRep::WriteBufferedBytes(const void* inBytes, long inAmt)
{
	enum { chLineFeed = 10 };

	::AssertNotNULL_AC(fWEView);
	
	const char* text = static_cast<const char*>(inBytes);

	long textLength = WEGetTextLength(fWEView->fWE);
	fWEView->SetSelection(textLength, textLength, true);
	fWEView->SetActive(false);
	
	while (inAmt > 0)
	{
		// set the selection to the end.
		textLength = WEGetTextLength(fWEView->fWE);
		fWEView->SetSelection(textLength, textLength, true);

		long oldLength = textLength;

		// Find the end of the line or the end of the text
		bool insertCR = false;
		const char* begin = text;
		short count = 0;
		while (inAmt > 0)
		{
			if (*text == chLineFeed)
			{
				// If we have a linefeed with no return character before or after it,
				// then we need to insert a return in the WEView
				char previousChar = (count > 0) ? *(text-1) : 0;
				char nextChar = (inAmt > 0) ? *(text+1) : 0;
				insertCR = (previousChar != chReturn) && (nextChar != chReturn);

				// Skip the linefeed in the text buffer, but don't add it to the count
				--inAmt;
				++text;
				break;
			}

			++count;
			--inAmt;
			++text;
		}

		if (count > 0)
			::WEInsert(begin, count, NULL, NULL, fWEView->fWE);

		if (insertCR)
		{
			unsigned char cr = chReturn;
			::WEInsert(&cr, 1, NULL, NULL, fWEView->fWE);
		}

		textLength = WEGetTextLength(fWEView->fWE);
		if (textLength > oldLength)
		{
			CTextStyle_AC aStyle;
			aStyle.tsColor = fColor;
			fWEView->SetOneStyle(oldLength, textLength, doColor, aStyle, kDontRedraw);
		}
	}

	textLength = WEGetTextLength(fWEView->fWE);
	fWEView->SetSelection(textLength, textLength, true);
	fWEView->SynchView(true);
	fWEView->SetActive(true);
}


//========================================================================================
// TWEViewStream
//========================================================================================

//----------------------------------------------------------------------------------------
// TWEViewStream::TWEViewStream
//----------------------------------------------------------------------------------------

TWEViewStream::TWEViewStream(TWEView* inWEView)
	:	CCharOutputSink_AC(TH_new TWEViewStreamRep(inWEView))
{
}

//----------------------------------------------------------------------------------------
// TWEViewStream::~TWEViewStream
//----------------------------------------------------------------------------------------

TWEViewStream::~TWEViewStream()
{
}

//----------------------------------------------------------------------------------------
// TWEViewStream::SetView
//----------------------------------------------------------------------------------------

void TWEViewStream::SetView(TWEView* inView)
{	
	TWEViewStreamRep* rep = dynamic_cast_or_throw_AC(TWEViewStreamRep*,GetStreamRep());
	rep->SetView(inView);
}

//----------------------------------------------------------------------------------------
// TWEViewStream::GetView
//----------------------------------------------------------------------------------------

TWEView* TWEViewStream::GetView() const
{
	TWEViewStreamRep* rep = dynamic_cast_or_throw_AC(TWEViewStreamRep*,GetStreamRep());
	return rep->GetView();
}

//----------------------------------------------------------------------------------------
// TWEViewStream::SetColor
//----------------------------------------------------------------------------------------

void TWEViewStream::SetColor(const CRGBColor_AC& color)
{
	TWEViewStreamRep* rep = dynamic_cast_or_throw_AC(TWEViewStreamRep*,GetStreamRep());
	rep->SetColor(color);
}

//----------------------------------------------------------------------------------------
// TWEViewStream::SetView
//----------------------------------------------------------------------------------------

void TWEViewStream::SetView(TWindow* inWindow, OSType inID)
{
	TWEViewStreamRep* rep = dynamic_cast_or_throw_AC(TWEViewStreamRep*,GetStreamRep());
	rep->SetView(inWindow, inID);
}

//----------------------------------------------------------------------------------------
// End of UWEViewStream.cpp