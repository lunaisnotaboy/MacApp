//----------------------------------------------------------------------------------------
// CWEImage.cpp
// Copyright © 1999-2000 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		11/19/99	Move to DemoWaste from Bowser. 
		11/04/99	WEInstallObjectHandler takes only a UniversalProcPtr so we
							have to cast for the 68K build. 
		11/03/99	Force the graphics importer to draw in the current GWorld so 
							it will work when WASTE is drawing offscreen. 
		10/12/99	Initial version. 
*/

#ifndef __CWEImage__
#include "CWEImage.h"
#endif

// Bowser

// MacApp

// ACS

#ifndef __Bail_AC__
#include "Bail_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

// WASTE

#include "WETabs.h"
#include "WEExtras.h"

// Toolbox

#ifndef __IMAGECOMPRESSION__
#include <ImageCompression.h>
#endif

#ifndef __MOVIES__
#include <Movies.h>
#endif

// ANSI


//========================================================================================
// class CWEImage
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// CWEImage::Install()
//		Installs the PICT handler into WASTE.
//----------------------------------------------------------------------------------------

void CWEImage::Install(WEReference theWE)
{
	static WENewObjectUPP		pNewHandlerUPP;
	static WEDisposeObjectUPP	pDisposeHandlerUPP;
	static WEDrawObjectUPP		pDrawHandlerUPP;

	if (!pNewHandlerUPP)
	{
		pNewHandlerUPP = NewWENewObjectProc(HandleNew);
		ThrowIfNULL_AC(pNewHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weNewHandler, (UniversalProcPtr)pNewHandlerUPP, theWE));
	}

	if (!pDisposeHandlerUPP)
	{
		pDisposeHandlerUPP = NewWEDisposeObjectProc(HandleDispose);
		ThrowIfNULL_AC(pDisposeHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weDisposeHandler, (UniversalProcPtr)pDisposeHandlerUPP, theWE));
	}

	if (!pDrawHandlerUPP)
	{
		pDrawHandlerUPP = NewWEDrawObjectProc(HandleDraw);
		ThrowIfNULL_AC(pDrawHandlerUPP);
		ThrowIfOSErr_AC(WEInstallObjectHandler(kFlavor, weDrawHandler, (UniversalProcPtr)pDrawHandlerUPP, theWE));
	}
}

//----------------------------------------------------------------------------------------
// HandleNew
// New Object Handler for PICTs
//----------------------------------------------------------------------------------------

pascal OSErr CWEImage::HandleNew(Point *defaultObjectSize, WEObjectReference obj)
{
	OSErr err = noErr;

	Handle theURLHandle = WEGetObjectDataHandle(obj);
	
	ComponentInstance gi = NULL;
	BailOSErr(GetGraphicsImporterForDataRef(theURLHandle, URLDataHandlerSubType, &gi));
	
	WESetObjectRefCon(obj, (long)gi);

	CRect_AC naturalBounds;
	BailOSErr(GraphicsImportGetNaturalBounds(gi, &naturalBounds));

	*defaultObjectSize = naturalBounds.GetSize();

bail:
	return err;
}

//----------------------------------------------------------------------------------------
// Dispose Object Handler for PICTS
//----------------------------------------------------------------------------------------

pascal OSErr CWEImage::HandleDispose(WEObjectReference obj)
{
	OSErr err = noErr;

	ComponentInstance gi = (ComponentInstance)WEGetObjectRefCon(obj);
	if (gi)
	{
		CloseComponent(gi);
		WESetObjectRefCon(obj, NULL);
	}

#if 0
	Handle theURLHandle = WEGetObjectDataHandle(obj);
	if (theURLHandle)
	{
		DisposeHandle(theURLHandle);
		BailMemErr();
	}
#endif

bail:
	return err;
}
//----------------------------------------------------------------------------------------
// Draw Object Handler for PICTs
//----------------------------------------------------------------------------------------

pascal OSErr CWEImage::HandleDraw(Rect *destRect, WEObjectReference obj)
{
	OSErr err = noErr;

	ComponentInstance gi = (ComponentInstance)WEGetObjectRefCon(obj);
	if (gi)
	{
		CGrafPtr port = NULL;
		GDHandle gdh = NULL;
		GetGWorld(&port, &gdh);
		BailOSErr(GraphicsImportSetGWorld(gi, port, gdh));
		BailOSErr(GraphicsImportSetBoundsRect(gi, destRect));
		BailOSErr(GraphicsImportDraw(gi));
	}

bail:
	return err;
}


//----------------------------------------------------------------------------------------
// End of CWEImage.cpp

