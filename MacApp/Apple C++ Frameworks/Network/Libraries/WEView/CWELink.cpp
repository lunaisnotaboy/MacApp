//----------------------------------------------------------------------------------------
// CWELink.cpp
// Copyright © 1999-2000 by Apple Computer, Inc.  All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/11/00	Carbon: port is opaque. 
							Carbon: internet config is in CarbonLib. 
		11/22/99	Allow both stylers and objects to draw. 
							Add a hand cursor. 
		11/19/99	Move to DemoWaste from Bowser. 
							Simplify the implementation. 
		11/17/99	Streaming support for stylers. 
							Rename styler procs for clarity. 
		11/15/99	Use a styler for the link object. 
		11/04/99	WEInstallObjectHandler takes only a UniversalProcPtr so we
							have to cast for the 68K build. 
		10/10/99	Initial version. 
*/

#ifndef __CWELink__
#include "CWELink.h"
#endif

// Bowser

#ifndef __CCursor__
#include "CCursor.h"
#endif

#ifndef __WEView_r__
#include "WEView.r.h"
#endif

// MacApp

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

// Internet Config

#ifndef __ICAPI__
#include "ICAPI.h"
#endif

// WASTE

#include "WASTEIntf.h"
#include "WETabs.h"
#include "WEExtras.h"

// Toolbox

#ifndef __SOUND__
#include <Sound.h>
#endif

// ANSI


//========================================================================================
// Global Functions
//========================================================================================
#undef Inherited

#if !TARGET_CARBON
inline Style GetPortTextFace(const GrafPtr thePort)
{
	return thePort->txFace;
}
#endif

//========================================================================================
// class CWELink
//========================================================================================
#undef Inherited

WEStylerNewUPP		CWELink::fgStylerNewUPP;
WEStylerDrawUPP		CWELink::fgStylerDrawUPP;
WEStylerClickUPP	CWELink::fgStylerClickUPP;
WEStylerDisposeUPP	CWELink::fgStylerDisposeUPP;

CRGBColor_AC		CWELink::fgReadColor(0, 0x8080, 0); // dark green
CRGBColor_AC		CWELink::fgUnreadColor(0, 0, 0xFFFF); // blue
CRGBColor_AC		CWELink::fgActiveColor(0xFFFF, 0, 0xFFFF); // magenta
bool				CWELink::fgUnderlineLinks = true;

//----------------------------------------------------------------------------------------
// CWELink::Install()
//----------------------------------------------------------------------------------------

void CWELink::Install()
{
	if (!fgStylerNewUPP)
	{
		fgStylerNewUPP = NewWEStylerNewProc(StylerNewProc);
		ThrowIfNULL_AC(fgStylerNewUPP);
		ThrowIfOSErr_AC(WEInstallStylerNewProc(kFlavor, fgStylerNewUPP));
	}

	if (!fgStylerDrawUPP)
	{
		fgStylerDrawUPP = NewWEStylerDrawProc(StylerDrawProc);
		ThrowIfNULL_AC(fgStylerDrawUPP);
		ThrowIfOSErr_AC(WEInstallStylerDrawProc(kFlavor, fgStylerDrawUPP));
	}

	if (!fgStylerClickUPP)
	{
		fgStylerClickUPP = NewWEStylerClickProc(StylerClickProc);
		ThrowIfNULL_AC(fgStylerClickUPP);
		ThrowIfOSErr_AC(WEInstallStylerClickProc(kFlavor, fgStylerClickUPP));
	}

	if (!fgStylerDisposeUPP)
	{
		fgStylerDisposeUPP = NewWEStylerDisposeProc(StylerDisposeProc);
		ThrowIfNULL_AC(fgStylerDisposeUPP);
		ThrowIfOSErr_AC(WEInstallStylerDisposeProc(kFlavor, fgStylerDisposeUPP));
	}
}

//----------------------------------------------------------------------------------------
// CWELink::StylerNewProc
//----------------------------------------------------------------------------------------

pascal OSErr CWELink::StylerNewProc(WEStylerReference styler)
{
	OSErr err = noErr;

	try
	{
		TH_new CWELink(styler);
	}
	catch (CException_AC& fi)
	{
		err = fi.GetError();
	}
	catch (...)
	{
		if (!err)
			err = minErr;
	}

	return err;
}


//----------------------------------------------------------------------------------------
// CWELink::StylerDrawProc
//----------------------------------------------------------------------------------------

pascal Boolean CWELink::StylerDrawProc(Ptr pText, SInt32 textLength, Fixed slop,
									   JustStyleCode styleRunPosition, WEStylerReference styler)
{
	Boolean handled = false;
	CWELink* it = (CWELink*)WEGetStylerRefCon(styler);
	if (it)
		handled = it->StylerDraw(pText, textLength, slop, styleRunPosition);

	return handled;
}

//----------------------------------------------------------------------------------------
// CWELink::StylerClickProc
//----------------------------------------------------------------------------------------

pascal Boolean CWELink::StylerClickProc(Point hitPt, EventModifiers modifiers, 
										UInt32 clickTime, WEStylerReference styler)
{
	bool handled = false;
	CWELink* it = (CWELink*)WEGetStylerRefCon(styler);
	if (it)
		handled = it->StylerClick(hitPt, modifiers, clickTime);

	return handled;
}

//----------------------------------------------------------------------------------------
// CWELink::StylerDisposeProc
//----------------------------------------------------------------------------------------

pascal OSErr CWELink::StylerDisposeProc(WEStylerReference styler)
{
	OSErr err = noErr;
	CWELink* it = (CWELink*)WEGetStylerRefCon(styler);
	if (it)
	{
		try
		{
			delete it;
		}
		catch (CException_AC& fi)
		{
			err = fi.GetError();
		}
		catch (...)
		{
			if (!err)
				err = minErr;
		}
	}

	return err;
}

//----------------------------------------------------------------------------------------
// CWELink::LaunchURL
//----------------------------------------------------------------------------------------

OSErr CWELink::LaunchURL(ConstStr255Param hint, Handle hURL)
{
	OSErr err = noErr;

	// find out the signature of the current process
	FourCharCode signature = '\?\?\?\?';
	{
		ProcessSerialNumber psn;
		psn.highLongOfPSN = 0;
		psn.lowLongOfPSN = 0;
		if (GetCurrentProcess(&psn) == noErr)
		{
			ProcessInfoRec info;
			BLOCK_CLR(info);
			info.processInfoLength = sizeof(info);
			if (GetProcessInformation(&psn, &info) == noErr)
			{
				signature = info.processSignature;
			}
		}
	}

	ICInstance inst;
	err = ICStart(&inst, signature);
	if (err == noErr)
	{
#if !TARGET_CARBON
		err = ICFindConfigFile(inst, 0, nil);
		if (err == noErr)
#endif
		{
			bool saveTextLock = _WESetHandleLock(hURL, true);
			long urlStart= 0;
			long urlEnd = 0;
			err = ICLaunchURL(inst, hint, *hURL, strlen(*hURL), &urlStart, &urlEnd);
			_WESetHandleLock(hURL, saveTextLock);
		}
		ICStop(inst);
	}
	
	return err;
}

//----------------------------------------------------------------------------------------
// CWELink constructor
//----------------------------------------------------------------------------------------

CWELink::CWELink(WEStylerReference styler)
	:	fWE(NULL),
		fStyler(styler),
		fRead(false),
		fActive(false)
{
	if (styler)
	{
		fWE = WEGetStylerOwner(styler);
		WESetStylerRefCon(styler, static_cast<long>(this));
	}
}

//----------------------------------------------------------------------------------------
// CWELink::StylerDraw
//----------------------------------------------------------------------------------------

bool CWELink::StylerDraw(Ptr pText, SInt32 textLength, Fixed slop,
						 JustStyleCode styleRunPosition)
{
#pragma unused (pText, textLength, slop, styleRunPosition)

	if (fgUnderlineLinks)
	{
		GrafPtr thePort;
		GetPort(&thePort);
		TextFace(GetPortTextFace(thePort) | underline);
	}

	{
		CRGBColor_AC color;
		if (fActive)
			color = fgActiveColor;
		else if (fRead)
			color = fgReadColor;
		else
			color = fgUnreadColor;

		RGBForeColor(&color);
	}

	return false;	// allow objects and text to draw
}

//----------------------------------------------------------------------------------------
// CWELink::StylerClick
//----------------------------------------------------------------------------------------

bool CWELink::StylerClick(Point hitPt, EventModifiers modifiers, UInt32 clickTime)
{
#pragma unused (clickTime)

	if (modifiers & cmdKey)
	{
		LongPt thePoint;
		WEPointToLongPoint(hitPt, &thePoint);
		WEEdge edge;
		SInt32 offset = WEGetOffset(&thePoint, &edge, fWE);
		WERunInfo runInfo;
		WEGetRunInfo(offset, &runInfo, fWE);
		CTempRegion_AC hiliteRgn = WEGetHiliteRgn(runInfo.runStart, runInfo.runEnd, fWE);
		fActive = false;
		CTempCursor handCursor(kHandCursorID);
		while (StillDown())
		{
			CPoint_AC theMouse;
			GetMouse(&theMouse);
			bool active = hiliteRgn.Contains(theMouse);
			if (active != fActive)
			{
				fActive = active;
				WEUpdate(hiliteRgn, fWE);
				if (active)
					handCursor.Set();
				else
					SetCursorToArrow_AC();
			}
		}

		if (fActive)
		{
			fActive = false;
			fRead = true;

			OSErr err = minErr;

			// open the URL
			Handle theURLHandle = WEGetStylerDataHandle(fStyler);
			if (theURLHandle && (strlen(*theURLHandle) > 0))
			{
				Str255 hint;
				hint[0] = 0;
				err = WEGetInfo(weURLHint, hint, fWE);

				err = LaunchURL(hint, theURLHandle);
			}

			if (err)
				SysBeep(10);
		}

		WEUpdate(hiliteRgn, fWE);
	}

	return true; // we've handled it
}


//----------------------------------------------------------------------------------------
// End of CWELink.cpp
