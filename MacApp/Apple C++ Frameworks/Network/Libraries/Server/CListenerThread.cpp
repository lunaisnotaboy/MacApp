//----------------------------------------------------------------------------------------
// CListenerThread.cpp
// Copyright © 2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/24/00	Rename GetEndpoint to GetOTEndpoint. 
		04/07/00	Initial version. 
*/

#ifndef __CListenerThread__
#include "CListenerThread.h"
#endif

// Network

#ifndef __CCall__
#include "CCall.h"
#endif

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __CServerThread__
#include "CServerThread.h"
#endif

// MacApp

// ACS

#ifndef __CYielder_AC__
#include "CYielder_AC.h"
#endif

// Toolbox

// ANSI

//========================================================================================
// CListenerThread
//========================================================================================

//----------------------------------------------------------------------------------------
// Construction and Destruction
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CListenerThread::CListenerThread(CYielder_AC* yielder, InetHost host, InetPort port,
								 MConnectionTrace* inProgress)
	:	fLocalAddress(host, port),
		fEndpoint(yielder, inProgress)
{
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

CListenerThread::CListenerThread(const CListenerThread& from)
	:	fLocalAddress(from.fLocalAddress),
		fEndpoint(from.fEndpoint.GetYielder(), from.fEndpoint.GetProgress())
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CListenerThread::~CListenerThread()
{
}

//----------------------------------------------------------------------------------------
// Listen
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Run
//----------------------------------------------------------------------------------------

void CListenerThread::Run()
{
	fEndpoint.Open("tilisten,tcp");

	{
		OSStatus junk = fEndpoint.SetOption(IP_REUSEADDR, true);
		Assertion_AC(junk == noErr, "Unable to negotiate raw mode for listener endpoint");
	}

	fEndpoint.Bind(fLocalAddress);

	for (;;)
	{
		CInetAddress remoteIPAddress;
		CCall call(remoteIPAddress);
		OSStatus listenErr = fEndpoint.GetOTEndpoint()->Listen(&call);
		if (listenErr)
			break;

		HandleConnection(remoteIPAddress, call);
	}

	fEndpoint.Close();
}

//----------------------------------------------------------------------------------------
// HandleConnection
//----------------------------------------------------------------------------------------

void CListenerThread::HandleConnection(const InetAddress& remoteIPAddress, TCall& call)
{
	bool accepted = false;

	if (WillAccept(remoteIPAddress))
	{
		CAutoPtr_AC<CServerThread> server = DoMakeServerThread();
		if (server)
		{
			EndpointRef worker = server->DoMakeEndpoint(fEndpoint.GetYielder(), fEndpoint.GetProgress());
			if (worker)
			{
				ThrowIfOSStatus(fEndpoint.GetOTEndpoint()->Accept(worker, &call));
				StartServer(server.release());
				accepted = true;
			}
		}
	}

	if (!accepted)
		Reject(call);
}

//----------------------------------------------------------------------------------------
// WillAccept
//----------------------------------------------------------------------------------------

bool CListenerThread::WillAccept(const InetAddress& /*remoteIPAddress*/)
{
	return true;
}

//----------------------------------------------------------------------------------------
// Reject
//----------------------------------------------------------------------------------------

void CListenerThread::Reject(TCall& call)
{
	OSStatus junk = fEndpoint.GetOTEndpoint()->SndDisconnect(&call);
}

//----------------------------------------------------------------------------------------
// DoMakeServerThread
//----------------------------------------------------------------------------------------

CServerThread* CListenerThread::DoMakeServerThread()
{
	return TH_new CServerThread();
}

//----------------------------------------------------------------------------------------
// StartServer
//----------------------------------------------------------------------------------------

void CListenerThread::StartServer(CServerThread* server)
{
	server->Start();
}


//----------------------------------------------------------------------------------------
// End of CListenerThread.cpp