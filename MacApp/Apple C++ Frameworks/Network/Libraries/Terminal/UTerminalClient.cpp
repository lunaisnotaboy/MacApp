//----------------------------------------------------------------------------------------
// UTerminalClient.cpp
// Copyright © 2000 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/24/00	Finish separating char I/O from endpoints. 
							Isolate clients from look errors. 
		05/17/00	Disconnect is really Close. 
		05/17/00	Go to the endpoint for the state. 
		05/16/00	Terminal object pushes received data to the event handler. 
		03/28/00	Initial version. 
*/
#ifndef __UTerminalClient__
#include "UTerminalClient.h"
#endif

// Network

// MacApp

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

//========================================================================================
// TTerminalClient
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TTerminalClient::TTerminalClient(TEventHandler* receiver, CommandNumber receiveCommandNumber,
								 CCharOutputSink_AC& log, MConnectionTrace* inProgress)
	:	TCommandThread(),
		fYielder(),
		fProtocol(&fYielder, log, inProgress),
		fReceiver(receiver),
		fReceiveCommandNumber(receiveCommandNumber),
		fMaxChars(1024)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TTerminalClient::~TTerminalClient()
{
	fReceiver = NULL;
}

//----------------------------------------------------------------------------------------
// Run
//----------------------------------------------------------------------------------------

void TTerminalClient::Run() // override
// Override to poll for received data, and to exit when disconnected. 
{
	DoInitialState();

	while (!ShutdownRequested() && !fProtocol.IsDone())
	{
		// Receiving takes priority over sending
		if (fProtocol.IsConnected())
		{
			if (PollReceive())
				continue;
		}

		// Check for a connect or send command
		fCurrent = RetrieveCommand();
		if (fCurrent)
		{
			fCurrent->RunCommand();
		}
		else if (fProtocol.IsConnected())
		{
			// Wait for more data or a command
			Yield();
		}
		else if (!fProtocol.IsDone())
		{
			// Wait for a command to come in
			Suspend();
		}
	}

	Terminate();
}

//----------------------------------------------------------------------------------------
// PollReceive
//----------------------------------------------------------------------------------------

bool TTerminalClient::PollReceive()
{
	long available = fProtocol.Available();
	if (available > 0)
	{
		CTextBuffer buffer;
		buffer.grow(available);
		long result = fProtocol.Receive(buffer, available, fProtocol.kImmediate);
		if (result > 0)
			buffer.append(NULL, result);

		if (fReceiver)
		{
			TTerminalReceiveCommand* received =
				TH_new TTerminalReceiveCommand(fReceiveCommandNumber, buffer, result, fReceiver);
			fReceiver->PostCommand(received);
		}
	}

	return (available > 0);
}

//----------------------------------------------------------------------------------------
// RequestShutdown
//----------------------------------------------------------------------------------------

void TTerminalClient::RequestShutdown() // override
{
	TCommandThread::RequestShutdown();
	//if (!fProtocol.IsDone())
	//	fProtocol.Cancel(userCanceledErr);
}

//----------------------------------------------------------------------------------------
// Terminate
//----------------------------------------------------------------------------------------

void TTerminalClient::Terminate() // override 
{
	OSStatus ignore = fProtocol.Close();
}


//========================================================================================
// TTerminalCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TTerminalCommand::TTerminalCommand(CommandNumber itsCommandNumber,
								   TTerminalClient* thread,
								   TEventHandler* itsContext)
	:	TThreadedCommand(itsCommandNumber, itsContext, kCantUndo, kCausesChange, itsContext),
		fClient(thread)
{
	ThrowIfNonObject_AC(thread);
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TTerminalCommand::~TTerminalCommand()
{
}

//----------------------------------------------------------------------------------------
// Post
//----------------------------------------------------------------------------------------

void TTerminalCommand::Post()
{
	TCommand::fContext->PostCommand(this);
	fClient->PostCommand(this);
}


//========================================================================================
// TTerminalConnectCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TTerminalConnectCommand::TTerminalConnectCommand(CommandNumber itsCommandNumber,
												 const InetAddress& inAddress,
												 TTerminalClient* client,
												 TEventHandler* itsContext)
	:	TTerminalCommand(itsCommandNumber, client, itsContext),
		fAddress(inAddress)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TTerminalConnectCommand::~TTerminalConnectCommand()
{
}

//----------------------------------------------------------------------------------------
// Run
//----------------------------------------------------------------------------------------

void TTerminalConnectCommand::Run() // override
{
	GetProtocol().Connect(fAddress);
}


//========================================================================================
// TTerminalSendCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TTerminalSendCommand::TTerminalSendCommand(CommandNumber itsCommandNumber,
										   const char* text, size_t count,
										   TTerminalClient* client,
										   TEventHandler* itsContext)
	:	TTerminalCommand(itsCommandNumber, client, itsContext),
		fBuffer()
{
	fBuffer.append(text, count);
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TTerminalSendCommand::~TTerminalSendCommand()
{
}

//----------------------------------------------------------------------------------------
// Run
//----------------------------------------------------------------------------------------

void TTerminalSendCommand::Run() // override
{
	CTerminalProtocol& protocol(GetProtocol());
	protocol.Send(fBuffer, fBuffer.GetSize());
	protocol.Flush();
}


//========================================================================================
// TTerminalReceiveCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TTerminalReceiveCommand::TTerminalReceiveCommand(CommandNumber itsCommandNumber,
												 CTextBuffer& buffer,
												 long result,
												 TEventHandler* itsContext)
	:	TCommand(itsCommandNumber, itsContext, kCantUndo, kCausesChange, itsContext),
		fBuffer(buffer),
		fResult(result)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TTerminalReceiveCommand::~TTerminalReceiveCommand()
{
}


//----------------------------------------------------------------------------------------
// End of UTerminalClient.cpp
