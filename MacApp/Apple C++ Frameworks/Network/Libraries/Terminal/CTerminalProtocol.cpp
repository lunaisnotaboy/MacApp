//----------------------------------------------------------------------------------------
// CTerminalProtocol.cpp
// Copyright © 2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/24/00	Finish separating char I/O from endpoints. 
							Isolate clients from look errors. 
		05/18/00	Close just closes. 
		05/17/00	Disconnect is really Close. 
		05/17/00	Go to the endpoint for the state. 
		05/16/00	Poll for received data. Add state. 
		03/28/00	Initial version. 
*/

#ifndef __CTerminalProtocol__
#include "CTerminalProtocol.h"
#endif

// Network

#ifndef __CCall__
#include "CCall.h"
#endif

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __Ports__
#include "Ports.h"
#endif

#ifndef __PrintSink__
#include "PrintSink.h"
#endif

// MacApp

// ACS

#ifndef __CCharOutputSink_AC__
#include "CCharOutputSink_AC.h"
#endif

#ifndef __CYielder_AC__
#include "CYielder_AC.h"
#endif

// Toolbox

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __OPENTRANSPORT__
#include <OpenTransport.h>
#endif

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

// ANSI

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STRING_H
#include <string.h>
#endif


//========================================================================================
// Constants
//========================================================================================

enum
{
	kSE					= 240,
	kNOP				= 241,
	kDataMark			= 242,
	kBreak				= 243,
	kInterruptProcess	= 244,
	kAbortOutput		= 245,
	kAreYouThere		= 246,
	kEraseCharacter		= 247,
	kEraseLine			= 248,
	kGoAhead			= 249,
	kSB					= 250,
	kWill				= 251,
	kWont				= 252,
	kDo					= 253,
	kDont				= 254,
	kIAC				= 255
};

// Telnet option code defines
enum
{
	kEcho				= 1,
	kSuppressGoAhead	= 3,
	kTerminalType		= 24
};

// Indices into the option list
enum
{
	kSuppressGAIndex	= 0,
	kEchoIndex			= 1,
	kTerminalTypeIndex	= 2
};

// terminal type subnegotiation commands
enum
{
	kTerminalTypeIs		= 0,
	kSendTerminalType	= 1
};

//========================================================================================
// CTerminalProtocol
//========================================================================================

//----------------------------------------------------------------------------------------
// Construction and Destruction
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CTerminalProtocol::CTerminalProtocol(CYielder_AC* yielder, CCharOutputSink_AC& log,
									 MConnectionTrace* inProgress)
	:	fTCPEndpoint(yielder, inProgress),
		fLog(log),
		fWasConnected(false),
		fTelnetMode(false),
		fLocalEcho(true),
		fWriteBuffer()
{
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

CTerminalProtocol::CTerminalProtocol(const CTerminalProtocol& from)
	:	fTCPEndpoint(from.fTCPEndpoint),
		fLog(from.fLog),
		fWasConnected(false),
		fTelnetMode(false),
		fLocalEcho(from.fLocalEcho),
		fWriteBuffer()
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CTerminalProtocol::~CTerminalProtocol()
{
}

//----------------------------------------------------------------------------------------
// IsConnected
//----------------------------------------------------------------------------------------

bool CTerminalProtocol::IsConnected() const
{
	return fTCPEndpoint.IsConnected();
}

//----------------------------------------------------------------------------------------
// IsDone
//----------------------------------------------------------------------------------------

bool CTerminalProtocol::IsDone() const
{
	return fWasConnected && !IsConnected();
}

//----------------------------------------------------------------------------------------
// Cancel
//----------------------------------------------------------------------------------------

void CTerminalProtocol::Cancel(OSStatus error)
{
	fTCPEndpoint.Cancel(error);
}

//----------------------------------------------------------------------------------------
// Connect
//----------------------------------------------------------------------------------------

void CTerminalProtocol::Connect(const InetAddress& inAddress)
{
	fTCPEndpoint.Open();
	fTCPEndpoint.Bind();
	fTCPEndpoint.Connect(inAddress);
	fWasConnected = true;
	fTelnetMode = (inAddress.fPort == kTelnetPort);
}

//----------------------------------------------------------------------------------------
// Close
//----------------------------------------------------------------------------------------

OSStatus CTerminalProtocol::Close()
{
	fTCPEndpoint.Disconnect();
	return fTCPEndpoint.Close();
}

//----------------------------------------------------------------------------------------
// Send
//----------------------------------------------------------------------------------------

void CTerminalProtocol::Send(const char* text, size_t count)
{
	fWriteBuffer.append(text, count);
}

//----------------------------------------------------------------------------------------
// SendDo
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendDo(char option)
{		
	char optionString[] = {kIAC, kDo, option};
	Send(optionString, sizeof(optionString));
}

//----------------------------------------------------------------------------------------
// SendDont
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendDont(char option)
{		
	char optionString[] = {kIAC, kDont, option};
	Send(optionString, sizeof(optionString));
}

//----------------------------------------------------------------------------------------
// SendOption
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendOption(bool doOption, char option)
{		
	char optionString[] = {kIAC, (doOption ? kDo : kDont), option};
	Send(optionString, sizeof(optionString));
}

//----------------------------------------------------------------------------------------
// SendInterruptProcess
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendInterruptProcess()
{
	SendTelnetCommand(kInterruptProcess);
}

//----------------------------------------------------------------------------------------
// SendAbortOutput
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendAbortOutput()
{
	SendTelnetCommand(kAbortOutput);
}

//----------------------------------------------------------------------------------------
// SendAreYouThere
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendAreYouThere()
{
	SendTelnetCommand(kAreYouThere);
}

//----------------------------------------------------------------------------------------
// SendEraseCharacter
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendEraseCharacter()
{
	SendTelnetCommand(kEraseCharacter);
}

//----------------------------------------------------------------------------------------
// SendEraseLine
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendEraseLine()
{
	SendTelnetCommand(kEraseLine);
}

//----------------------------------------------------------------------------------------
// SendBreak
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendBreak()
{
	SendTelnetCommand(kBreak);
}

//----------------------------------------------------------------------------------------
// SendTelnetCommand
//----------------------------------------------------------------------------------------

void CTerminalProtocol::SendTelnetCommand(char command)
{
	char commandString[] = {kIAC, command};
	Transmit(commandString, sizeof(commandString));
}

//----------------------------------------------------------------------------------------
// Flush
//----------------------------------------------------------------------------------------

void CTerminalProtocol::Flush()
{
	size_t count = fWriteBuffer.GetSize();
	if (count > 0)
	{
		Transmit(fWriteBuffer, count);
		fWriteBuffer.SetSize(0);
	}
}

//----------------------------------------------------------------------------------------
// Transmit
//----------------------------------------------------------------------------------------

void CTerminalProtocol::Transmit(const char* text, size_t count)
{
	fTCPEndpoint.Send(text, count);
}

//----------------------------------------------------------------------------------------
// Available
//----------------------------------------------------------------------------------------

long CTerminalProtocol::Available()
{
	return fTCPEndpoint.Available();
}

//----------------------------------------------------------------------------------------
// Receive
//----------------------------------------------------------------------------------------

long CTerminalProtocol::Receive(char* buffer, size_t maxlen, OTTimeout timeout)
{
	long result = 0;

	fTCPEndpoint.Receiving(maxlen);

	long available = fTCPEndpoint.Available();
	if (timeout && !available)
	{
		OTTimeStamp startTime;
		OTGetTimeStamp(&startTime);
		UInt32 elapsed = 0;
		CYielder_AC* yielder = fTCPEndpoint.GetYielder();
		do
		{
			if (yielder)
				yielder->YieldIfTime();
			
			fTCPEndpoint.ThrowIfCanceled();

			available = fTCPEndpoint.Available();
			elapsed = OTElapsedMilliseconds(&startTime);
		}
		while ((elapsed < timeout) && !available);
	}

	if (available > 0)
	{
		result = fTCPEndpoint.Receive(buffer, Min_AC(available, maxlen));
		if (result > 0)
			fTCPEndpoint.Received(buffer, result);
		else if (result < 0)
			Close();
	}

	return result;
}


//----------------------------------------------------------------------------------------
// End of CTerminalProtocol.cpp
