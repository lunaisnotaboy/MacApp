//----------------------------------------------------------------------------------------
// COpenTransport.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/04/00	Init and close in context for Carbon. 
		02/16/00	Include TidyHeap and Gestalt. 
		06/14/99	Add MUsingOpenTransport and CUsingOpenTransport to manage the
							ref counting instead of using a CRefCountingPtr. 
		06/08/99	Initial version. 
*/

#ifndef __COpenTransport__
#include "COpenTransport.h"
#endif

// Network

#ifndef __Transport__
#include "Transport.h"
#endif

// ACS

#ifndef __Configuration_AC__
#include "Configuration_AC.h"
#endif

#ifndef __TidyHeap_AC__
#include "TidyHeap_AC.h"
#endif

// Toolbox

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

// ANSI


//========================================================================================
// COpenTransport
//========================================================================================

//----------------------------------------------------------------------------------------
// COpenTransport global data
//----------------------------------------------------------------------------------------

COpenTransport* COpenTransport::fInstance;

//----------------------------------------------------------------------------------------
// COpenTransport constructor
//----------------------------------------------------------------------------------------

COpenTransport::COpenTransport()
#if qCarbon
	: fClientContext(NULL)
#endif
{
#if qCarbon
	ThrowIfOSStatus( InitOpenTransportInContext(kInitOTForApplicationMask, &fClientContext) );
#else
	ThrowIfOSStatus( InitOpenTransport() );
#endif
}

//----------------------------------------------------------------------------------------
// COpenTransport destructor
//----------------------------------------------------------------------------------------

COpenTransport::~COpenTransport()
{
#if qCarbon
	CloseOpenTransportInContext(fClientContext);
	fClientContext = NULL;
#else
	CloseOpenTransport();
#endif
}

//----------------------------------------------------------------------------------------
// COpenTransport::GestaltOpenTransport
//----------------------------------------------------------------------------------------

long COpenTransport::GestaltOpenTransport()
{
	static bool defined;
	static long response;
	if (!defined)
	{
		defined = true;
		OSErr err = ::Gestalt(gestaltOpenTpt, &response);
	}
	return response;
}

//----------------------------------------------------------------------------------------
// COpenTransport::OpenTransportVersion
//----------------------------------------------------------------------------------------

long COpenTransport::OpenTransportVersion()
{
	static bool defined;
	static long response;
	if (!defined)
	{
		defined = true;
		OSErr err = ::Gestalt(gestaltOpenTptVersions, &response);
	}
	return response;
}

//----------------------------------------------------------------------------------------
// COpenTransport::HasOpenTransport
//----------------------------------------------------------------------------------------

bool COpenTransport::HasOpenTransport()
{
	static bool defined;
	static bool value;
	if (!defined)
	{
		defined = true;
		value = (GestaltOpenTransport() & gestaltOpenTptPresentMask) != 0;
		if (value)
		{
			long version = OpenTransportVersion();
			if (version < 0x01108000)	// version 1.1f0
				value = false;
		}
	}
	return value;
}

//----------------------------------------------------------------------------------------
// COpenTransport::HasOpenTransportTCP
//----------------------------------------------------------------------------------------

bool COpenTransport::HasOpenTransportTCP()
{
	static bool defined;
	static bool value;
	if (!defined)
	{
		defined = true;
		value = (GestaltOpenTransport() & gestaltOpenTptTCPPresentMask) != 0;
	}
	return value;
}

//----------------------------------------------------------------------------------------
// COpenTransport::Initialize
//----------------------------------------------------------------------------------------

void COpenTransport::Initialize()
{
	if ((fInstance == NULL) && HasOpenTransport() && HasOpenTransportTCP())
		fInstance = TH_new COpenTransport();

	AcquireObject(fInstance);
}

//----------------------------------------------------------------------------------------
// COpenTransport::Terminate
//----------------------------------------------------------------------------------------

void COpenTransport::Terminate()
{
	ReleaseObject(fInstance);
}

#if qCarbon
//----------------------------------------------------------------------------------------
// COpenTransport::GetClientContext
//----------------------------------------------------------------------------------------

OTClientContextPtr COpenTransport::GetClientContext()
{
	return fInstance ? fInstance->fClientContext : NULL;
}
#endif


//========================================================================================
// MUsingOpenTransport
//========================================================================================

//----------------------------------------------------------------------------------------
// MUsingOpenTransport constructor
//----------------------------------------------------------------------------------------

MUsingOpenTransport::MUsingOpenTransport()
{
	COpenTransport::Initialize();
}

//----------------------------------------------------------------------------------------
// MUsingOpenTransport destructor
//----------------------------------------------------------------------------------------

MUsingOpenTransport::~MUsingOpenTransport()
{
	COpenTransport::Terminate();
}


//----------------------------------------------------------------------------------------
// End of COpenTransport.cpp