//----------------------------------------------------------------------------------------
// CTCPEndpoint.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/24/00	Finish separating char I/O from endpoints. 
							Isolate clients from look errors. 
							Stay within buffer in receive. Return whatever data is available. 
		05/22/00	Use CReceived for TCP as well as RawIP. 
							Support timeout on receive. 
		05/20/00	Make CIPEndpoint as a common base class for CRawIPEndpoint and
							CTCPEndpoint. 
		05/18/00	Close just closes. 
		05/17/00	Don't need busy flag. Disconnect returns status. 
							Handle look errors when checking for data. 
		05/15/00	CW Pro 6: namespacing. 
		05/12/00	Open endpoint in context for Carbon. 
							Need a UPP for the notify proc. 
		04/08/00	Add methods for getting and setting internet IP options. 
							Add CancelAll. 
							Make the passed in addresses const. 
							Add some more flavors of Bind. 
							Disconnect attempts to receive the orderly disconnect, and it
							doesn't throw if there's an error. 
		03/31/00	Default constructor doesn't open the endpoint. 
							Connect doesn't bind. Unbind doesn't throw. 
							Add receive method. Handle look errors when reading. 
		02/07/00	Revised for new threads implementation. 
		10/24/99	Received needs to get a pointer to the beginning, not the end
							of the received data. 
							Add WarnIfMainThread. 
		10/13/99	getline and getstring now can return line terminator.
		09/16/99	Optionally compile logging based on qMacApp.
		08/30/99	Added putline which understands strings.  Added getstring.
		08/16/99	Work around kOTOutStateErr in Available. 
		08/16/99	Merged CEndpoint into CTCPEndpoint. 
							Changed the send and receive methods to be like standard
							stream methods. 
							Moved progress and debug logging into MConnectionTrace. 
		07/21/99	Skip empty strings in debug trace. 
							Do a sync idle while waiting for data to show up. 
		06/22/99	Initial version. 
*/

#ifndef __CTCPEndpoint__
#include "CTCPEndpoint.h"
#endif

// Network

#ifndef __CCall__
#include "CCall.h"
#endif

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __COpenTransport__
#include "COpenTransport.h"
#endif

#ifndef __COption__
#include "COption.h"
#endif

#if qDebug && qMacApp
	#ifndef __ULogWindow__
	#include "ULogWindow.h"
	#endif
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CYielder_AC__
#include "CYielder_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

// Toolbox

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

// ANSI

//========================================================================================
// CTCPEndpoint
//========================================================================================

//----------------------------------------------------------------------------------------
// Construction and Destruction
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CTCPEndpoint::CTCPEndpoint(CYielder_AC* yielder, MConnectionTrace* inProgress)
	:	CIPEndpoint(yielder, inProgress)
{
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CTCPEndpoint::CTCPEndpoint(CYielder_AC* yielder, const InetAddress& inAddress, MConnectionTrace* inProgress)
	:	CIPEndpoint(yielder, inProgress)
{
	Open();
	Bind();
	Connect(inAddress);
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CTCPEndpoint::CTCPEndpoint(CYielder_AC* yielder, const DNSAddress& inAddress, MConnectionTrace* inProgress)
	:	CIPEndpoint(yielder, inProgress)
{
	Open();
	Bind();
	Connect(inAddress);
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

CTCPEndpoint::CTCPEndpoint(const CTCPEndpoint& from)
	:	CIPEndpoint(from)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CTCPEndpoint::~CTCPEndpoint()
{
}

//----------------------------------------------------------------------------------------
// Connect and Disconnect
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Connect
//----------------------------------------------------------------------------------------

void CTCPEndpoint::Connect(const InetAddress& inAddress)
{
	WarnIfMainThread();
//	Assertion_AC(IsBound(), NULL);

	Connecting(inAddress);

	CInetAddress address(inAddress); // because there is no CConstCall. 
	CCall sndCall(address);
	OSStatus status = fEndpoint->Connect(&sndCall, NULL);
	if (status == kOTLookErr)
		HandleLook();
	else
		ThrowIfOSStatus(status);
}

//----------------------------------------------------------------------------------------
// Connect
//----------------------------------------------------------------------------------------

void CTCPEndpoint::Connect(const DNSAddress& inAddress)
{
	WarnIfMainThread();
//	Assertion_AC(IsBound(), NULL);

	Connecting(inAddress);

	CDNSAddress address(inAddress); // because there is no CConstCall. 
	CCall sndCall(address);
	OSStatus status = fEndpoint->Connect(&sndCall, NULL);
	if (status == kOTLookErr)
		HandleLook();
	else
		ThrowIfOSStatus(status);
}

//----------------------------------------------------------------------------------------
// Disconnect
//----------------------------------------------------------------------------------------

OSStatus CTCPEndpoint::Disconnect()
{
	OSStatus err = noErr;
	
	WarnIfMainThread();

	if (fEndpoint)
	{
		Disconnecting();

		err = fEndpoint->SndOrderlyDisconnect();
		if (!err)
			err = fEndpoint->RcvOrderlyDisconnect();
	}

	return err;
}

//----------------------------------------------------------------------------------------
// HandleLook
//----------------------------------------------------------------------------------------

OSStatus CTCPEndpoint::HandleLook()
{
	OSStatus err = noErr;
	
	WarnIfMainThread();
	Assertion_AC(fEndpoint != kOTInvalidEndpointRef, NULL);

	OTResult lookResult = fEndpoint->Look();
	switch (lookResult)
	{
		case T_DISCONNECT:
			// If we get a T_DISCONNECT event, the remote peer
			// has disconnected the stream in a dis-orderly
			// fashion.  HTTP servers will often just disconnect
			// a connection like this to indicate the end of the
			// data, so all we need do is clear the T_DISCONNECT
			// event on the endpoint.

			err = fEndpoint->RcvDisconnect(NULL);
			break;
			
		case T_ORDREL:
			// If we get a T_ORDREL event, the remote peer
			// has disconnected the stream in an orderly
			// fashion.  This orderly disconnect indicates that
			// the end of the data.  We respond by clearing
			// the T_ORDREL, and then calling OTSndOrderlyDisconnect
			// to acknowledge the orderly disconnect at
			// the remote peer.
			
			err = fEndpoint->SndOrderlyDisconnect();
			if (!err)
				err = fEndpoint->RcvOrderlyDisconnect();
			break;
			
		default:
			break;
	}

	return err;
}

//----------------------------------------------------------------------------------------
// Output
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Send
//----------------------------------------------------------------------------------------

void CTCPEndpoint::Send(const char* p, size_t n)
{
	enum { kDefaultSendSize = 1024 * 4 };

	WarnIfMainThread();
	Assertion_AC(fEndpoint != kOTInvalidEndpointRef, NULL);
//	Assertion_AC(MaySend(), NULL);

	Sending(p, n);
	
	const char* buf = p;
	size_t amountLeft = n;
	while (amountLeft > 0)
	{
		size_t bufSize = Min_AC(amountLeft, kDefaultSendSize);
			
		OTResult result = fEndpoint->Snd(const_cast<char*>(buf), bufSize, 0);
		if (result < 0)
			ThrowIfOSStatus(result);

		Sent(buf, bufSize);

		buf += bufSize;
		amountLeft -= bufSize;
	}
}

//----------------------------------------------------------------------------------------
// Input
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Available
//----------------------------------------------------------------------------------------

long CTCPEndpoint::Available()
{
	WarnIfMainThread();
	Assertion_AC(fEndpoint != kOTInvalidEndpointRef, NULL);
//	Assertion_AC(MayReceive(), NULL);

	OTByteCount count = 0;
	OSStatus result = fEndpoint->CountDataBytes(&count);
	long available = count;
	if (result == kOTLookErr)
	{
		HandleLook();
		available = -1;
	}
	else if (result != kOTNoDataErr)
		ThrowIfOSStatus(result);

	return available;
}

//----------------------------------------------------------------------------------------
// Receive
//----------------------------------------------------------------------------------------

CReceived CTCPEndpoint::Receive(char* buffer, size_t maxlen, OTTimeout timeout)
{
	WarnIfMainThread();

	Assertion_AC(fEndpoint != kOTInvalidEndpointRef, NULL);
//	Assertion_AC(MayReceive(), NULL);

	CReceived received;

	long available = Available();
	if (timeout && !available)
	{
		OTTimeStamp startTime;
		OTGetTimeStamp(&startTime);
		UInt32 elapsed = 0;
		do
		{
			Idle();
			available = Available();
			elapsed = OTElapsedMilliseconds(&startTime);
		}
		while ((elapsed < timeout) && !available);

		if (!available)
			received.Set(T_TIMEDOUT);
	}

	if (available <= 0)
	{
		received = available;
	}
	else
	{
		if (maxlen > available)
			maxlen = available;

		OTResult result = fEndpoint->Rcv(buffer, maxlen, &received.fFlags);
		if (result >= 0)
		{
			received = result;
		}
		else if (result == kOTLookErr)
		{
			HandleLook();
			received = -1;
		}
		else if (result != kOTNoDataErr)
		{
			ThrowIfOSStatus(result);
		}
	}

	return received;
}


//----------------------------------------------------------------------------------------
// End of CTCPEndpoint.cpp
