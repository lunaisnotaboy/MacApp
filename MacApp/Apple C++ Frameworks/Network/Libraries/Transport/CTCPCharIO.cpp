//----------------------------------------------------------------------------------------
// CTCPCharIO.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		10/02/00	Use std::string.
		05/24/00	Finish separating char I/O from endpoints. 
		05/23/00	Use \r and \n only internally. 
		05/21/00	Split off CTCPCharIO from CTCPEndpoint. 
*/

#ifndef __CTCPCharIO__
#include "CTCPCharIO.h"
#endif

// Network

#ifndef __ASCII__
#include "ASCII.h"
#endif

#ifndef __CMemBlock__
#include "CMemBlock.h"
#endif

#ifndef __COpenTransport__
#include "COpenTransport.h"
#endif

// ACS

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

// Toolbox

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

// ANSI

using std::strlen;
using std::string;

//========================================================================================
// CTCPCharIO
//========================================================================================

//----------------------------------------------------------------------------------------
// Construction and Destruction
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CTCPCharIO::CTCPCharIO(CYielder_AC* yielder, MConnectionTrace* inProgress)
	:	CTCPEndpoint(yielder, inProgress),
		fLastGetCount(0)
{
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CTCPCharIO::CTCPCharIO(CYielder_AC* yielder, const InetAddress& inAddress, MConnectionTrace* inProgress)
	:	CTCPEndpoint(yielder, inAddress, inProgress),
		fLastGetCount(0)
{
	Open();
	Bind();
	Connect(inAddress);
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CTCPCharIO::CTCPCharIO(CYielder_AC* yielder, const DNSAddress& inAddress, MConnectionTrace* inProgress)
	:	CTCPEndpoint(yielder, inAddress, inProgress),
		fLastGetCount(0)
{
	Open();
	Bind();
	Connect(inAddress);
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

CTCPCharIO::CTCPCharIO(const CTCPCharIO& from)
	:	CTCPEndpoint(from),
		fLastGetCount(0)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CTCPCharIO::~CTCPCharIO()
{
}

//----------------------------------------------------------------------------------------
// Output
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// putline
//----------------------------------------------------------------------------------------

CTCPCharIO& CTCPCharIO::putline(const char* p)
{
	if (p)
	{
		// Buffer the line so it's a single write
		int len = strlen(p);
		CAutoMemBlock tempLine;
		tempLine.reallocate(len + 2);
		BlockMove_AC(p, tempLine, len);
		tempLine[len++] = kCRChar;
		tempLine[len++] = kLFChar;
		write(tempLine, len);
	}
	else
	{
		char CRLF[] = {kCRChar, kLFChar};
		write(CRLF, sizeof(CRLF));
	}

	return *this;
}

//----------------------------------------------------------------------------------------
// putline
//----------------------------------------------------------------------------------------

CTCPCharIO& CTCPCharIO::putline(const string& aString)
{
	// Buffer the line so it's a single write
	string tempString = aString + char(kCRChar) + char(kLFChar);
	write(tempString.data(), tempString.size());

	return *this;
}

//----------------------------------------------------------------------------------------
// write
//----------------------------------------------------------------------------------------

CTCPCharIO& CTCPCharIO::write(const char* p, size_t n)
{
	Send(p, n);
	return *this;
}

//----------------------------------------------------------------------------------------
// Input
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// showmanyc
//----------------------------------------------------------------------------------------

long CTCPCharIO::showmanyc()
{
	return Available();
}

//----------------------------------------------------------------------------------------
// getline
//----------------------------------------------------------------------------------------

CTCPCharIO& CTCPCharIO::getline(char* p, size_t n)
{
	size_t count = 0;

	const char* buf = p;
	Receiving(n);
	{
		InhibitTracing tempInhibit(*this);

		while (count < n)
		{
			*p = 0;
			
			char c;
			if (get(c).gcount() != 1)
				break;

			if (c == kCRChar)
			{
				*p++ = c;
				*p = 0;
				++count;

				c = get();
				Assertion_AC(c == kLFChar, NULL);
				if (c == kLFChar)
				{
					*p++ = c;
					*p = 0;
					++count;
				}
				break;
			}
			
			*p++ = c;
			++count;
		}
	}
	Received(buf, count);

	return *this;
}

//----------------------------------------------------------------------------------------
// getstring
//----------------------------------------------------------------------------------------

CTCPCharIO& CTCPCharIO::getstring(string& aString)
// Fetch a line and return it as a string.
{
	char theLine[1026];
	getline(static_cast<char*>(theLine), 1024);
	aString = theLine;
	return *this;
}

//----------------------------------------------------------------------------------------
// ignore
//----------------------------------------------------------------------------------------

CTCPCharIO& CTCPCharIO::ignore(size_t n /*, int t*/)
{
	char c;
	while ((n-- > 0) && (get(c).gcount() == 1))
	{
	}

	return *this;
}

//----------------------------------------------------------------------------------------
// read
//----------------------------------------------------------------------------------------

CTCPCharIO& CTCPCharIO::read(char* p, size_t n)
{
	WarnIfMainThread();

	fLastGetCount = 0;

	Receiving(n);

	long count = Available();
	if (n && !count && MayReceive())
	{
		// Nothing's happening, so let's give the rest of the system some time. 
		Idle();
	}

	if (n > count)
		n = count;

	if (n > 0)
	{
		fLastGetCount = Receive(p, n);
		if (fLastGetCount >= 0)
			Received(p, fLastGetCount);
	}

	return *this;
}


//----------------------------------------------------------------------------------------
// End of CTCPCharIO.cpp
