//----------------------------------------------------------------------------------------
// CBlocking.cpp
// Copyright © 2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		02/17/00	Initial version. 
*/

#ifndef __CBlocking__
#include "CBlocking.h"
#endif

// Network

// MacApp

// ACS

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// Toolbox

// ANSI

#if qDebug
	#ifndef _STDIO_H
	#include <stdio.h>
	#endif
#endif

//========================================================================================
// CBlocking
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CBlocking::CBlocking(EndpointRef endpoint)
	:	fEndpoint(endpoint),
		fWasBlocking(endpoint->IsBlocking())
{
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CBlocking::CBlocking(EndpointRef endpoint, bool blocking)
	:	fEndpoint(endpoint),
		fWasBlocking(endpoint->IsBlocking())
{
	if (blocking != fWasBlocking)
	{
		if (blocking)
			ThrowIfOSStatus(fEndpoint->SetBlocking());
		else
			ThrowIfOSStatus(fEndpoint->SetNonBlocking());
	}
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CBlocking::~CBlocking()
{
	if (fEndpoint && (fEndpoint->IsBlocking() != fWasBlocking))
	{
		if (fWasBlocking)
		{
#if qDebug
			printf("turning blocking back on\n");
#endif
			ThrowIfOSStatus(fEndpoint->SetBlocking());
		}
		else
		{
#if qDebug
			printf("turning blocking back off\n");
#endif
			ThrowIfOSStatus(fEndpoint->SetNonBlocking());
		}
	}
}


//----------------------------------------------------------------------------------------
// End of CBlocking.cpp
