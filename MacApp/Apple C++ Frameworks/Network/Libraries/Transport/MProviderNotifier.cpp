//----------------------------------------------------------------------------------------
// MProviderNotifier.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/15/00	CW Pro 6: can't static cast void* to non-pointer. 
		02/23/00	Split off MSyncIdler. 
		06/07/99	Initial version. 
*/

#ifndef __MProviderNotifier__
#include "MProviderNotifier.h"
#endif

// Network

#ifndef __COpenTransport__
#include "COpenTransport.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

// Toolbox

// ANSI


//========================================================================================
// MSyncIdler
//========================================================================================

//----------------------------------------------------------------------------------------
// MSyncIdler::NotifyProc
//----------------------------------------------------------------------------------------

pascal void MSyncIdler::NotifyProc(void* contextPtr, OTEventCode code, OTResult result,
								   void* cookie)
{
	static_cast<MSyncIdler*>(contextPtr)->HandleOTEvent(code, result, cookie);
}

//----------------------------------------------------------------------------------------
// MSyncIdler::HandleOTEvent
//----------------------------------------------------------------------------------------

void MSyncIdler::HandleOTEvent(OTEventCode code, OTResult result, void* cookie)
{
#pragma unused (result, cookie)

	if (code == kOTSyncIdleEvent)
		HandleSyncIdleEvent();
}

//----------------------------------------------------------------------------------------
// MSyncIdler::HandleSyncIdleEvent
//----------------------------------------------------------------------------------------

void MSyncIdler::HandleSyncIdleEvent()
// A synchronous call is waiting to complete. Call the
// function YieldToAnyThread from your notiﬁer to allow
// other concurrent processes to obtain processing time. See
// “Using Synchronous Processing With Threads” (page 130)
// for more information.
{
}


//========================================================================================
// MProviderNotifier
//========================================================================================

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleOTEvent
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleOTEvent(OTEventCode code, OTResult result, void* cookie)
{
	if (code == kOTSyncIdleEvent)
		HandleSyncIdleEvent();
	else if (((code) & 0x7f000000L) == 0)
		HandleAsyncEvent(code, result, cookie);
	else if (IsOTPrivateEvent(code))
		HandlePrivateEvent(code, result, cookie);
	else if (IsOTCompleteEvent(code))
		HandleCompleteEvent(code, result, cookie);
	else if (IsOTProtocolEvent(code))
		HandleProtocolEvent(code, result, cookie);
	else if (IsOTStreamEvent(code))
		HandleStreamEvent(code, result, cookie);
	else if (IsOTSignalEvent(code))
		HandleSignalEvent(code, result, cookie);
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleAsyncEvent
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleAsyncEvent(OTEventCode code, OTResult result, void* cookie)
{
	switch (code)
	{
		// These will be returned by the T_LOOK function, or will be returned
		// if asynchronous notification is used.

		case T_LISTEN:	// An connection request is available
			HandleListen(result);
			break;

		case T_CONNECT:	// Confirmation of a connect request
			HandleConnect(result, static_cast<TCall*>(cookie));
			break;

		case T_DATA:	// Standard data is available
			HandleData(result);
			break;

		case T_EXDATA:	// Expedited data is available
			HandleExpeditedData(result);
			break;

		case T_DISCONNECT:	// A disconnect is available
			HandleDisconnect(result, static_cast<TCall*>(cookie));
			break;

		case T_ERROR:	// obsolete/unused in library
			break;

		case T_UDERR:	// A Unit Data Error has occurred
			HandleUnitDataError(result);
			break;

		case T_ORDREL:	// An orderly release is available
			HandleOrderlyRelease(result);
			break;

		case T_GODATA:	// Flow control lifted on standard data
			HandleGoData(result);
			break;

		case T_GOEXDATA:	// Flow control lifted on expedited data
			HandleGoExpeditedData(result);
			break;

		case T_REQUEST:	// An Incoming request is available
			HandleRequest(result);
			break;

		case T_REPLY:	// An Incoming reply is available
			HandleReply(result);
			break;

		case T_PASSCON:	// State is now T_DATAXFER
			HandlePassConnection(result, static_cast<EndpointRef>(cookie));
			break;

		case T_RESET:	// Protocol has been reset
			HandleReset(result);
			break;

		default:
			break;
	}
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleListen
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleListen(OTResult result)
// A connection request has arrived. Call the OTListen
// function to read the request.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleConnect
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleConnect(OTResult result, TCall* sndCall)
// The passive peer has accepted a connection that you
// requested using the OTConnect function. Call the
// OTRcvConnect function to retrieve any data or option
// information that the passive peer has speciﬁed when
// accepting the connection or to retrieve the address to
// which you are actually connected. The cookie parameter to
// the notiﬁer function is the sndCall parameter that you
// speciﬁed when calling the OTConnect function.
{
#pragma unused (result, sndCall)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleData
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleData(OTResult result)
// Normal data has arrived. Depending on the type of service
// of the endpoint you are using, you can call the OTRcvUData
// function or the OTRcv function to read it. Continue reading
// data until the function returns with the kOTNoDataErr
// result; you will not get another indication that data has
// arrived until you have read all the data and got this error.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleExpeditedData
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleExpeditedData(OTResult result)
// Expedited data has arrived. Use the OTRcv function to read
// it. Continue reading data by calling the OTRcv function
// until the function returns with the kOTNoDataErr result; you
// will not get another indication that data has arrived until
// you have read all the data and got this error.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleDisconnect
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleDisconnect(OTResult result, TCall* sndCall)
// A connection has been torn down or rejected. Use the
// OTRcvDisconnect function to clear the event.
// If the event is used to signify that a connection has been
// terminated, the cookie parameter to the notiﬁer is NULL.
// If the event indicates a rejected connection request, the
// cookie parameter to the notification routine is the same as
// the sndCall parameter that you passed to the OTConnect
// function.
{
#pragma unused (result, sndCall)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleUnitDataError
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleUnitDataError(OTResult result)
// The provider was not able to send the data you speciﬁed
// using the OTSndUData function even though the function
// returned successfully. You must call the OTRcvUDErr
// function to clear this event and determine why the
// function failed.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleOrderlyRelease
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleOrderlyRelease(OTResult result)
// The remote client has called the OTSndOrderlyDisconnect
// function to initiate an orderly disconnect. You must call the
// OTRcvOrderlyDisconnect function to acknowledge receiving
// the event.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleGoData
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleGoData(OTResult result)
// Flow-control restrictions have been lifted. You can now
// send normal data.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleGoExpeditedData
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleGoExpeditedData(OTResult result)
// Flow-control restrictions have been lifted. You can now
// send expedited data.
{
	HandleGoData(result);
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleRequest
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleRequest(OTResult result)
// A request has arrived. Depending on the type of service
// for the endpoint you are using, you can call the
// OTRcvRequest function or the OTRcvURequest function to
// receive it. You must continue to call the function until it
// returns with the kOTNoDataErr result.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleReply
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleReply(OTResult result)
// A response to a request has arrived. Depending on the
// type of service of the endpoint you are using, you can call
// the OTRcvReply function or OTRcvUReply function to receive
// it. You must continue to call the function until it returns
// with the kOTNoDataErr result.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandlePassConnection
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandlePassConnection(OTResult result, EndpointRef resRef)
// When the OTAccept function completes, the endpoint
// provider passes this event to the endpoint receiving the
// connection (whether that endpoint is the same as or
// different from the endpoint that calls the OTAccept
// function). The cookie parameter contains the resRef
// parameter to the OTAccept function.
{
#pragma unused (result, resRef)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleReset
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleReset(OTResult result)
// A connection-oriented endpoint has received a reset from
// the remote end and has ﬂushed all unread and unsent
// data. This only occurs for some types of endpoints, and it
// generally leaves the endpoint in an unknown state.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandlePrivateEvent
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandlePrivateEvent(OTEventCode code, OTResult result, void* cookie)
// kPRIVATEEVENT + 1 through kPRIVATEEVENT + 0xffff
// may be used for any private event codes desired.
// All other event codes are reserved for Apple Computer, Inc.
// use only.
{
#pragma unused (code, result, cookie)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleCompleteEvent
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleCompleteEvent(OTEventCode code, OTResult result, void* cookie)
{
	switch (code)
	{
		// These are only returned if asynchronous notification is being used

		case T_BINDCOMPLETE:	// Bind call is complete
			BindComplete(result, static_cast<TBind*>(cookie));
			break;

		case T_UNBINDCOMPLETE:	// Unbind call is complete
			UnbindComplete(result);
			break;

		case T_ACCEPTCOMPLETE:	// Accept call is complete
			AcceptComplete(result, static_cast<EndpointRef>(cookie));
			break;

		case T_REPLYCOMPLETE:	// SendReply call is complete
			ReplyComplete(result, reinterpret_cast<OTSequence>(cookie));
			break;

		case T_DISCONNECTCOMPLETE:	// Disconnect call is complete
			DisconnectComplete(result, static_cast<TCall*>(cookie));
			break;

		case T_OPTMGMTCOMPLETE:	// OptMgmt call is complete
			OptionManagementComplete(result, static_cast<TOptMgmt*>(cookie));
			break;

		case T_OPENCOMPLETE:	// An Open call is complete
			OpenComplete(result, static_cast<ProviderRef>(cookie));
			break;

		case T_GETPROTADDRCOMPLETE:	// GetProtAddress call is complete
			GetProtocolAddressComplete(result, static_cast<TBind*>(cookie));
			break;

		case T_RESOLVEADDRCOMPLETE:	// A ResolveAddress call is complete
			ResolveAddressComplete(result, static_cast<TBind*>(cookie));
			break;

		case T_GETINFOCOMPLETE:	// A GetInfo call is complete
			GetInfoComplete(result, static_cast<TEndpointInfo*>(cookie));
			break;

		case T_SYNCCOMPLETE:	// A Sync call is complete
			SyncComplete(result);
			break;

		case T_MEMORYRELEASED:	// No-copy memory was released
			MemoryReleased(result, cookie);
			break;

		case T_REGNAMECOMPLETE:	// A RegisterName call is complete
			RegisterNameComplete(result, cookie);
			break;

		case T_DELNAMECOMPLETE:	// A DeleteName call is complete
			DeleteNameComplete(result, cookie);
			break;

		case T_LKUPNAMECOMPLETE:	// A LookupName call is complete
			LookupNameComplete(result, static_cast<TLookupReply*>(cookie));
			break;

		case T_LKUPNAMERESULT:	// A LookupName is returning a name
			LookupNameResult(result, static_cast<TLookupReply*>(cookie));
			break;

		//case kOTSyncIdleEvent:	// Synchronous call Idle event
		//	break;

		default:
			break;
	}
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::BindComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::BindComplete(OTResult result, TBind* retAddr)
// The OTBind function has completed. The cookie parameter
// contains the retAddr parameter of the bind call.
{
#pragma unused (result, retAddr)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::UnbindComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::UnbindComplete(OTResult result)
// The OTUnbind function has completed. The cookie
// parameter is meaningless.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::AcceptComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::AcceptComplete(OTResult result, EndpointRef resRef)
// The OTAccept function has completed. The cookie
// parameter contains the resRef parameter to the OTAccept
// function.
{
#pragma unused (result, resRef)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::ReplyComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::ReplyComplete(OTResult result, OTSequence sequence)
// The OTSndUReply or OTSndReply functions have completed.
// The cookie parameter contains the sequence number used
// in the OTSndUReply or OTSndReply call.
{
#pragma unused (result, sequence)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::DisconnectComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::DisconnectComplete(OTResult result, TCall* call)
// The OTSndDisconnect function has completed. The cookie
// parameter contains the call parameter of the
// OTSndDisconnect function.
{
#pragma unused (result, call)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::OptionManagementComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::OptionManagementComplete(OTResult result, TOptMgmt* ret)
// The OTOptionManagement function has completed. The
// cookie parameter contains the ret parameter that you
// passed to the function.
{
#pragma unused (result, ret)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::OpenComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::OpenComplete(OTResult result, ProviderRef provider)
// An asynchronous call to open a provider has completed.
// The cookie parameter contains the provider reference.
{
#pragma unused (result, provider)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::GetProtocolAddressComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::GetProtocolAddressComplete(OTResult result, TBind* addr)
// The OTGetProtAddress function has completed. The cookie
// parameter contains the peerAddr parameter that you
// passed to the OTGetProtocolAddress function. If you passed
// NULL for that parameter, the cookie parameter contains the
// address passed in the boundAddr parameter.
{
#pragma unused (result, addr)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::ResolveAddressComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::ResolveAddressComplete(OTResult result, TBind* retAddr)
// The OTResolveAddress function has completed. The cookie
// parameter contains the retAddr parameter of the
// OTResolveAddress function.
{
#pragma unused (result, retAddr)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::GetInfoComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::GetInfoComplete(OTResult result, TEndpointInfo* info)
// The OTGetEndpointInfo function has completed. The cookie
// parameter contains the info parameter of the
// OTGetEndpointInfo function.
{
#pragma unused (result, info)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::SyncComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::SyncComplete(OTResult result)
// The OTSync function has completed. The cookie parameter
// is meaningless.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::MemoryReleased
//----------------------------------------------------------------------------------------

void MProviderNotifier::MemoryReleased(long nbytes, void* buf)
// You are using an asynchronous endpoint that
// acknowledges sends and Open Transport is done using the
// buffers containing the data you are sending. If you called
// the OTSnd function, the cookie parameter contains the buf
// parameter. If you called the OTSndUData function, the cookie
// parameter contains the udata parameter. The result
// parameter contains the number of bytes that were sent.
// This might be less than the number you meant to send due
// to ﬂow-control or memory restrictions.
// You should not wait for the T_MEMORYRELEASED event from a
// previous send operation to trigger more sends. The exact
// time this event occurs depends on how the underlying
// provider is implemented. It might hold on to memory until
// the next send occurs, or behave in some other way which
// causes it to delay releasing memory.
// Note that T_MEMORYRELEASED events can reenter your
// notiﬁer. See “OTAckSends” (page 401) for more
// information.
{
#pragma unused (nbytes, buf)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::RegisterNameComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::RegisterNameComplete(OTResult result, void* cookie)
// The OTRegisterName function has completed. The cookie
// parameter is the reply parameter, unless it was NULL. In
// this case, it is the req parameter.
{
#pragma unused (result, cookie)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::DeleteNameComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::DeleteNameComplete(OTResult result, void* cookie)
// The OTDeleteName function or the OTDeleteNameByID
// function has completed. The cookie parameter contains the
// name parameter or the nameId parameter of the function,
// respectively.
{
#pragma unused (result, cookie)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::LookupNameComplete
//----------------------------------------------------------------------------------------

void MProviderNotifier::LookupNameComplete(OTResult result, TLookupReply* reply)
// The OTLookupName function has completed. The cookie
// parameter contains the reply parameter of the
// OTLookupName function.
{
#pragma unused (result, reply)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::LookupNameResult
//----------------------------------------------------------------------------------------

void MProviderNotifier::LookupNameResult(OTResult result, TLookupReply* reply)
// An OTLookupName function has found a name and is
// returning it, but the lookup is not yet complete. The cookie
// parameter contains the reply parameter passed to the
// OTLookupName function.
{
#pragma unused (result, reply)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleProtocolEvent
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleProtocolEvent(OTEventCode code, OTResult result, void* cookie)
// Some event from the protocols
{
#pragma unused (cookie)

	switch (code)
	{
		// These are miscellaneous events that could be sent to a provider

		case kOTProviderIsDisconnected:	// Provider is temporarily off-line
			// Your provider was bound with a qlen parameter value
			// greater than 0 and it has been disconnected (is no longer
			// listening). You receive this event after a port has accepted a
			// request to temporarily yield ownership of a port to another
			// provider, which causes this provider to be disconnected
			// from the port in question. This currently only happens
			// with serial ports, but could also happen with other
			// connection-oriented drivers that have characteristics
			// similar to serial ports. You get a kOTProviderIsReconnected
			// message when the port reverts back to this provider’s
			// ownership again.
			break;

		case kOTProviderIsReconnected:	// Provider is now back on-line
			// Your provider has been reconnected, that is, the cause for
			// its disconnection has been relieved.
			break;

		// These are system events sent to each provider.

		case kOTProviderWillClose:	// Provider will close immediately
			ProviderWillClose(result);
			break;

		case kOTProviderIsClosed:	// Provider was closed
			ProviderIsClosed(result);
			break;

		default:
			break;
	}
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::ProviderWillClose
//----------------------------------------------------------------------------------------

void MProviderNotifier::ProviderWillClose(OTResult result)
// When you return from the notiﬁer function, Open
// Transport will close the provider whose reference is
// contained in the cookie parameter. The result parameter
// contains a result code specifying the reason why the
// provider had to close. For example, the user decided to
// switch links using the TCP/IP or AppleTalk control panel.
// The result codes that can be returned are in the range
// –3280 through –3285; these are documented in “Result
// Codes” (page 785).
// You can only get this event at system task time.
// Consequently, you are allowed to set the endpoint to
// synchronous mode (from within the notiﬁer function) and
// call functions synchronously before you return from the
// notiﬁer, at which point the provider is closed. After this,
// any calls other than OTCloseProvider will fail with a
// kOTOutStateErr.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::ProviderIsClosed
//----------------------------------------------------------------------------------------

void MProviderNotifier::ProviderIsClosed(OTResult result)
// The provider has closed. The reason for being closed can
// be found in the OTResult value passed to your notiﬁer. The
// reasons typically are kOTPortHasDiedErr,
// kOTPortWasEjectedErr, or kOTPortLostConnectionErr. At
// this point, any calls other than OTCloseProvider will fail
// with a kOTOutStateErr.
{
#pragma unused (result)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleStreamEvent
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleStreamEvent(OTEventCode code, OTResult result, void* cookie)
// These are events you get using the STREAMS functions like
// IOCtl, PutMessage, and GetMessage
{
#pragma unused (code, result, cookie)
}

//----------------------------------------------------------------------------------------
// MProviderNotifier::HandleSignalEvent
//----------------------------------------------------------------------------------------

void MProviderNotifier::HandleSignalEvent(OTEventCode code, OTResult result, void* cookie)
// A signal has arrived from the STREAM
{
#pragma unused (code, result, cookie)
}


//----------------------------------------------------------------------------------------
// End of MProviderNotifier.cpp