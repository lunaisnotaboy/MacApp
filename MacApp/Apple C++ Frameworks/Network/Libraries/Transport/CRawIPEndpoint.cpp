//----------------------------------------------------------------------------------------
// CRawIPEndpoint.cpp
// Copyright © 1996-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		10/02/00	Make temporary in GetSendError.
		05/24/00	Finish separating char I/O from endpoints. 
		05/22/00	Change TemplateNetbuf from class to function and specialize
							for DNSAddress. 
							Use CReceived for TCP as well as RawIP. 
		05/20/00	Make CIPEndpoint as a common base class for CRawIPEndpoint and
							CTCPEndpoint. 
		03/21/00	Add ThrowIfCanceled. Call it when waiting for data to be recieved. 
		03/13/00	Hook up progress. 
		02/07/00	Revised for new threads implementation. 
		01/12/00	Based on OTPingSample by Quinn "The Eskimo!"
*/

#ifndef __CRawIPEndpoint__
#include "CRawIPEndpoint.h"
#endif

// Network

#ifndef __CCall__
#include "CCall.h"
#endif

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __CNetbuf__
#include "CNetbuf.h"
#endif

// MacApp

// ACS

#ifndef __CCooperativeThread_AC__
#include "CCooperativeThread_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CYielder_AC__
#include "CYielder_AC.h"
#endif

// Toolbox

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __OPENTRANSPORT__
#include <OpenTransport.h>
#endif

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

// ANSI

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STRING_H
#include <string.h>
#endif

//========================================================================================
// Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// OTTimeStampZero
//----------------------------------------------------------------------------------------

inline OTTimeStamp OTTimeStampZero()
{
	OTTimeStamp zero = {0, 0};
	return zero;
}

//========================================================================================
// CRawIPEndpoint
//========================================================================================

//----------------------------------------------------------------------------------------
// Construction and Destruction
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CRawIPEndpoint::CRawIPEndpoint(CYielder_AC* yielder, MConnectionTrace* inProgress)
	:	CIPEndpoint(yielder, inProgress)
{
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

CRawIPEndpoint::CRawIPEndpoint(const CRawIPEndpoint& from)
	:	CIPEndpoint(from)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CRawIPEndpoint::~CRawIPEndpoint()
{
}

//----------------------------------------------------------------------------------------
// Datagrams
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Send
//----------------------------------------------------------------------------------------

void CRawIPEndpoint::Send(const TNetbuf& address, const TNetbuf& data)
{
	TUnitData udata;
	udata.addr = address;
	udata.opt = CNetbuf();
	udata.udata = data;
	ThrowIfOSStatus( fEndpoint->SndUData(&udata) );
}

//----------------------------------------------------------------------------------------
// Send
//----------------------------------------------------------------------------------------

void CRawIPEndpoint::Send(const InetAddress& address, const void* buffer, size_t length)
{
	CNetbuf addr(TemplateNetbuf(const_cast<InetAddress&>(address)));
	CNetbuf data(length, const_cast<void*>(buffer), length);
	Send(addr, data);
}

//----------------------------------------------------------------------------------------
// Send
//----------------------------------------------------------------------------------------

void CRawIPEndpoint::Send(const DNSAddress& address, const void* buffer, size_t length)
{
	CNetbuf addr(TemplateNetbuf(const_cast<DNSAddress&>(address)));
	CNetbuf data(length, const_cast<void*>(buffer), length);
	Send(addr, data);
}

//----------------------------------------------------------------------------------------
// GetSendError
//----------------------------------------------------------------------------------------

OSStatus CRawIPEndpoint::GetSendError()
{
	CNetbuf		tempNetBuf;
	return GetSendError(tempNetBuf);
}

//----------------------------------------------------------------------------------------
// GetSendError
//----------------------------------------------------------------------------------------

OSStatus CRawIPEndpoint::GetSendError(TNetbuf& address)
{
	TUDErr uderr;
	uderr.addr = address;
	uderr.opt = CNetbuf();
	ThrowIfOSStatus( fEndpoint->RcvUDErr(&uderr) );
	return uderr.error;
}

//----------------------------------------------------------------------------------------
// GetSendError
//----------------------------------------------------------------------------------------

OSStatus CRawIPEndpoint::GetSendError(InetAddress& address)
{
	CNetbuf addr(TemplateNetbuf(address));
	return GetSendError(addr);
}

//----------------------------------------------------------------------------------------
// GetSendError
//----------------------------------------------------------------------------------------

OSStatus CRawIPEndpoint::GetSendError(DNSAddress& address)
{
	CNetbuf addr(TemplateNetbuf(address));
	return GetSendError(addr);
}

//----------------------------------------------------------------------------------------
// Available
//----------------------------------------------------------------------------------------

long CRawIPEndpoint::Available()
{
	WarnIfMainThread();

	Assertion_AC(fEndpoint != kOTInvalidEndpointRef, NULL);

	unsigned long available = 0;
	OSStatus result = fEndpoint->CountDataBytes(&available);
	
	return available;
}


//----------------------------------------------------------------------------------------
// Receive
//----------------------------------------------------------------------------------------

CReceived CRawIPEndpoint::Receive(TNetbuf& address, TNetbuf& data, OTTimeout timeout)
{
	WarnIfMainThread();

	CReceived result;

	long available = Available();
	if (timeout && !available)
	{
		OTTimeStamp startTime;
		OTGetTimeStamp(&startTime);
		UInt32 elapsed = 0;
		do
		{
			Idle();
			available = Available();
			elapsed = OTElapsedMilliseconds(&startTime);
		}
		while ((elapsed < timeout) && !available);

		if (!available)
			result.Set(T_TIMEDOUT);
	}

	if (available <= 0)
	{
		result = available;
	}
	else
	{
		TUnitData udata;
		udata.addr = address;
		udata.opt = CNetbuf();
		udata.udata = data;
		if (udata.udata.maxlen > available)
			udata.udata.maxlen = available;

		OSStatus err = fEndpoint->RcvUData(&udata, &result.fFlags);
		if ((err != noErr) && (err != kOTNoDataErr))
			ThrowIfOSStatus(err);

		result = udata.udata.len;
	}

	return result;
}

//----------------------------------------------------------------------------------------
// Receive
//----------------------------------------------------------------------------------------

CReceived CRawIPEndpoint::Receive(TNetbuf& address, void* buffer, size_t maxlen, OTTimeout timeout)
{
	CNetbuf data(maxlen, buffer);
	return Receive(address, data, timeout);
}

//----------------------------------------------------------------------------------------
// Receive
//----------------------------------------------------------------------------------------

CReceived CRawIPEndpoint::Receive(InetAddress& address, void* buffer, size_t maxlen, OTTimeout timeout)
{
	CNetbuf addr(TemplateNetbuf(address));
	return Receive(addr, buffer, maxlen, timeout);
}

//----------------------------------------------------------------------------------------
// Receive
//----------------------------------------------------------------------------------------

CReceived CRawIPEndpoint::Receive(DNSAddress& address, void* buffer, size_t maxlen, OTTimeout timeout)
{
	CNetbuf addr(TemplateNetbuf(address));
	return Receive(addr, buffer, maxlen, timeout);
}


//----------------------------------------------------------------------------------------
// End of CRawIPEndpoint.cpp
