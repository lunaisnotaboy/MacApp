//----------------------------------------------------------------------------------------
// CIPEndpoint.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/24/00	Cosmetic. 
		05/20/00	Make CIPEndpoint as a common base class for CRawIPEndpoint and
							CTCPEndpoint. 
*/

#ifndef __CIPEndpoint__
#include "CIPEndpoint.h"
#endif

// Network

#ifndef __CCall__
#include "CCall.h"
#endif

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __COpenTransport__
#include "COpenTransport.h"
#endif

#ifndef __COption__
#include "COption.h"
#endif

#if qDebug && qMacApp
	#ifndef __ULogWindow__
	#include "ULogWindow.h"
	#endif
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CYielder_AC__
#include "CYielder_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

// Toolbox

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

// ANSI


//========================================================================================
// CIPEndpoint
//========================================================================================

bool CIPEndpoint::fgCancelAll;

//----------------------------------------------------------------------------------------
// Construction and Destruction
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CIPEndpoint::CIPEndpoint(CYielder_AC* yielder, MConnectionTrace* inProgress)
	:	fEndpoint(kOTInvalidEndpointRef),
		fInfo(),
		fYielder(yielder),
		fCancelError(kOTNoError),
#if qDebug && qMacApp
		fLog(this),
#endif
		fProgress(inProgress)
{
	if (fProgress)
		fProgress->SetParent(this);
}

//----------------------------------------------------------------------------------------
// copy constructor
//----------------------------------------------------------------------------------------

CIPEndpoint::CIPEndpoint(const CIPEndpoint& from)
	:	fEndpoint(kOTInvalidEndpointRef),
		fInfo(),
		fYielder(from.fYielder),
		fCancelError(kOTNoError),
#if qDebug && qMacApp
		fLog(this),
#endif
		fProgress(NULL)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CIPEndpoint::~CIPEndpoint()
{
	Close();
}

//----------------------------------------------------------------------------------------
// Open and Close
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Open
//----------------------------------------------------------------------------------------

void CIPEndpoint::Open(OTConfiguration* config, OTOpenFlags oflag)
{
	Assertion_AC(fEndpoint == kOTInvalidEndpointRef, NULL);
//	Assertion_AC(IsUninitialized(), NULL);

	OSStatus status = kOTNoError;
	fInfo.Clear();
#if qCarbon
	fEndpoint = OTOpenEndpointInContext(config, oflag, &fInfo, &status, GetClientContext());
#else
	fEndpoint = OTOpenEndpoint(config, oflag, &fInfo, &status);
#endif
	ThrowIfOSStatus(status);

	ThrowIfOSStatus( fEndpoint->SetBlocking() );
	ThrowIfOSStatus( fEndpoint->SetSynchronous() );
#if qCarbon
	static OTNotifyUPP notifyUPP = NULL;
	if (!notifyUPP)
		notifyUPP = NewOTNotifyUPP(NotifyProc);

	ThrowIfOSStatus( fEndpoint->InstallNotifier(notifyUPP, this) );
#else
	ThrowIfOSStatus( fEndpoint->InstallNotifier(NotifyProc, this) );
#endif
	ThrowIfOSStatus( fEndpoint->UseSyncIdleEvents() );
	ThrowIfOSStatus( fEndpoint->DontAckSends() );
}

//----------------------------------------------------------------------------------------
// Open
//----------------------------------------------------------------------------------------

void CIPEndpoint::Open(const char* path, OTOpenFlags oflag)
{
	Opening(path);

	// Assert before calling OTCreateConfiguration so we don't leak if it throws. 
	Assertion_AC(fEndpoint == kOTInvalidEndpointRef, NULL);

	Open(OTCreateConfiguration(path), oflag);
}

//----------------------------------------------------------------------------------------
// Bind
//----------------------------------------------------------------------------------------

void CIPEndpoint::Bind(InetHost host, InetPort port, TBind* retAddr)
{
	CInetAddress address(host, port);
	Bind(address, retAddr);
}

//----------------------------------------------------------------------------------------
// Bind
//----------------------------------------------------------------------------------------

void CIPEndpoint::Bind(InetAddress& address, TBind* retAddr)
{
	TBind reqAddr;
	reqAddr.addr.buf = (UInt8 *) &address;
	reqAddr.addr.len = sizeof(address);
	reqAddr.qlen = 1;
	Bind(&reqAddr, retAddr);
}

//----------------------------------------------------------------------------------------
// Bind
//----------------------------------------------------------------------------------------

void CIPEndpoint::Bind(TBind* reqAddr, TBind* retAddr)
{
//	Assertion_AC(IsOpen(), NULL);
	ThrowIfOSStatus( fEndpoint->Bind(reqAddr, retAddr) );
}

//----------------------------------------------------------------------------------------
// Unbind
//----------------------------------------------------------------------------------------

OSStatus CIPEndpoint::Unbind()
{
//	Assertion_AC(IsBound(), NULL);
	return fEndpoint->Unbind();
}

//----------------------------------------------------------------------------------------
// Close
//----------------------------------------------------------------------------------------

OSStatus CIPEndpoint::Close()
{
	WarnIfMainThread();

	OSStatus status = kOTNoError;

	if (fEndpoint)
	{
		// Remove any notifier first so OT doesn't try to call the smoking hole where
		// we used to be. 
		fEndpoint->RemoveNotifier();

		// Close the endpoint. 
		status = fEndpoint->Close();
	}

	// Clean up. 
	fEndpoint = kOTInvalidEndpointRef;
	fInfo.Clear();

	// Return the status if anyone cares. 
	return status;
}

//----------------------------------------------------------------------------------------
// Notifier Callbacks
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// HandleSyncIdleEvent
//----------------------------------------------------------------------------------------

void CIPEndpoint::HandleSyncIdleEvent()
{
	try
	{
		Idling();

		// If we've got a cancel error, use it to cancel any pending I/O. 
		if (fgCancelAll)
			fCancelError = userCanceledErr;

		if (fCancelError && (fEndpoint != kOTInvalidEndpointRef))
		{
			Canceling(fCancelError);

			OSStatus status = OTCancelSynchronousCalls(fEndpoint, fCancelError);
			Warning_AC(status == noErr, "HandleSyncIdleEvent failed to cancel");
			if (status == noErr)
				fCancelError = noErr;
		}
		else
		{
			// Give time to the rest of the system. 
			if (fYielder)
				fYielder->YieldIfTime();
		}
	}
	catch (CException_AC& fi)
	{
	}
	catch (...)
	{
	}
}

//----------------------------------------------------------------------------------------
// Idle
//----------------------------------------------------------------------------------------

void CIPEndpoint::Idle()
{
	// Give time to the rest of the system. 
	if (fYielder)
		fYielder->YieldIfTime();

	ThrowIfCanceled();
}

//----------------------------------------------------------------------------------------
// Cancel
//----------------------------------------------------------------------------------------

void CIPEndpoint::Cancel(OSStatus error)
{
	fCancelError = error;
}

//----------------------------------------------------------------------------------------
// ThrowIfCanceled
//----------------------------------------------------------------------------------------

void CIPEndpoint::ThrowIfCanceled()
{
	if (fgCancelAll)
		fCancelError = userCanceledErr;

	OSStatus error = fCancelError;
	if (error)
	{
		fCancelError = noErr;
		ThrowIfOSStatus(error);
	}
}

//----------------------------------------------------------------------------------------
// Endpoint Status
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// GetLocalAddress
//----------------------------------------------------------------------------------------

InetAddress CIPEndpoint::GetLocalAddress()
{
	InetInterfaceInfo info;
	ThrowIfOSStatus( OTInetGetInterfaceInfo(&info, 0) );
	return CInetAddress(info.fAddress);
}

//----------------------------------------------------------------------------------------
// GetEndpointState
//----------------------------------------------------------------------------------------

OTResult CIPEndpoint::GetEndpointState() const
{
	return fEndpoint->GetEndpointState();
}

//----------------------------------------------------------------------------------------
// IsUninitialized
//----------------------------------------------------------------------------------------

bool CIPEndpoint::IsUninitialized() const
{
	OTResult state = GetEndpointState();
	return state <= T_UNINIT;
}

//----------------------------------------------------------------------------------------
// IsOpen
//----------------------------------------------------------------------------------------

bool CIPEndpoint::IsOpen() const
{
	OTResult state = GetEndpointState();
	return state == T_UNBND;
}

//----------------------------------------------------------------------------------------
// IsBound
//----------------------------------------------------------------------------------------

bool CIPEndpoint::IsBound() const
{
	OTResult state = GetEndpointState();
	return state == T_IDLE;
}

//----------------------------------------------------------------------------------------
// IsConnecting
//----------------------------------------------------------------------------------------

bool CIPEndpoint::IsConnecting() const
{
	OTResult state = GetEndpointState();
	return (state == T_OUTCON) || (state == T_INCON);
}

//----------------------------------------------------------------------------------------
// IsConnected
//----------------------------------------------------------------------------------------

bool CIPEndpoint::IsConnected() const
{
	OTResult state = GetEndpointState();
	return state == T_DATAXFER;
}

//----------------------------------------------------------------------------------------
// IsDisconnecting
//----------------------------------------------------------------------------------------

bool CIPEndpoint::IsDisconnecting() const
{
	OTResult state = GetEndpointState();
	return (state == T_OUTREL) || (state == T_INREL);
}

//----------------------------------------------------------------------------------------
// MaySend
//----------------------------------------------------------------------------------------

bool CIPEndpoint::MaySend() const
{
	OTResult state = GetEndpointState();
	return (state == T_DATAXFER) || (state == T_INREL);
}

//----------------------------------------------------------------------------------------
// MayReceive
//----------------------------------------------------------------------------------------

bool CIPEndpoint::MayReceive() const
{
	OTResult state = GetEndpointState();
	return (state == T_DATAXFER) || (state == T_OUTREL);
}

//----------------------------------------------------------------------------------------
// Options
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// SetOption
//----------------------------------------------------------------------------------------

UInt32 CIPEndpoint::SetOption(OTXTIName inName, UInt32 inValue)
{
	return SetInternetOption(fEndpoint, inName, inValue);
}

//----------------------------------------------------------------------------------------
// GetOption
//----------------------------------------------------------------------------------------

UInt32 CIPEndpoint::GetOption(OTXTIName inName, UInt32& outValue)
{
	return GetInternetOption(fEndpoint, inName, outValue);
}

//----------------------------------------------------------------------------------------
// Progress
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// SetProgress
//----------------------------------------------------------------------------------------

void CIPEndpoint::SetProgress(MConnectionTrace* progress)
{
	if (fProgress != progress)
	{
		if (fProgress)
			Remove(*fProgress);

		fProgress = progress;

		if (fProgress)
			Add(*fProgress);
	}
}

#if qDebug
//----------------------------------------------------------------------------------------
// WarnIfMainThread
//----------------------------------------------------------------------------------------

void CIPEndpoint::WarnIfMainThread()
{
	ThreadID currentThread = kNoThreadID;
	ThrowIfOSErr_AC(MacGetCurrentThread(&currentThread));
	if (currentThread == kApplicationThreadID)
	{
		ProgramReport_AC("Warning: calling async network code from main thread\n");
	}
}

#endif // qDebug

//----------------------------------------------------------------------------------------
// End of CIPEndpoint.cpp
