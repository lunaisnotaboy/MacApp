//----------------------------------------------------------------------------------------
// CPingProtocol.cpp
// Copyright © 1996-2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		05/22/00	Use CReceived for TCP as well as RawIP. 
		02/23/00	Add time sent to ping packet. 
		02/07/00	Revised for new threads implementation. 
		01/12/00	Based on OTPingSample by Quinn "The Eskimo!"
*/

#ifndef __CPingProtocol__
#include "CPingProtocol.h"
#endif

// Network

#ifndef __CCall__
#include "CCall.h"
#endif

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __PrintSink__
#include "PrintSink.h"
#endif

// MacApp

// ACS

#ifndef __CCharOutputSink_AC__
#include "CCharOutputSink_AC.h"
#endif

#ifndef __CYielder_AC__
#include "CYielder_AC.h"
#endif

// Toolbox

#include <Events.h>
#include <OpenTransport.h>
#include <OpenTptInternet.h>

// ANSI

#include <stdio.h>
#include <string.h>

//========================================================================================
// CPingProtocol
//========================================================================================

//----------------------------------------------------------------------------------------
// Construction and Destruction
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// CPingProtocol constructor
//----------------------------------------------------------------------------------------

CPingProtocol::CPingProtocol(CYielder_AC* yielder, CCharOutputSink_AC& log,
							 MConnectionTrace* inProgress)
	:	fRawIPEndpoint(yielder, inProgress),
		fLog(log)
{
}

//----------------------------------------------------------------------------------------
// CPingProtocol copy constructor
//----------------------------------------------------------------------------------------

CPingProtocol::CPingProtocol(const CPingProtocol& from)
	:	fRawIPEndpoint(from.fRawIPEndpoint),
		fLog(from.fLog)
{
}

//----------------------------------------------------------------------------------------
// CPingProtocol destructor
//----------------------------------------------------------------------------------------

CPingProtocol::~CPingProtocol()
{
}

//----------------------------------------------------------------------------------------
// Ping
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// CPingProtocol::Close
//----------------------------------------------------------------------------------------

OSStatus CPingProtocol::Close()
{
	return fRawIPEndpoint.Close();
}

//----------------------------------------------------------------------------------------
// CPingProtocol::Cancel
//----------------------------------------------------------------------------------------

void CPingProtocol::Cancel(OSStatus error)
{
	fRawIPEndpoint.Cancel(error);
}

//----------------------------------------------------------------------------------------
// CPingProtocol::ChecksumBuffer
//----------------------------------------------------------------------------------------

UInt16 CPingProtocol::ChecksumBuffer(UInt16* buf, size_t len)
{
	UInt32 sum = 0;

	// This checksum implementation requires the buffer to be an even number of bytes long.
	long nwords = len >> 1;
	while (--nwords >= 0)
		sum += *buf++;

	sum = (sum >> 16 ) + (sum & 0xffff);
	sum += (sum >> 16);

	return ~sum;
}

//----------------------------------------------------------------------------------------
// CPingProtocol::CreateAndConfigICMP
//----------------------------------------------------------------------------------------

void CPingProtocol::CreateAndConfigICMP()
{
	fRawIPEndpoint.Open();
	
	fRawIPEndpoint.Bind();

	// no others options to negotiate at this stage
	
	// You might think we need to negotiate the XTI_GENERIC/XTI_PROTOTYPE
	// option to request ICMP packets (ie protocol 2).  This is not
	// necessary because rawip endpoints default to that protocol.
}

//----------------------------------------------------------------------------------------
// CPingProtocol::SendICMP
//----------------------------------------------------------------------------------------

void CPingProtocol::SendICMP(InetHost dest, UInt16 seq_number)
{
	CInetAddress dest_addr(dest);

	fLog << "Pinging " << dest_addr << '\n';

	PingPacket ping_data;
	ping_data.pType = 8;
	ping_data.pCode = 0;
	ping_data.pChecksum = 0;		// dummy checksum of 0 for purposes of checksum calculation
	ping_data.pID = 666;
	ping_data.pSeqNum = seq_number;
	ping_data.pMagic = kOurMagic;
	OTGetTimeStamp(&ping_data.pSent);

	ping_data.pChecksum = ChecksumBuffer((UInt16 *) &ping_data, sizeof(ping_data));

	fRawIPEndpoint.Sending((char*)&ping_data, sizeof(ping_data));
	fRawIPEndpoint.Send(dest_addr, &ping_data, sizeof(ping_data));
	fRawIPEndpoint.Sent((char*)&ping_data, sizeof(ping_data));
}

//----------------------------------------------------------------------------------------
// CPingProtocol::WaitAndPrintICMPs
//----------------------------------------------------------------------------------------

bool CPingProtocol::WaitAndPrintICMPs(UInt16 seq_number, OTTimeout timeout)
{
	bool got_response = false;

	// we use this buffer to hold incoming ICMP packets
	static UInt8 icmp_data[5000];

	// Wait for 5 seconds and print out any ICMP packets we get back.
	OTTimeStamp startTime;
	OTGetTimeStamp(&startTime);
	long timeLeft = timeout;
	do
	{
		// Look for a packet...
		InetAddress src_addr;
		BlockSet_AC(icmp_data, sizeof(icmp_data), 0);
		fRawIPEndpoint.Receiving(sizeof(icmp_data));
		CReceived received = fRawIPEndpoint.Receive(src_addr, icmp_data, sizeof(icmp_data), timeLeft);
		if (received > 0)
		{
			double_t tripMilliSeconds = 0;

			PingPacketPtr ping_data_ptr = (PingPacketPtr) &icmp_data[20];
			if (ping_data_ptr->pType == 0 &&
				ping_data_ptr->pID == 666 &&
				ping_data_ptr->pSeqNum == seq_number &&
				ping_data_ptr->pMagic == kOurMagic)
			{
				got_response = true;

				UInt64 tripTime = OTElapsedMicroseconds(&ping_data_ptr->pSent);
				tripMilliSeconds = ((double_t)tripTime) / 1000.;
			}

			fRawIPEndpoint.Received((const char*) icmp_data, received);
			
			// Print out salient information from the packet...
			print(fLog, "ICMP from = %d.%d.%d.%d", icmp_data[12], icmp_data[13], icmp_data[14], icmp_data[15]);
			print(fLog, ", type = %d", ping_data_ptr->pType);
			print(fLog, ", code = %d", ping_data_ptr->pCode);
			if (got_response)
				print(fLog, ", time = %f msec\n", tripMilliSeconds);
			else
				print(fLog, " but it's not ours!\n");

			fflush(stdout);
		}
		CYielder_AC* yielder = fRawIPEndpoint.GetYielder();
		if (yielder)
			yielder->YieldNow();

		timeLeft = timeout - OTElapsedMilliseconds(&startTime);
	}
	while (timeLeft > 0);

	return got_response;
}

//----------------------------------------------------------------------------------------
// CPingProtocol::DoPing
//----------------------------------------------------------------------------------------

void CPingProtocol::DoPing(InetHost dest)
{
	// Create the endpoint and negotiate the options...
	CreateAndConfigICMP();
	
	// Do the main ping loop...
	enum { timeout = 5000 };
	UInt16 seq_number = 0;
	UInt16 lost = 0;
	do
	{
		SendICMP(dest, seq_number);

		bool got_response = WaitAndPrintICMPs(seq_number, timeout);
		if (!got_response)
			++lost;
			
		fflush(stdout);
	}
	while (++seq_number < 2);

	print(fLog, "Ping complete.  %d packets sent.  %d packets lost.  %d%% packet loss.\n", seq_number, lost, lost * 100 / seq_number);
	fflush(stdout);

	// clean up
	fRawIPEndpoint.Close();
}

//----------------------------------------------------------------------------------------
// CPingProtocol::main
//----------------------------------------------------------------------------------------

void CPingProtocol::main()
{
	print(fLog, "Hello Cruel World!\n");
	
	try
	{
		char host_name[256];

		print(fLog, "Enter name of host to ping:\n");
		gets(host_name);
		
		CInetAddress dest(host_name);

		DoPing(dest.fHost);

		print(fLog, "Success!\n");
	}
	catch (CException_AC& fi)
	{
		OSStatus err = fi.GetError();
		print(fLog, "Failure!  Error = %d.\n", err);
	}
	catch (...)
	{
	}
}

//----------------------------------------------------------------------------------------
// End of CPingProtocol.cpp
