//----------------------------------------------------------------------------------------
// CIMAPParser.cpp
// Copyright © 1999-2000 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

// Parsing Rules for IMAP Interchanges

/*
	Change History
		10/13/00	CWP6 support: namespacing. 
		04/18/00	Fixed typo in CLogoutParse: MakeSubTerms was being declared
							rather than called. 
							Remove parse namespace. 
		04/17/00	Rename nodes to terms. Remove string versions of Parse. 
		12/02/99	Un-inline the destructors so it will be easier to debug them. 
		11/29/99	Dump tokens. 
		11/23/99	Correct parsing in CListParse::ParseListStream.
		11/18/99	Changed ID for bodyMultiPartTerm to eMultiPartTermID in 
							CFetchParse::ParseFetchStream. Also, when a body is a part
							of a multi-part it can match 1+ times so pass 1, 32767 where
							it is added as a subpart.
		11/15/99	Reworked CFetchParse::ParseFetchStream. Added CBodyFieldsTerm,
							CBodyFieldsTerm, CBodyDspLangExt and CBodyParameters.
		11/03/99	Fine tune CFetchBodyTextParse::ParseFetchStream to accept BODY[1].
							Fix minMatch error on second period in ParseFetchStream.
		11/01/99	Added missing implementation of CFetchBodyTextParse::ParseFetchStream.
		10/29/99	Forgot to parse mailbox name and a restOfLine in 
							ParseStatusStream.
		10/28/99	Added CStatusParse and CStatusResponseToken.
		10/27/99	Added CFetchBodyTextParse::ParseFetchStream and
							CFetchEnvelopeParse::ParseFetchStream. Moved in
							CollectNilString.
		10/26/99	HandleNo/OKMessage had a little problem getting the message
							text so had to rework the grammar created in MakeStandardStarTerms.
		10/25/99	Removed various qMacApp tests; no longer needed.
		10/22/99	Added CGenericResponseParse.
		10/21/99	Add methods for handling the unsolicited responses. 
							Get the protocol from the parse stream. 
							Comment out a debug output test. 
		10/21/99	Added CAddressTerm, CEnvelopeTerm and CSectMsgTextTerm.
		10/21/99	Fix off-by-one in CStringTerm::Parse by reworking text
							size calculation. sectMsgNot should be ‘.NOT’, not ‘NOT’.
							Top level fetch envelope needed keyword ENVELOPE.
		10/20/99	Changed all CParseTerm instantiations into CParseNubs.
		10/13/99	Add CTextPtr-style parsing.
		10/05/99	Added MakeStandardStarTerms and MakeTaggedResponseTerms
							convenience functions; use in CCapabilityParse. Start all
							enums with 'e' rather than 'sc'. Added CFetchParse.
		10/01/99	Added CSelectParse and CSelectResponseToken. Remove
							empty functions. Fixed up FLAGS terms in CAPABILITY
							and SELECT.
		09/30/99	Major modifications for new parsing strategy.
		09/22/99	Added CListParse.
		09/21/99	Fix up CLogoutParse.
		09/20/99	Implement Login and Logout parsing. A lot of
							debugging.
		09/09/99	Created.
*/

#ifndef __CIMAPParser__
#include "CIMAPParser.h"
#endif

// IMAP Suite

#ifndef __CIMAPProtocol__
//#include "CIMAPProtocol.h"
#endif

// ACS

#ifndef __ASCII__
#include "ASCII.h"
#endif

#ifndef __CStdReporter_AC__
#include "CStdReporter_AC.h"
#endif

// Standard Library

#include <locale>

using namespace std;

//========================================================================================
// CXKeywordTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CXKeywordTerm::dtor
//----------------------------------------------------------------------------------------

CXKeywordTerm::~CXKeywordTerm()
{
}

//----------------------------------------------------------------------------------------
// CXKeywordTerm::Parse
//----------------------------------------------------------------------------------------

bool CXKeywordTerm::Parse(	CTextPtr&	textPtr,
							CToken*		parentToken)
// Parse first tests a character to see if it's an 'X' and if so
// it calls the inherited Parse. (This function is modelled on CKeywordTerm's.)
//
// textPtr:		A pointer into a text buffer containing the material to parse.
// parentToken:	The token to which new tokens we create should be added.
{
	bool				success = false;

	if (!textPtr.AtEnd())		// Make sure there's something there.
	{
		CTextPtr	localTextPtr = textPtr;
		
		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
		
		if (toupper(*localTextPtr) == 'X')
		{
			localTextPtr++;		// Skip 'X'.
			CTextPtr	endOfToken = FindToken(localTextPtr, fDelimeters.c_str());
			if (endOfToken != localTextPtr)
			{
				// We found a token. Create a token object and then
				// then process any subterms, update the offset, and send
				// any notifications.
				
				CAutoPtr_AC<CXKeywordToken> aTokenAP(TH_new CXKeywordToken(parentToken,
															 this,
															 string(localTextPtr, endOfToken - localTextPtr)));
	
				if (CTerm::Parse(endOfToken, aTokenAP))
				{
					textPtr = endOfToken;
					success = true;
					if (!aTokenAP->ThrowAway())
						aTokenAP.release();
				}
			}
		}
	}

	return success;
}


//========================================================================================
// CXKeywordToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CXKeywordToken::dtor
//----------------------------------------------------------------------------------------

CXKeywordToken::~CXKeywordToken()
{
}

#if qDebug && qMacApp
//----------------------------------------------------------------------------------------
// CXKeywordToken::DumpContents
//----------------------------------------------------------------------------------------

void CXKeywordToken::DumpContents(CStream_AC& toStream, short level) const
{
#pragma unused (level)

	toStream << ", x-keyword: \"" << fXKeyword.c_str() << '\"';
}
#endif
		

//========================================================================================
// CStringTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CStringTerm::dtor
//----------------------------------------------------------------------------------------

CStringTerm::~CStringTerm()
{
}

//----------------------------------------------------------------------------------------
// CStringTerm::Parse
//----------------------------------------------------------------------------------------

bool CStringTerm::Parse(CTextPtr&	textPtr,
						CToken*		parentToken)
// Parse looks for a quoted or literal IMAP string.
//
// textPtr:		A pointer into a text buffer containing the material to parse.
// parentToken:	The token to which new tokens we create should be added.
{
	bool			success = false;

	if (!textPtr.AtEnd())		// Make sure there's something there.
	{
		string	foundString;
		CTextPtr	localTextPtr = textPtr;
		
		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
			
		// First, look for a quoted string, a string enclosed within
		// double-quotes, which may contain quoted double quotes ('\"')
		// and quoted quotes ('\\') which must be scanned properly. Yah.
		
		if (*localTextPtr == '"')
		{
			// Yep, potentially a quoted string. Scan to the next double-quote
			// if there's anything left in the string.
			localTextPtr++;
			CTextPtr	endOfQuotePtr = localTextPtr;
			CTextPtr	quotePos;
			bool		found = false;

			while (!found && !endOfQuotePtr.AtEnd())	// Be sure we can continue.
			{
				quotePos = FindToken(endOfQuotePtr, "\"");
				if (!quotePos.AtEnd() && *(quotePos-1) != '\\')	// We found a quote but was it quoted?
					found = true;
				else if (!quotePos.AtEnd())				// Quoted quote, bump and keep going.
					endOfQuotePtr = quotePos;
			}
			
			if (found)
			{
				foundString = string(localTextPtr, quotePos - localTextPtr);
				localTextPtr = quotePos + 1;	// Bump past the string and terminating quote.
				success = true;
			}
		}
		else if (*localTextPtr == '{')
		{
			// Not a quoted string but it looks like it might be a literal string
			// which is a string defined by a lengthctaking the following
			// form: "{" num "}" CRLF *CHAR8s.
			
			// Collect a number.
			UInt32		textSize = 0;					// The length of the text in the stream.
			CTextPtr	originalPtr = ++localTextPtr;
			while (!localTextPtr.AtEnd() && isdigit(*localTextPtr))
			{
				textSize = (textSize * 10) + (*localTextPtr - '0');
				localTextPtr++;
			}
			if (localTextPtr != originalPtr)
			{
				// We successfully got a number now see if we got a closing brace.
				if (*localTextPtr == '}')
				{
					localTextPtr++;		// Bump past brace.
					
					// Got a brace, how about the CRLF? Since we're dealing with <string>
					// we should be at the end of the string and ought to move to the next one.
					if (*localTextPtr == kCRChar && *(localTextPtr+1) == kLFChar)
					{
						localTextPtr += 2;	// Bump past CRLF.
						
						// Grab the input buffer for this text area.
						if (localTextPtr.AssureData(textSize))
						{
							success = true;
							foundString = string(localTextPtr, textSize);
							localTextPtr += textSize;	// Bump past the string.
						}
#if qDebug
						else
							ProgramBreak_AC("CStringTerm::Parse: Not enough characters in text buffer.");
#endif
					}
				}
			}			
		}
		
		if (success)
		{
			// We found a matching string. Create a token object and then
			// then process any subterms, update the offset, and send
			// any notifications.
			CAutoPtr_AC<CStringToken> aTokenAP(TH_new CStringToken(parentToken, this, foundString));

			if (CTerm::Parse(localTextPtr, aTokenAP))
			{
				textPtr = localTextPtr;
				success = true;
				if (!aTokenAP->ThrowAway())
					aTokenAP.release();
			}
		}
	}
	
	return success;
}


//========================================================================================
// CStringToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CStringToken::dtor
//----------------------------------------------------------------------------------------

CStringToken::~CStringToken()
{
}

#if qDebug && qMacApp
//----------------------------------------------------------------------------------------
// CStringToken::DumpContents
//----------------------------------------------------------------------------------------

void CStringToken::DumpContents(CStream_AC& toStream, short level) const
{
#pragma unused (level)

	toStream << ", string: \"" << fString.c_str() << '\"';
}
#endif
		

//========================================================================================
// CNilStringTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CNilStringTerm::dtor
//----------------------------------------------------------------------------------------

CNilStringTerm::~CNilStringTerm()
{
}

//----------------------------------------------------------------------------------------
// CNilStringTerm::Parse
//----------------------------------------------------------------------------------------

bool CNilStringTerm::Parse(	CTextPtr&	textPtr,
							CToken*		parentToken)
// Parse specializes on CStringTerm's Parse by also looking for a literal
// 'NIL'. Note that this will only create a CNilStringToken if indeed the
// string is 'NIL'.
//
// textPtr:		A pointer into a text buffer containing the material to parse.
// parentToken:	The token to which new tokens we create should be added.
{
	bool		success = false;

	if (!textPtr.AtEnd())		// Make sure there's something there.
	{
		CTextPtr	localTextPtr = textPtr;
		
		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
		
		// See if we got a 'NIL'.
		string	tempString(localTextPtr, 3);
		if (equal(tempString.begin(), tempString.end(), "NIL", InsensitiveCompare))
		{
			localTextPtr += 3;		// Skip the NIL.
			
			// Got a NIL so do the default copied from CStringTerm.
			// Create a token object and then then process any subterms,
			// update the offset, and send any notifications.
			CAutoPtr_AC<CNilStringToken> aTokenAP(TH_new CNilStringToken(parentToken, this));

			if (CTerm::Parse(localTextPtr, aTokenAP))
			{
				textPtr = localTextPtr;
				success = true;
				if (!aTokenAP->ThrowAway())
					aTokenAP.release();
			}
		}
		else
			success = CStringTerm::Parse(textPtr, parentToken);
	}
	
	return success;
}

//========================================================================================
// CNilStringToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CNilStringToken::dtor
//----------------------------------------------------------------------------------------

CNilStringToken::~CNilStringToken()
{
}

//========================================================================================
// CAtomStringTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CAtomStringTerm::dtor
//----------------------------------------------------------------------------------------

CAtomStringTerm::~CAtomStringTerm()
{
}

//----------------------------------------------------------------------------------------
// CAtomStringTerm::Parse
//----------------------------------------------------------------------------------------

bool CAtomStringTerm::Parse(CTextPtr&	textPtr,
							CToken*		parentToken)
// Parse specializes on CStringTerm's Parse by also looking for an
// 'atom' which is a keyword not enclosed in quote or which is a literal;
// instead it can contain any character except (, ), {, space, CTL, %, *, ",
// or \. So we first check to see if we get a match for CStringTerm and
// then we try to fetch a keyword without one of these special
// characters. Note that a CAtomStringToken will only be created if indeed
// it is an atom.
//
// textPtr:		A pointer into a text buffer containing the material to parse.
// parentToken:	The token to which new tokens we create should be added.
{

	bool		success = false;

	if (!textPtr.AtEnd())		// Make sure there's something there.
	{
		// The first thing we do is give CStringTerm a crack at it.
		if (CStringTerm::Parse(textPtr, parentToken))
			success = true;
		else
		{
			// Not a CStringTerm so try for an atom.
			CTextPtr	localTextPtr = textPtr;	
		
			if (fSkipWhiteSpace)
				SkipWhiteSpace(localTextPtr);
				
			CTextPtr	newTextPtr = FindToken(localTextPtr, sfDelimeters.c_str());
			if (newTextPtr != localTextPtr)
			{
				// We found a string which looks like an atom. Create a token object and then
				// then process any subterms, update the offset, and send
				// any notifications.
				CAutoPtr_AC<CAtomStringToken> aTokenAP(TH_new CAtomStringToken(parentToken,
															 this,
															 string(localTextPtr, newTextPtr - localTextPtr)));
				if (CTerm::Parse(newTextPtr, aTokenAP))
				{
					textPtr = newTextPtr;
					success = true;
					if (!aTokenAP->ThrowAway())
						aTokenAP.release();
				}
			}
		}
	}
	
	return success;
}


//========================================================================================
// CAtomStringToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CAtomStringToken::dtor
//----------------------------------------------------------------------------------------

CAtomStringToken::~CAtomStringToken()
{
}

//========================================================================================
// CContainerTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CContainerTerm::dtor
//----------------------------------------------------------------------------------------

CContainerTerm::~CContainerTerm()
{
}

//----------------------------------------------------------------------------------------
// CContainerTerm::Parse
//----------------------------------------------------------------------------------------

bool CContainerTerm::Parse(	CTextPtr&	textPtr,
							CToken*		parentToken)
// Parse checks to see if the next character, after skipping whitespace if
// required, is fStartChar, then it processes the subterms, and finally it
// looks for fEndChar.
//
// textPtr:		A pointer into a text buffer containing the material to parse.
// parentToken:	The token to which new tokens we create should be added.
{
	bool		success = false;

	if (!textPtr.AtEnd())		// Make sure there's something there.
	{
		CTextPtr	localTextPtr = textPtr;	
		
		if (fSkipWhiteSpace)
			SkipWhiteSpace(localTextPtr);
		
		// Is the next character fStartChar?
		if (!localTextPtr.AtEnd()
			&& *localTextPtr == fStartChar)
		{
			// We found fStartChar. Create a token object and then
			// then process any subterms.
			// Process the subterms.
			localTextPtr++;		// Bump past start character.
			
			CAutoPtr_AC<CContainerToken> aTokenAP(TH_new CContainerToken(parentToken, this));

			if (CTerm::Parse(localTextPtr, aTokenAP))
			{
				// If the next character is fEndChar update the offset, and send
				// any notifications.
				if (!localTextPtr.AtEnd()
					&& *localTextPtr == fEndChar)
				{
					textPtr = ++localTextPtr;		// Dont forget: bump past end character.
					success = true;
					if (!aTokenAP->ThrowAway())
						aTokenAP.release();
				}
			}
			
			
		}
			
	}
	
	return success;
}

//========================================================================================
// CContainerToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CContainerToken::dtor
//----------------------------------------------------------------------------------------

CContainerToken::~CContainerToken()
{
}

//========================================================================================
// CQuotedTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CQuotedTerm::dtor
//----------------------------------------------------------------------------------------

CQuotedTerm::~CQuotedTerm()
{
}

//========================================================================================
// CParenTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CParenTerm::dtor
//----------------------------------------------------------------------------------------

CParenTerm::~CParenTerm()
{
}

//========================================================================================
// CBracketTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CBracketTerm::dtor
//----------------------------------------------------------------------------------------

CBracketTerm::~CBracketTerm()
{
}

//========================================================================================
// CLtGtTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CLtGtTerm::dtor
//----------------------------------------------------------------------------------------

CLtGtTerm::~CLtGtTerm()
{
}

//========================================================================================
// CIMAPResponseParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CIMAPResponseParse::dtor
//----------------------------------------------------------------------------------------

CIMAPResponseParse::~CIMAPResponseParse()
{
}

//----------------------------------------------------------------------------------------
// CIMAPResponseParse::Reset
//----------------------------------------------------------------------------------------

void CIMAPResponseParse::Reset()
{
	CParseStream::Reset();
}

//----------------------------------------------------------------------------------------
// CIMAPResponseParse::MakeStandardStarTerms
//----------------------------------------------------------------------------------------

CTerm* CIMAPResponseParse::MakeStandardStarTerms() const
{
	CLiteralTerm* starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
		CParseNub* prseTerm = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 1);
			CIntegerTerm* intgTerm = TH_new CIntegerTerm(0, 1, eIntegerID, 1, 1);
				CLiteralTerm* exstTerm = TH_new CLiteralTerm("EXISTS", 0, 1, eExistsID, 0, 0, eUnsolicitedID);
				CLiteralTerm* rcntTerm = TH_new CLiteralTerm("RECENT", 0, 1, eRecentID, 0, 0, eUnsolicitedID);
				CLiteralTerm* expgTerm = TH_new CLiteralTerm("EXPUNGE", 0, 1, eExpungeID, 0, 0, eUnsolicitedID);
				CParseNub* plceTerm = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 1);
					CLiteralTerm* fetcTerm = TH_new CLiteralTerm("FETCH (FLAGS (", 0, 1, eFetchID, 1, 32767, eUnsolicitedID);
						CKeywordTerm* fflgTerm = TH_new CKeywordTerm(") \t\r", 0, 32767, eFetchFlagID);
					CLiteralTerm* fendTerm = TH_new CLiteralTerm("))", 1, 1);
			CLiteralTerm* okmgTerm = TH_new CLiteralTerm("OK", 1, 2, eOKMessageID, 0, 1, eOKMessageID, eOrdered);
				CLiteralTerm* alrtTerm = TH_new CLiteralTerm("[ALERT]", 0, 1, eOKAlertID);
				CRestOfLineTerm* rol1Term = TH_new CRestOfLineTerm(eMessageID);
			CLiteralTerm* nomgTerm = TH_new CLiteralTerm("NO", 0, 1, eNoMessageID, 1, 1, eNoMessageID);
				CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(eMessageID);
			CLiteralTerm* badmTerm = TH_new CLiteralTerm("BAD", 0, 1, eBadCommandID, 1, 1, eDoneID);
				CRestOfLineTerm* rol3Term = TH_new CRestOfLineTerm(eMessageID);

	starTerm->AddSubTerm(prseTerm);
		prseTerm->AddSubTerm(intgTerm);
			intgTerm->AddSubTerm(exstTerm);
			intgTerm->AddSubTerm(rcntTerm);
			intgTerm->AddSubTerm(expgTerm);
			intgTerm->AddSubTerm(plceTerm);
				plceTerm->AddSubTerm(fetcTerm);
					fetcTerm->AddSubTerm(fflgTerm);
				plceTerm->AddSubTerm(fendTerm);
		prseTerm->AddSubTerm(okmgTerm);
			okmgTerm->AddSubTerm(alrtTerm);
			okmgTerm->AddSubTerm(rol1Term);
		prseTerm->AddSubTerm(nomgTerm);
			nomgTerm->AddSubTerm(rol2Term);
		prseTerm->AddSubTerm(badmTerm);
			badmTerm->AddSubTerm(rol3Term);

	return starTerm;
}

//----------------------------------------------------------------------------------------
// CIMAPResponseParse::MakeTaggedResponseTerms
//----------------------------------------------------------------------------------------

CTerm* CIMAPResponseParse::MakeTaggedResponseTerms() const
{
	CLiteralTerm* cmdtTerm = TH_new CLiteralTerm(fCommandTag, 0, 1, eCommandTagID, 1, 2, eDoneID);
		CParseNub* plc3Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
			CLiteralTerm* oktgTerm = TH_new CLiteralTerm("OK", 0, 1, eTaggedOKID);
			CLiteralTerm* notgTerm = TH_new CLiteralTerm("NO", 0, 1, eTaggedNoID);
			CLiteralTerm* bdtgTerm = TH_new CLiteralTerm("BAD", 0, 1, eTaggedBadID);
		CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(eMessageID);
	
	cmdtTerm->AddSubTerm(plc3Term);
		plc3Term->AddSubTerm(oktgTerm);
		plc3Term->AddSubTerm(notgTerm);
		plc3Term->AddSubTerm(bdtgTerm);
	cmdtTerm->AddSubTerm(rol2Term);

	return cmdtTerm;
}

//========================================================================================
// CIMAPResponseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::dtor
//----------------------------------------------------------------------------------------

CIMAPResponseToken::~CIMAPResponseToken()
{
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleNotification
//----------------------------------------------------------------------------------------

void CIMAPResponseToken::HandleNotification(CToken* notifier)
// HandleNotification receives notices of special cases while parsing an
// IMAP response.
{
	switch (notifier->GetNotifyID())
	{
		case eDoneID:
			// We encountered a token which indicates that we are done parsing.
			HandleDone(notifier);
			break;
		case eUnsolicitedID:
			// We have received an unsolicited message.
			HandleUnsolicitedResponse(notifier);
			break;
		case eNoMessageID:
			// We have received an untagged 'NO' message from the server.
			HandleNoMessage(notifier);
			break;
		case eOKMessageID:
			// We have received an untagged 'OK' message from the server.
			HandleOKMessage(notifier);
			break;
	}
	
	CParseStreamToken::HandleNotification(notifier);
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleDone
//----------------------------------------------------------------------------------------

void CIMAPResponseToken::HandleDone(CToken* notifier)
// HandleDone responds to any condition which indicates that the parsing is
// complete. This may be because of a successful parse or an error condition.
{
	#pragma unused (notifier)
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleUnsolicitedResponse
//----------------------------------------------------------------------------------------

void CIMAPResponseToken::HandleUnsolicitedResponse(CToken* notifier)
// HandleUnsolicitedResponse deals with the four unsolicited responses which may
// come in at any time from the server: EXISTS, EXPUNGE, FETCH and RECENT.
{
	// Find the token containing the message number or message count.
	CIntegerToken*	numToken = dynamic_cast<CIntegerToken*>(notifier->FindSubToken(eIntegerID, false));
	UInt32			theNum = numToken->GetInteger();	
	
	// The token doing the reporting will have an ID indicating which of the
	// four types this message is.
	IDType		identifier = notifier->GetIdentifier();
	switch (identifier)
	{
		case eExistsID:
			HandleUnsolicitedExists(theNum);
			break;
		case eExpungeID:
			HandleUnsolicitedExpunge(theNum);
			break;
		case eFetchID:
			{
				IMAPFlagSet		aFlagSet;
				// Iterate over all of the subtokens of the fetch token looking for FLAG tokens.
				for(CTokenListIterator	flagToken = fTokens.begin();
					flagToken != fTokens.end();
					flagToken++)
				{
					CKeywordToken*	flagToken = dynamic_cast<CKeywordToken*>(flagToken);
					if (flagToken)
						aFlagSet.push_back(flagToken->GetKeyword());
				}
				HandleUnsolicitedFetch(theNum, aFlagSet);
			}
			break;
		case eRecentID:
			HandleUnsolicitedRecent(theNum);
			break;
#if qDebug
		default:
			string	tempString = "CIMAPResponseToken::HandleUnsolicitedResponse: Unknown response type: ‘";
			tempString += identifier + "’.";
			ProgramBreak_AC(tempString);
#endif
	}
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleNoMessage
//----------------------------------------------------------------------------------------

void CIMAPResponseToken::HandleNoMessage(CToken* notifier)
// HandleNoMessage takes care of an untagged NO message coming in from the
// server. This is usually an informational message of some server condition
// that prevents normal handling of requests.
{
	// We should have a sibling term which contains the message text.
	CRestOfLineToken*	msgToken = dynamic_cast<CRestOfLineToken*>(notifier->FindSubToken(eMessageID));
	if (msgToken)
	{
		string	tempString = "NO: " + msgToken->GetString();
		HandleAlert(tempString);
	}
#if qDebug
	else
		ProgramBreak_AC("CIMAPResponseToken::HandleNoMessage: No message token found.");
#endif
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleOKMessage
//----------------------------------------------------------------------------------------

void CIMAPResponseToken::HandleOKMessage(CToken* notifier)
// HandleOKMessage handles untagged OK messages received from the server such
// as when the server has resolved a situation previously reported in an
// untagged NO message. An OK message may also have been tagged with an
// [ALERT] that indicates a message that should be passed on to the user.
{
	// See if this is an ALERT.
	CLiteralTerm*	alertToken = dynamic_cast<CLiteralTerm*>(notifier->FindSubToken(eOKAlertID, false));

	// We should have a sibling term which contains the message text.
	CRestOfLineToken*	msgToken = dynamic_cast<CRestOfLineToken*>(notifier->FindSubToken(eMessageID));
	if (msgToken)
	{
		string	tempString = ((alertToken) ? "ALERT: " : "OK: ") + msgToken->GetString();
		HandleAlert(tempString);
	}
#if qDebug
	else
		ProgramBreak_AC("CIMAPResponseToken::HandleNoMessage: No message token found.");
#endif
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::GetProtocol
//----------------------------------------------------------------------------------------

CIMAPProtocol* CIMAPResponseToken::GetProtocol() const
{
	const CIMAPResponseParse* parseStream = dynamic_cast_AC(const CIMAPResponseParse*, GetParseStream());
	return parseStream ? parseStream->GetProtocol() : NULL;
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleUnsolicitedExists
//----------------------------------------------------------------------------------------

bool CIMAPResponseToken::HandleUnsolicitedExists(UInt32 messageCount)
{
//	CIMAPProtocol* protocol = GetProtocol();
//	return protocol && protocol->HandleUnsolicitedExists(messageCount);
#pragma unused (messageCount)
	return false;
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleUnsolicitedRecent
//----------------------------------------------------------------------------------------

bool CIMAPResponseToken::HandleUnsolicitedRecent(UInt32 messageCount)
{
//	CIMAPProtocol* protocol = GetProtocol();
//	return protocol && protocol->HandleUnsolicitedRecent(messageCount);
#pragma unused (messageCount)
	return false;
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleUnsolicitedExpunge
//----------------------------------------------------------------------------------------

bool CIMAPResponseToken::HandleUnsolicitedExpunge(UInt32 messageNum)
{
//	CIMAPProtocol* protocol = GetProtocol();
//	return protocol && protocol->HandleUnsolicitedExpunge(messageNum);
#pragma unused (messageNum)
	return false;
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleUnsolicitedFetch
//----------------------------------------------------------------------------------------

bool CIMAPResponseToken::HandleUnsolicitedFetch(UInt32				messageNum,
												const IMAPFlagSet&	aFlagSet)
{
//	CIMAPProtocol* protocol = GetProtocol();
//	return protocol && protocol->HandleUnsolicitedFetch(messageNum, aFlagSet);
#pragma unused (messageNum, aFlagSet)
	return false;
}

//----------------------------------------------------------------------------------------
// CIMAPResponseToken::HandleAlert
//----------------------------------------------------------------------------------------

bool CIMAPResponseToken::HandleAlert(string message)
{
//	CIMAPProtocol* protocol = GetProtocol();
//	return protocol && protocol->HandleAlert(message);
#pragma unused (message)
	return false;
}


//========================================================================================
// CCapabilityParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CCapabilityParse::dtor
//----------------------------------------------------------------------------------------

CCapabilityParse::~CCapabilityParse()
{
}

//----------------------------------------------------------------------------------------
// CCapabilityParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CCapabilityParse::MakeSubTerms()
// Set up our CAPABILITY parse tree.
{
	// It's not strictly necessary to create each parse term as a local but
	// I do it here for debugging purposes. The indentations shows the
	// relationships between the terms.
	CLiteralTerm* starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
		CLiteralTerm* capaTerm = TH_new CLiteralTerm("CAPABILITY", 1, 1, kNoIdentifier_AC, 1, 32767);
			CLiteralTerm* imapTerm = TH_new CLiteralTerm("IMAP4rev1", 1, 1, eIMAP4rev1ID);
			CLiteralTerm* aut1Term = TH_new CLiteralTerm("AUTH=", 0, 32767, kNoIdentifier_AC, 1, 1);
				CKeywordTerm* aut2Term = TH_new CKeywordTerm(" \t\r", 1, 1, eAuthenticationID);
			CXKeywordTerm* xkeyTerm = TH_new CXKeywordTerm(" \t\r", 0, 32767);
			CKeywordTerm* key1Term = TH_new CKeywordTerm(" \t\r", 0, 32767);
		CRestOfLineTerm* rol1Term = TH_new CRestOfLineTerm(eMessageID);
	CTerm* stdsTerm = MakeStandardStarTerms();
	CTerm* cmdtTerm = MakeTaggedResponseTerms();
	CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(0, 32767);
	
	// Now hook all the terms up together. ('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(capaTerm);
			capaTerm->AddSubTerm(imapTerm);
			capaTerm->AddSubTerm(aut1Term);
				aut1Term->AddSubTerm(aut2Term);
			capaTerm->AddSubTerm(xkeyTerm);
			capaTerm->AddSubTerm(key1Term);
		starTerm->AddSubTerm(rol1Term);
	this->AddSubTerm(stdsTerm);
	this->AddSubTerm(cmdtTerm);
	this->AddSubTerm(rol2Term);
}

//----------------------------------------------------------------------------------------
// CCapabilityParse::ParseCapabilityStream
//----------------------------------------------------------------------------------------

CCapabilityResponseToken* CCapabilityParse::ParseCapabilityStream()
// Set up and execute our CAPABILITY parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CCapabilityResponseToken> 	apParseToken(TH_new CCapabilityResponseToken(this));

	Reset();		// Reset ourselves.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CCapabilityResponseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CCapabilityResponseToken::dtor
//----------------------------------------------------------------------------------------

CCapabilityResponseToken::~CCapabilityResponseToken()
{
}

//========================================================================================
// CAddressTerm
//========================================================================================

//----------------------------------------------------------------------------------------
// CAddressesTerm::ctor
//----------------------------------------------------------------------------------------

CAddressesTerm::CAddressesTerm(	unsigned short	minimumMatch,
								unsigned short	maximumMatch,
								IDType			identifier,
								IDType			notifyID,
								ParseOrdering	ordered,
								WhiteSpace		skipWhiteSpace)
	:	CParseNub(minimumMatch, maximumMatch, identifier, 1, 1, notifyID, ordered, skipWhiteSpace)
{
	// address & addresses
	CParenTerm*		address = TH_new CParenTerm(1, 1, eAddressID, 4, 4, kNoIdentifier_AC, eOrdered);		// address
		CNilStringTerm*	addrName = TH_new CNilStringTerm(1, 1, eAddrNameID);			// addr-name
		CNilStringTerm*	addrAdl = TH_new CNilStringTerm(1, 1, eAddrAdlID);				// addr-adl
		CNilStringTerm*	addrMailbox = TH_new CNilStringTerm(1, 1, eAddrMailboxID);		// addr-mailbox
		CNilStringTerm*	addrHost = TH_new CNilStringTerm(1, 1, eAddrHostID);			// addr-host
		
		address->AddSubTerm(addrName);
		address->AddSubTerm(addrAdl);
		address->AddSubTerm(addrMailbox);
		address->AddSubTerm(addrHost);

	CLiteralTerm*	nilLit = TH_new CLiteralTerm("NIL", 0, 1, eNilID);
	CParenTerm*		anAddress = TH_new CParenTerm(0, 1, eAddressContainerID, 1, 32767);		// anAddress

	this->AddSubTerm(nilLit);
	this->AddSubTerm(anAddress);
		anAddress->AddSubTerm(address, 1, 32767);
	
}

//----------------------------------------------------------------------------------------
// CAddressesTerm::dtor
//----------------------------------------------------------------------------------------

CAddressesTerm::~CAddressesTerm()
{
}

//========================================================================================
// CSectMsgTextTerm - Supporting Class for CFetchParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CSectMsgTextTerm::ctor
//----------------------------------------------------------------------------------------

CSectMsgTextTerm::CSectMsgTextTerm()
	:	CParenTerm(0, 1, eSectMsgTextTermID, 1, 1)
{
	CLiteralTerm*	sectMsgHdrFlds = TH_new CLiteralTerm("HEADER.FIELDS", 0, 1, eSectMsgHdrFldsID, 1, 2, kNoIdentifier_AC, eOrdered);
		CLiteralTerm*	sectMsgNot = TH_new CLiteralTerm(".NOT", 0, 1, eSectMsgNotID);
		CParenTerm*		headerList = TH_new CParenTerm(1, 1, eHeaderListID, 1, 32767);
			CAtomStringTerm*	headerFldName = TH_new CAtomStringTerm(1, 32767, eHeaderFldNameID);
	CLiteralTerm*	sectMsgHeader = TH_new CLiteralTerm("HEADER", 0, 1, eSectMsgHeaderID);
	CLiteralTerm*	sectMsgText = TH_new CLiteralTerm("TEXT", 0, 1, eSectMsgTextID);

	AddSubTerm(sectMsgHdrFlds);
		sectMsgHdrFlds->AddSubTerm(sectMsgNot);
		sectMsgHdrFlds->AddSubTerm(headerList);
			headerList->AddSubTerm(headerFldName);
	AddSubTerm(sectMsgHeader);
	AddSubTerm(sectMsgText);
}

//----------------------------------------------------------------------------------------
// CSectMsgTextTerm::dtor
//----------------------------------------------------------------------------------------

CSectMsgTextTerm::~CSectMsgTextTerm()
{
}

//========================================================================================
// CEnvelopeTerm - Supporting Class for CFetchParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CEnvelopeTerm::ctor
//----------------------------------------------------------------------------------------

CEnvelopeTerm::CEnvelopeTerm()
	:	CParenTerm(1, 1, eEnvelopeID, 10, 10, kNoIdentifier_AC, eOrdered)
{
	// envelope
	AddSubTerm(TH_new CNilStringTerm(1, 1, eNilStringID));	// env-date
	AddSubTerm(TH_new CNilStringTerm(1, 1, eNilStringID));	// env-subject
	AddSubTerm(TH_new CAddressesTerm(1, 1, eAddressesID));	// env-from
	AddSubTerm(TH_new CAddressesTerm(1, 1, eAddressesID));	// env-sender
	AddSubTerm(TH_new CAddressesTerm(1, 1, eAddressesID));	// env-reply-to
	AddSubTerm(TH_new CAddressesTerm(1, 1, eAddressesID));	// env-to
	AddSubTerm(TH_new CAddressesTerm(1, 1, eAddressesID));	// env-cc
	AddSubTerm(TH_new CAddressesTerm(1, 1, eAddressesID));	// env-bcc
	AddSubTerm(TH_new CNilStringTerm(1, 1, eNilStringID));	// env-in-reply-to
	AddSubTerm(TH_new CNilStringTerm(1, 1, eNilStringID));	// env-message-id
}

//----------------------------------------------------------------------------------------
// CEnvelopeTerm::dtor
//----------------------------------------------------------------------------------------

CEnvelopeTerm::~CEnvelopeTerm()
{
}

//========================================================================================
// CBodyParameters - Supporting Class for CFetchParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CBodyParameters::ctor
//----------------------------------------------------------------------------------------

CBodyParameters::CBodyParameters()
	:	CParseNub(1, 1, eBodyFldParamID, 1, 1)
{
	// body-fld-param
	CParenTerm*		bodyFldParmTerm = TH_new CParenTerm(0, 1, kNoIdentifier_AC, 1, 32767);
		CParseNub*		bodyFldParms = TH_new CParseNub(1, 32767, eBodyFldParmsID, 2, 2);

	this->AddSubTerm(TH_new CLiteralTerm("NIL", 0, 1, eNilID));
	this->AddSubTerm(bodyFldParmTerm);
		bodyFldParmTerm->AddSubTerm(bodyFldParms);
			bodyFldParms->AddSubTerm(TH_new CStringTerm(2, 2, eBodyFldStringID));
}

//----------------------------------------------------------------------------------------
// CBodyParameters::dtor
//----------------------------------------------------------------------------------------

CBodyParameters::~CBodyParameters()
{
}

//========================================================================================
// CBodyFieldsTerm - Supporting Class for CFetchParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CBodyFieldsTerm::ctor
//----------------------------------------------------------------------------------------

CBodyFieldsTerm::CBodyFieldsTerm()
	:	CParseNub(0, 1, eBodyFieldsID, 5, 5, kNoIdentifier_AC, eOrdered)
{
	// body-fields
	CNilStringTerm*	bodyIdentifier = TH_new CNilStringTerm(1, 1, eBodyFldID);
	CNilStringTerm*	bodyDescription = TH_new CNilStringTerm(1, 1, eBodyFldDescID);
	CParseNub*		bodyEncoding = TH_new CParseNub(1, 1, eBodyFldEnc, 1, 1);
		CLiteralTerm*	body7Bit = TH_new CLiteralTerm("\"7BIT\"", 0, 1, e7BitID);
		CLiteralTerm*	body8Bit = TH_new CLiteralTerm("\"8BIT\"", 0, 1, e8BitID);
		CLiteralTerm*	bodyBinary = TH_new CLiteralTerm("\"BINARY\"", 0, 1, eBinaryID);
		CLiteralTerm*	bodyBase64 = TH_new CLiteralTerm("\"BASE64\"", 0, 1, eBase64ID);
		CLiteralTerm*	bodyQuotePrint = TH_new CLiteralTerm("\"QUOTED-PRINTABLE\"", 0, 1, eQuotePrintID);
	CIntegerTerm*	bodySizeOctets = TH_new CIntegerTerm(1, 1, eBodyFldOctetsID);

	this->AddSubTerm(TH_new CBodyParameters());
	this->AddSubTerm(bodyIdentifier);
	this->AddSubTerm(bodyDescription);
	this->AddSubTerm(bodyEncoding);
		bodyEncoding->AddSubTerm(body7Bit);
		bodyEncoding->AddSubTerm(body8Bit);
		bodyEncoding->AddSubTerm(bodyBinary);
		bodyEncoding->AddSubTerm(bodyBase64);
		bodyEncoding->AddSubTerm(bodyQuotePrint);
	this->AddSubTerm(bodySizeOctets);
}

//----------------------------------------------------------------------------------------
// CBodyFieldsTerm::dtor
//----------------------------------------------------------------------------------------

CBodyFieldsTerm::~CBodyFieldsTerm()
{
}

//========================================================================================
// CBodyDspLangExt - Supporting Class for CFetchParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CBodyDspLangExt::ctor
//----------------------------------------------------------------------------------------

CBodyDspLangExt::CBodyDspLangExt()
	:	CParseNub(0, 1, eDspLanExtID, 1, 2, kNoIdentifier_AC, eOrdered)
{
	// body-fld-dsp/lang/extension

	// body-fld-dsp - Body Disposition
	CParseNub*		bodyDisposition = TH_new CParseNub(1, 1, eBodyDispositionID, 1, 1);
		CParenTerm*		bodyDispositionTerm = TH_new CParenTerm(0, 1, kNoIdentifier_AC, 2, 2, kNoIdentifier_AC, eOrdered);

		bodyDisposition->AddSubTerm(TH_new CLiteralTerm("NIL", 0, 1, eNilID));
		bodyDisposition->AddSubTerm(bodyDispositionTerm);
			bodyDispositionTerm->AddSubTerm(TH_new CStringTerm(1, 1, eBodyFldDspStringID));		// Body disposition string.
			bodyDispositionTerm->AddSubTerm(TH_new CBodyParameters());

	// body-fld-lang - Body Language
	CParseNub*		bodyLanguage = TH_new CParseNub(1, 1, eBodyLanguageID, 1, 1);
		CParenTerm*		bodyLanguageTerm = TH_new CParenTerm(0, 1, kNoIdentifier_AC, 1, 32767);

		bodyLanguage->AddSubTerm(bodyLanguageTerm);
			bodyLanguageTerm->AddSubTerm(TH_new CStringTerm(1, 32767, eBodyLanguageStringID));	// Language string.
		bodyLanguage->AddSubTerm(TH_new CNilStringTerm(0, 1, eBodyLanguageNilStringID));		// NIL language specification.

	// body-extension
	CParseNub*		bodyExtension = TH_new CParseNub(0, 1, eBodyExtContainerID, 1, 1);
		CParenTerm*		bodyExtTerm = TH_new CParenTerm(0, 1, kNoIdentifier_AC, 1, 32767);
		
		bodyExtension->AddSubTerm(bodyExtTerm);
			bodyExtTerm->AddSubTerm(bodyExtension);		// ••• Recursion
		bodyExtension->AddSubTerm(TH_new CIntegerTerm(0, 1, eBodyExtIntID));
		bodyExtension->AddSubTerm(TH_new CNilStringTerm(0, 1, eBodyExtStringID));
	
	// Put it together now.
	CParseNub*		dspLangExt1 = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 2, kNoIdentifier_AC, eOrdered);

	this->AddSubTerm(bodyDisposition, 1, 1);
	this->AddSubTerm(dspLangExt1);
		dspLangExt1->AddSubTerm(bodyLanguage, 1, 1);
		dspLangExt1->AddSubTerm(bodyExtension);
}
	
//----------------------------------------------------------------------------------------
// CBodyDspLangExt::dtor
//----------------------------------------------------------------------------------------

CBodyDspLangExt::~CBodyDspLangExt()
{
}

//========================================================================================
// CFetchParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CFetchParse::dtor
//----------------------------------------------------------------------------------------

CFetchParse::~CFetchParse()
{
}

//----------------------------------------------------------------------------------------
// CFetchParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CFetchParse::MakeSubTerms()
// Set up our FETCH parse tree.
{
	// Make up some FETCH grammar tree components.
	CIntegerTerm*	integer = TH_new CIntegerTerm(1, 1, eIntegerID);
	CLiteralTerm*	dash = TH_new CLiteralTerm("-", 1, 1, kNoIdentifier_AC, 0, 0, kNoIdentifier_AC, eNotOrdered, eDontSkipWhiteSpace);
	CLiteralTerm*	colon = TH_new CLiteralTerm(":", 1, 1, kNoIdentifier_AC, 0, 0, kNoIdentifier_AC, eNotOrdered, eDontSkipWhiteSpace);
	
	// dateTime

	CQuotedTerm*	dateTime = TH_new CQuotedTerm(1, 1, eDateTimeID, 12, 12, kNoIdentifier_AC, eOrdered);		// date-time
		CKeywordTerm*	month = TH_new CKeywordTerm("-) \t\r", 1, 1, eMonthID, 0, 0, kNoIdentifier_AC, eNotOrdered, eDontSkipWhiteSpace);
		CParseNub*		plusMinusTerm = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
		CLiteralTerm*	plus = TH_new CLiteralTerm("+", 0, 1, ePlusID);
		CLiteralTerm*	minus = TH_new CLiteralTerm("-", 0, 1, eMinusID);
	
		dateTime->AddSubTerm(integer);			// date-day-fixed
		dateTime->AddSubTerm(dash);				// -
		dateTime->AddSubTerm(month);			// date-month
		dateTime->AddSubTerm(dash);				// -
		dateTime->AddSubTerm(integer);			// date-year
		dateTime->AddSubTerm(integer);			// date-hours
		dateTime->AddSubTerm(colon);			// :
		dateTime->AddSubTerm(integer);			// date-minutes
		dateTime->AddSubTerm(colon);			// :
		dateTime->AddSubTerm(integer);			// date-seconds
		dateTime->AddSubTerm(plusMinusTerm);	// +/-
			plusMinusTerm->AddSubTerm(plus);		// +
			plusMinusTerm->AddSubTerm(minus);		// -
		dateTime->AddSubTerm(integer);			// zone-offset
		
	// body - Each one of these encountered will cause a CMIMEObject to be created.
	CParenTerm*		body = TH_new CParenTerm(1, 1, eBodyID, 1, 1);
		CParseNub*		bodyLeafPart = TH_new CParseNub(0, 1, eLeafPartID, 1, 2, kNoIdentifier_AC, eOrdered);
			CParseNub*		leafPartTerm = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
				CParseNub*		bodyTypeMsg = TH_new CParseNub(0, 1, eBodyTypeMsgID, 6, 6, kNoIdentifier_AC, eOrdered);
					CParseNub*		bodyTypeMsgTerm = TH_new CParseNub(1, 1, eBodyTypeID, 1, 1);
				CParseNub*		bodyTypeText = TH_new CParseNub(0, 1, eBodyTypeTextID, 4, 4, kNoIdentifier_AC, eOrdered);
					CParseNub*		bodyTypeTextTerm = TH_new CParseNub(1, 1, eBodyTypeID, 1, 1);
						CLiteralTerm*	bodyTypeTextText = TH_new CLiteralTerm("\"TEXT\"", 0, 1, eBodyTextTypeID);
				CParseNub*		bodyTypeBasic = TH_new CParseNub(0, 1, eBodyTypeBasicID, 3, 3, kNoIdentifier_AC, eOrdered);
					CParseNub*		bodyTypeBasicTerm = TH_new CParseNub(1, 1, eBodyTypeID, 1, 1);
			CNilStringTerm*	bodyFldMd5 = TH_new CNilStringTerm(0, 1, eBodyFldMd5ID, 0, 1);	// body-ext-lpart
		CParseNub*		bodyMultiPart = TH_new CParseNub(0, 1, eMultiPartID, 2, 32767, kNoIdentifier_AC, eOrdered);
			CParseNub*		bodyMultiPartTerm = TH_new CParseNub(1, 1, eMultiPartTermID, 2, 3, kNoIdentifier_AC, eOrdered);
				CParseNub*		multiSubType = TH_new CParseNub(1, 1, eMultiSubTypeID, 0, 1);
		
		body->AddSubTerm(bodyLeafPart);
			bodyLeafPart->AddSubTerm(leafPartTerm);
				leafPartTerm->AddSubTerm(bodyTypeMsg);
					bodyTypeMsg->AddSubTerm(bodyTypeMsgTerm);
						bodyTypeMsgTerm->AddSubTerm(TH_new CLiteralTerm("\"MESSAGE\"", 1, 1, eMessageTypeID));
					bodyTypeMsg->AddSubTerm(TH_new CLiteralTerm("\"RFC822\"", 0, 1, eBodySubTypeID));
					bodyTypeMsg->AddSubTerm(TH_new CBodyFieldsTerm());
					bodyTypeMsg->AddSubTerm(TH_new CEnvelopeTerm());
					bodyTypeMsg->AddSubTerm(body);					// ••• Recursion
					bodyTypeMsg->AddSubTerm(TH_new CIntegerTerm(1, 1, eBodyFldLinesID));
				leafPartTerm->AddSubTerm(bodyTypeText);
					bodyTypeText->AddSubTerm(bodyTypeTextTerm);
						bodyTypeTextTerm->AddSubTerm(bodyTypeTextText);
					bodyTypeText->AddSubTerm(TH_new CStringTerm(1, 1, eBodySubTypeID));
					bodyTypeText->AddSubTerm(TH_new CBodyFieldsTerm());
					bodyTypeText->AddSubTerm(TH_new CIntegerTerm(1, 1, eBodyFldLinesID));
				leafPartTerm->AddSubTerm(bodyTypeBasic);
					bodyTypeBasic->AddSubTerm(bodyTypeBasicTerm);
						bodyTypeBasicTerm->AddSubTerm(TH_new CLiteralTerm("\"APPLICATION\"", 0, 1, eApplicationID));
						bodyTypeBasicTerm->AddSubTerm(TH_new CLiteralTerm("\"AUDIO\"", 0, 1, eAudioID));
						bodyTypeBasicTerm->AddSubTerm(TH_new CLiteralTerm("\"IMAGE\"", 0, 1, eImageID));
						bodyTypeBasicTerm->AddSubTerm(TH_new CLiteralTerm("\"MESSAGE\"", 0, 1, eMessageID));
						bodyTypeBasicTerm->AddSubTerm(TH_new CLiteralTerm("\"VIDEO\"", 0, 1, eVideoID));
						bodyTypeBasicTerm->AddSubTerm(TH_new CStringTerm(0, 1, eBodyTypeOtherID));
					bodyTypeBasic->AddSubTerm(TH_new CStringTerm(1, 1, eBodySubTypeID));
					bodyTypeBasic->AddSubTerm(TH_new CBodyFieldsTerm());
			bodyLeafPart->AddSubTerm(bodyFldMd5);
				bodyFldMd5->AddSubTerm(TH_new CBodyDspLangExt());
		body->AddSubTerm(bodyMultiPart);
			bodyMultiPart->AddSubTerm(body, 1, 32767);						// ••• Recursion
			bodyMultiPart->AddSubTerm(bodyMultiPartTerm);
				bodyMultiPartTerm->AddSubTerm(multiSubType);
					multiSubType->AddSubTerm(TH_new CLiteralTerm("\"MIXED\"", 0, 1, eMultiMixedTypeID));
					multiSubType->AddSubTerm(TH_new CLiteralTerm("\"DIGEST\"", 0, 1, eMultiDigestTypeID));
					multiSubType->AddSubTerm(TH_new CLiteralTerm("\"PARALLEL\"", 0, 1, eMultiParallelTypeID));
					multiSubType->AddSubTerm(TH_new CLiteralTerm("\"ALTERNATIVE\"", 0, 1, eMultiAltTypeID));
					multiSubType->AddSubTerm(TH_new CStringTerm(0, 1, eMultiOtherTypeID));
				bodyMultiPartTerm->AddSubTerm(TH_new CBodyParameters());
				bodyMultiPartTerm->AddSubTerm(TH_new CBodyDspLangExt());

	// Build the main grammar tree.
	CLiteralTerm*	starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
		CIntegerTerm*	msgNum = TH_new CIntegerTerm(1, 1, eMessageNumID, 2, 2, kNoIdentifier_AC, eOrdered);		// msg-data
			CLiteralTerm*	fetch = TH_new CLiteralTerm("FETCH");
			CParenTerm*		paren = TH_new CParenTerm(1, 1, eFetchMessageID, 1, 32767);		// msg-att
				CLiteralTerm*	flags = TH_new CLiteralTerm("FLAGS", 0, 32767, eFlagsTagID, 1, 1);		// msg-att-dynamic
					CParenTerm*		parenFlag = TH_new CParenTerm(1, 1, kNoIdentifier_AC, 1, 32767);
						CKeywordTerm*	flag = TH_new CKeywordTerm(") \t\r", 1, 32767, eFlagID);		// flag
				CLiteralTerm*	envKeywordTerm = TH_new CLiteralTerm("ENVELOPE", 0, 32767, eEnvelopeTermID, 1, 1);		// msg-att-dynamic
					// envelope
				CLiteralTerm*	internalDate = TH_new CLiteralTerm("INTERNALDATE", 0, 32767, eInternalDateID, 1, 1);
					// date-time
				CLiteralTerm*	r822Term = TH_new CLiteralTerm("RFC822", 0, 32767, eRFC822ID, 1, 1);
					CParseNub*		plc1Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 2, kNoIdentifier_AC, eOrdered);
						CParseNub*		plc2Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 1);
							CLiteralTerm*	dotHeader = TH_new CLiteralTerm(".HEADER", 0, 1, eDotHeaderID);
							CLiteralTerm*	dotText = TH_new CLiteralTerm(".TEXT", 0, 1, eDotTextID);
						CNilStringTerm*	dotTextString = TH_new CNilStringTerm(1, 1, eDotTextStringID);
					CLiteralTerm*	dotSize = TH_new CLiteralTerm(".SIZE", 0, 1, kNoIdentifier_AC, 1, 1);
						CIntegerTerm* rfcSize = TH_new CIntegerTerm(1, 1, eRFC822SizeID);
				CLiteralTerm*	bodyTerm = TH_new CLiteralTerm("BODY", 0, 32767, eBodyPartID, 1, 1);
					CParseNub*		plc3Term = TH_new CParseNub(0, 1, eBodyMainID, 1, 2, kNoIdentifier_AC, eOrdered, eDontSkipWhiteSpace);		// body
						CLiteralTerm*	bodyStructure = TH_new CLiteralTerm("STRUCTURE", 0, 1, eStructureID, 0, 32767, kNoIdentifier_AC, eNotOrdered, eDontSkipWhiteSpace);
						// body
					CParseNub*		bodySectTerm = TH_new CParseNub(0, 1, eBodySectionID, 2, 2, kNoIdentifier_AC, eOrdered);		// section
						CBracketTerm*	bodyBrktTerm = TH_new CBracketTerm(1, 1, eBodyBracketID, 1, 1);		// sect-spec
							// sect-msgtext
							CParseNub*		plc5Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 2, kNoIdentifier_AC, eOrdered);		// sect-part
								CParseNub*		plc6Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 32767);
									CIntegerTerm* integer1 = TH_new CIntegerTerm(1, 1, eInteger1ID);
									CParseNub*		plc7Term = TH_new CParseNub(0, 32767, kNoIdentifier_AC, 2, 2, kNoIdentifier_AC, eOrdered);
										CLiteralTerm*	period1 = TH_new CLiteralTerm(".", 1, 1, eDotID);
										CIntegerTerm* integer2 = TH_new CIntegerTerm(1, 1, eInteger2ID);
								CLiteralTerm*	period2 = TH_new CLiteralTerm(".", 0, 1, eDotID);
									// sect-msgtext
									CLiteralTerm*	mime = TH_new CLiteralTerm("MIME", 0, 1, eMIMEID);
						CParseNub*		plc8Term = TH_new CParseNub(1, 1, eBodyStringID, 1, 2, kNoIdentifier_AC, eOrdered);
							CLtGtTerm*	ltgtTerm = TH_new CLtGtTerm(0, 1, kNoIdentifier_AC, 1, 1);
								CIntegerTerm* integer3 = TH_new CIntegerTerm(1, 1, eInteger3ID);
							CNilStringTerm*	sectionString = TH_new CNilStringTerm(1, 1, eSectionStringID);
				CLiteralTerm*	msgUIDTerm = TH_new CLiteralTerm("UID", 0, 32767, eMsgUIDID, 1, 1);
					CIntegerTerm* uidID = TH_new CIntegerTerm(1, 1, eUIDID);
		CRestOfLineTerm* rol1Term = TH_new CRestOfLineTerm(eMessageID);
	CTerm* stdsTerm = MakeStandardStarTerms();
	CTerm* cmdtTerm = MakeTaggedResponseTerms();
	CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(0, 32767);
	
	// Now hook all the terms up together. ('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(msgNum);			// msg-data
			msgNum->AddSubTerm(fetch);
			msgNum->AddSubTerm(paren);				// msg-att
				paren->AddSubTerm(flags);				// msg-att-dynamic
					flags->AddSubTerm(parenFlag);
						parenFlag->AddSubTerm(flag);				// flag
				paren->AddSubTerm(envKeywordTerm);
					envKeywordTerm->AddSubTerm(TH_new CEnvelopeTerm());
				paren->AddSubTerm(internalDate);
					internalDate->AddSubTerm(dateTime);
				paren->AddSubTerm(r822Term);
					r822Term->AddSubTerm(plc1Term);
						plc1Term->AddSubTerm(plc2Term);
							plc2Term->AddSubTerm(dotHeader);
							plc2Term->AddSubTerm(dotText);
						plc1Term->AddSubTerm(dotTextString);
					r822Term->AddSubTerm(dotSize);
						dotSize->AddSubTerm(rfcSize);
				paren->AddSubTerm(bodyTerm);
					bodyTerm->AddSubTerm(plc3Term);			// body
						plc3Term->AddSubTerm(bodyStructure);
						plc3Term->AddSubTerm(body);
					bodyTerm->AddSubTerm(bodySectTerm);			// section
						bodySectTerm->AddSubTerm(bodyBrktTerm);		// sect-spec
							bodyBrktTerm->AddSubTerm(TH_new CSectMsgTextTerm());	// sect-msgtext
							bodyBrktTerm->AddSubTerm(plc5Term);		// sect-part
								plc5Term->AddSubTerm(plc6Term);
									plc6Term->AddSubTerm(integer1);
									plc6Term->AddSubTerm(plc7Term);
										plc7Term->AddSubTerm(period1);
										plc7Term->AddSubTerm(integer2);
								plc5Term->AddSubTerm(period2);			// sect-text
									period2->AddSubTerm(TH_new CSectMsgTextTerm());		// sect-msg-text
									period2->AddSubTerm(mime);
						bodySectTerm->AddSubTerm(plc8Term);
							plc8Term->AddSubTerm(ltgtTerm);
								ltgtTerm->AddSubTerm(integer3);
							plc8Term->AddSubTerm(sectionString);
				paren->AddSubTerm(msgUIDTerm);
					msgUIDTerm->AddSubTerm(uidID);
		starTerm->AddSubTerm(rol1Term);
	this->AddSubTerm(stdsTerm);
	this->AddSubTerm(cmdtTerm);
	this->AddSubTerm(rol2Term);
}

//----------------------------------------------------------------------------------------
// CFetchParse::ParseFetchStream
//----------------------------------------------------------------------------------------

CFetchResponseToken* CFetchParse::ParseFetchStream()
// Set up and execute our FETCH parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CFetchResponseToken> 	apParseToken(TH_new CFetchResponseToken(this));

	Reset();		// Reset ourselves.
	MakeSubTerms();
	
	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CFetchResponseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CFetchResponseToken::dtor
//----------------------------------------------------------------------------------------

CFetchResponseToken::~CFetchResponseToken()
{
}

//========================================================================================
// CFetchBodyTextParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CFetchBodyTextParse::dtor
//----------------------------------------------------------------------------------------

CFetchBodyTextParse::~CFetchBodyTextParse()
{
}

//----------------------------------------------------------------------------------------
// CFetchBodyTextParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CFetchBodyTextParse::MakeSubTerms()
// Set up our FETCH (BODY[TEXT]) parse tree.
{
	// Build the main grammar tree.
	CLiteralTerm*	starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
		CIntegerTerm*	msgNum = TH_new CIntegerTerm(1, 1, eMessageNumID, 2, 2, kNoIdentifier_AC, eOrdered);		// msg-data
			CLiteralTerm*	fetch = TH_new CLiteralTerm("FETCH");
			CParenTerm*		paren = TH_new CParenTerm(1, 1, eFetchMessageID, 1, 32767);		// msg-att
				CLiteralTerm*	bodyTerm = TH_new CLiteralTerm("BODY", 1, 1, eBodyPartID, 1, 1);
					CParseNub*		bodySectTerm = TH_new CParseNub(1, 1, eBodySectionID, 2, 2, kNoIdentifier_AC, eOrdered);		// section
						CBracketTerm*	bodyBrktTerm = TH_new CBracketTerm(1, 1, eBodyBracketID, 1, 1);		// sect-spec
							CParseNub*		bodySection = TH_new CParseNub(0, 1, eSectMsgTextTermID, 1, 1);
								CLiteralTerm*	sectMsgText1 = TH_new CLiteralTerm("TEXT", 1, 1, eSectMsgTextID);
							CParseNub*		plc5Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 2, kNoIdentifier_AC, eOrdered);		// sect-part
								CParseNub*		plc6Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 32767);
									CIntegerTerm* integer1 = TH_new CIntegerTerm(1, 1, eInteger1ID);
									CParseNub*		plc7Term = TH_new CParseNub(0, 32767, kNoIdentifier_AC, 2, 2, kNoIdentifier_AC, eOrdered);
										CLiteralTerm*	period1 = TH_new CLiteralTerm(".", 1, 1, eDotID);
										CIntegerTerm*	integer2 = TH_new CIntegerTerm(1, 1, eInteger2ID);
								CLiteralTerm*	period2 = TH_new CLiteralTerm(".TEXT", 0, 1, eDotID);
						CParseNub*		plc8Term = TH_new CParseNub(1, 1, eBodyStringID, 1, 2, kNoIdentifier_AC, eOrdered);
							CNilStringTerm*	sectionString = TH_new CNilStringTerm(1, 1, eSectionStringID);
				CLiteralTerm*	msgUIDTerm = TH_new CLiteralTerm("UID", 0, 32767, eMsgUIDID, 1, 1);
					CIntegerTerm* uidID = TH_new CIntegerTerm(1, 1, eUIDID);
		CRestOfLineTerm* rol1Term = TH_new CRestOfLineTerm(eMessageID);
	CTerm* stdsTerm = MakeStandardStarTerms();
	CTerm* cmdtTerm = MakeTaggedResponseTerms();
	CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(0, 32767);
	
	// Now hook all the terms up together. ('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(msgNum);			// msg-data
			msgNum->AddSubTerm(fetch);
			msgNum->AddSubTerm(paren);				// msg-att
				paren->AddSubTerm(bodyTerm);
					bodyTerm->AddSubTerm(bodySectTerm);			// section
						bodySectTerm->AddSubTerm(bodyBrktTerm);		// sect-spec
							bodyBrktTerm->AddSubTerm(bodySection);	// sect-msgtext
								bodySection->AddSubTerm(sectMsgText1);
							bodyBrktTerm->AddSubTerm(plc5Term);		// sect-part
								plc5Term->AddSubTerm(plc6Term);
									plc6Term->AddSubTerm(integer1);
									plc6Term->AddSubTerm(plc7Term);
										plc7Term->AddSubTerm(period1);
										plc7Term->AddSubTerm(integer2);
								plc5Term->AddSubTerm(period2);			// sect-text
						bodySectTerm->AddSubTerm(plc8Term);
							plc8Term->AddSubTerm(sectionString);
				paren->AddSubTerm(msgUIDTerm);
					msgUIDTerm->AddSubTerm(uidID);
		starTerm->AddSubTerm(rol1Term);
	this->AddSubTerm(stdsTerm);
	this->AddSubTerm(cmdtTerm);
	this->AddSubTerm(rol2Term);
}

//----------------------------------------------------------------------------------------
// CFetchBodyTextParse::ParseFetchStream
//----------------------------------------------------------------------------------------

CFetchResponseToken* CFetchBodyTextParse::ParseFetchStream()
// Set up and execute our FETCH (BODY[TEXT]) parse tree.
{
	// •••  This command should not receive a response consisting
	// of "FETCH (BODY[1])" but it does from an AppleShare IP server.
	// Create our master token.
	CAutoPtr_AC<CFetchResponseToken> 	apParseToken(TH_new CFetchResponseToken(this));

	Reset();		// Reset ourselves.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CFetchEnvelopeParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CFetchEnvelopeParse::dtor
//----------------------------------------------------------------------------------------

CFetchEnvelopeParse::~CFetchEnvelopeParse()
{
}

//----------------------------------------------------------------------------------------
// CFetchEnvelopeParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CFetchEnvelopeParse::MakeSubTerms()
// Set up our FETCH (ENVELOPE UID) parse tree.
{
	// Build the main grammar tree.
	CLiteralTerm*	starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
		CIntegerTerm*	msgNum = TH_new CIntegerTerm(1, 1, eMessageNumID, 2, 2, kNoIdentifier_AC, eOrdered);		// msg-data
			CLiteralTerm*	fetch = TH_new CLiteralTerm("FETCH");
			CParenTerm*		paren = TH_new CParenTerm(1, 1, eFetchMessageID, 1, 32767);		// msg-att
				CLiteralTerm*	envKeywordTerm = TH_new CLiteralTerm("ENVELOPE", 0, 32767, eEnvelopeTermID, 1, 1);		// msg-att-dynamic
					// envelope
				CLiteralTerm*	msgUIDTerm = TH_new CLiteralTerm("UID", 0, 32767, eMsgUIDID, 1, 1);
					CIntegerTerm* uidID = TH_new CIntegerTerm(1, 1, eUIDID);
		CRestOfLineTerm* rol1Term = TH_new CRestOfLineTerm(eMessageID);
	CTerm* stdsTerm = MakeStandardStarTerms();
	CTerm* cmdtTerm = MakeTaggedResponseTerms();
	CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(0, 32767);
	
	// Now hook all the terms up together. ('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(msgNum);			// msg-data
			msgNum->AddSubTerm(fetch);
			msgNum->AddSubTerm(paren);				// msg-att
				paren->AddSubTerm(envKeywordTerm);
					envKeywordTerm->AddSubTerm(TH_new CEnvelopeTerm());
				paren->AddSubTerm(msgUIDTerm);
					msgUIDTerm->AddSubTerm(uidID);
		starTerm->AddSubTerm(rol1Term);
	this->AddSubTerm(stdsTerm);
	this->AddSubTerm(cmdtTerm);
	this->AddSubTerm(rol2Term);
}

//----------------------------------------------------------------------------------------
// CFetchEnvelopeParse::ParseFetchStream
//----------------------------------------------------------------------------------------

CFetchResponseToken* CFetchEnvelopeParse::ParseFetchStream()
// Set up and execute our FETCH (ENVELOPE UID) parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CFetchResponseToken> 	apParseToken(TH_new CFetchResponseToken(this));

	Reset();		// Reset ourselves.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CFetchStructureParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CFetchStructureParse::dtor
//----------------------------------------------------------------------------------------

CFetchStructureParse::~CFetchStructureParse()
{
}

//----------------------------------------------------------------------------------------
// CFetchStructureParse::ParseFetchStream
//----------------------------------------------------------------------------------------

CFetchResponseToken* CFetchStructureParse::ParseFetchStream()
// Set up and execute our FETCH (BODYSTRUCTURE) parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CFetchResponseToken> 	apParseToken(TH_new CFetchResponseToken(this));

	Reset();		// Reset ourselves.
	
	ProgramBreak_AC("CFetchStructureParse::ParseFetchStream: NOT IMPLEMENTED.");
	
	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CGenericResponseParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CGenericResponseParse::dtor
//----------------------------------------------------------------------------------------

CGenericResponseParse::~CGenericResponseParse()
{
}

//----------------------------------------------------------------------------------------
// CGenericResponseParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CGenericResponseParse::MakeSubTerms()
// Set up our LOGIN parse tree.
{
	// Build the grammar tree.
	CTerm* stdsTerm = MakeStandardStarTerms();
	CTerm* cmdtTerm = MakeTaggedResponseTerms();
	CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(0, 32767);
	
	// Now hook all the terms up together. ('this->' shown for clarification.)
	this->AddSubTerm(stdsTerm);
	this->AddSubTerm(cmdtTerm);
	this->AddSubTerm(rol2Term);
}

//----------------------------------------------------------------------------------------
// CGenericResponseParse::ParseResponseStream
//----------------------------------------------------------------------------------------

CIMAPResponseToken* CGenericResponseParse::ParseResponseStream()
// Set up and execute our LOGIN parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CIMAPResponseToken> 	apParseToken(TH_new CIMAPResponseToken(this));

	Reset();		// Reset ourselves.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CListParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CListParse::dtor
//----------------------------------------------------------------------------------------

CListParse::~CListParse()
{
}

//----------------------------------------------------------------------------------------
// CListParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CListParse::MakeSubTerms()
// Set up our LOGIN parse tree.
{
	// Build the grammar tree.
	CLiteralTerm* starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
		CLiteralTerm* listTerm = TH_new CLiteralTerm("LIST", 1, 1, eMailboxItem, 3, 3, eOrdered);
			CParenTerm* oprnTerm = TH_new CParenTerm(1, 1, kNoIdentifier_AC, 0, 32767);
				CKeywordTerm* mboxFlagTerm = TH_new CKeywordTerm(") \t\r", 0, 32767, eMboxAttributeID);
			CNilStringTerm* pathDelimeterTerm = TH_new CNilStringTerm(1, 1, eMboxDelimeterID);
			CAtomStringTerm* mboxNameTerm = TH_new CAtomStringTerm(1, 1, eMboxNameID);
		CRestOfLineTerm* rol1Term = TH_new CRestOfLineTerm(eMessageID);
	CTerm* stdsTerm = MakeStandardStarTerms();
	CTerm* cmdtTerm = MakeTaggedResponseTerms();
	CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(0, 32767);
	
	// Now hook all the terms up together. ('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(listTerm);
			listTerm->AddSubTerm(oprnTerm);
				oprnTerm->AddSubTerm(mboxFlagTerm);
			listTerm->AddSubTerm(pathDelimeterTerm);
			listTerm->AddSubTerm(mboxNameTerm);
		starTerm->AddSubTerm(rol1Term);
	this->AddSubTerm(stdsTerm);
	this->AddSubTerm(cmdtTerm);
	this->AddSubTerm(rol2Term);
}

//----------------------------------------------------------------------------------------
// CListParse::ParseListStream
//----------------------------------------------------------------------------------------

CListResponseToken* CListParse::ParseListStream()
// Set up and execute our LOGIN parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CListResponseToken> 	apParseToken(TH_new CListResponseToken(this));

	Reset();		// Reset ourselves.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CListResponseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CListResponseToken::dtor
//----------------------------------------------------------------------------------------

CListResponseToken::~CListResponseToken()
{
}

//========================================================================================
// CLoginParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CLoginParse::dtor
//----------------------------------------------------------------------------------------

CLoginParse::~CLoginParse()
{
}

//----------------------------------------------------------------------------------------
// CLoginParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CLoginParse::MakeSubTerms()
// Set up our LOGIN parse tree.
{
	// Create the parsing terms individually.
	CLiteralTerm* starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
	CParseNub* plc1Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
			CLiteralTerm* okmgTerm = TH_new CLiteralTerm("OK", 0, 1, eOKMessageID, 0, 1, eOKMessageID);
				CLiteralTerm* alrtTerm = TH_new CLiteralTerm("[ALERT]", 0, 1, eOKAlertID);
			CLiteralTerm* nomgTerm = TH_new CLiteralTerm("NO", 0, 1, eNoMessageID, 1, 1, eNoMessageID);
			CLiteralTerm* badmTerm = TH_new CLiteralTerm("BAD", 0, 1, eBadCommandID, 1, 1, eDoneID);
		CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(eMessageID);
	CLiteralTerm* cmdtTerm = TH_new CLiteralTerm(fCommandTag, 0, 1, eCommandTagID, 1, 2, eDoneID);
		CParseNub* plc2Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
			CLiteralTerm* oktgTerm = TH_new CLiteralTerm("OK", 0, 1, eTaggedOKID);
			CLiteralTerm* notgTerm = TH_new CLiteralTerm("NO", 0, 1, eTaggedNoID);
			CLiteralTerm* bdtgTerm = TH_new CLiteralTerm("BAD", 0, 1, eTaggedBadID);
		CRestOfLineTerm* rol3Term = TH_new CRestOfLineTerm();
	CRestOfLineTerm* rol4Term = TH_new CRestOfLineTerm();
	
	// Now hook all the terms up together.	('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(plc1Term);
			plc1Term->AddSubTerm(okmgTerm);
				okmgTerm->AddSubTerm(alrtTerm);
			plc1Term->AddSubTerm(nomgTerm);
			plc1Term->AddSubTerm(badmTerm);
		starTerm->AddSubTerm(rol2Term);
	this->AddSubTerm(cmdtTerm);
		cmdtTerm->AddSubTerm(plc2Term);
			plc2Term->AddSubTerm(oktgTerm);
			plc2Term->AddSubTerm(notgTerm);
			plc2Term->AddSubTerm(bdtgTerm);
		cmdtTerm->AddSubTerm(rol3Term);
	this->AddSubTerm(rol4Term, 0, 32767);
}

//----------------------------------------------------------------------------------------
// CLoginParse::ParseLoginStream
//----------------------------------------------------------------------------------------

CLoginResponseToken* CLoginParse::ParseLoginStream()
// Set up and execute our LOGIN parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CLoginResponseToken> 	apParseToken(TH_new CLoginResponseToken(this));

	Reset();		// Reset ourselves.
	
	// Create the parsing terms individually.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CLoginResponseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CLoginResponseToken::dtor
//----------------------------------------------------------------------------------------

CLoginResponseToken::~CLoginResponseToken()
{
}

//========================================================================================
// CLogoutParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CLogoutParse::dtor
//----------------------------------------------------------------------------------------

CLogoutParse::~CLogoutParse()
{
}

//----------------------------------------------------------------------------------------
// CLogoutParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CLogoutParse::MakeSubTerms()
// Set up our LOGOUT parse tree.
{
	// Create the parsing terms individually.
	CLiteralTerm* starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
	CParseNub* plc1Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
			CLiteralTerm* byeTerm = TH_new CLiteralTerm("BYE", 0, 1, eByeMessageID, 1, 1, eByeMessageID);
			CLiteralTerm* okmgTerm = TH_new CLiteralTerm("OK", 0, 1, eOKMessageID, 0, 1, eOKMessageID);
				CLiteralTerm* alrtTerm = TH_new CLiteralTerm("[ALERT]", 0, 1, eOKAlertID);
			CLiteralTerm* nomgTerm = TH_new CLiteralTerm("NO", 0, 1, eNoMessageID, 1, 1, eNoMessageID);
			CLiteralTerm* badmTerm = TH_new CLiteralTerm("BAD", 0, 1, eBadCommandID, 1, 1, eDoneID);
		CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(eMessageID);
	CLiteralTerm* cmdtTerm = TH_new CLiteralTerm(fCommandTag, 0, 1, eCommandTagID, 1, 2, eDoneID);
		CParseNub* plc2Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
			CLiteralTerm* oktgTerm = TH_new CLiteralTerm("OK", 0, 1, eTaggedOKID);
			CLiteralTerm* notgTerm = TH_new CLiteralTerm("NO", 0, 1, eTaggedNoID);
			CLiteralTerm* bdtgTerm = TH_new CLiteralTerm("BAD", 0, 1, eTaggedBadID);
		CRestOfLineTerm* rol3Term = TH_new CRestOfLineTerm(eMessageID);
	CRestOfLineTerm* rol4Term = TH_new CRestOfLineTerm(eMessageID);
	
	// Now hook all the terms up together.	('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(plc1Term);
			plc1Term->AddSubTerm(byeTerm);
			plc1Term->AddSubTerm(okmgTerm);
				okmgTerm->AddSubTerm(alrtTerm);
			plc1Term->AddSubTerm(nomgTerm);
			plc1Term->AddSubTerm(badmTerm);
		starTerm->AddSubTerm(rol2Term);
	this->AddSubTerm(cmdtTerm);
		cmdtTerm->AddSubTerm(plc2Term);
			plc2Term->AddSubTerm(oktgTerm);
			plc2Term->AddSubTerm(notgTerm);
			plc2Term->AddSubTerm(bdtgTerm);
		cmdtTerm->AddSubTerm(rol3Term);
	this->AddSubTerm(rol4Term, 0, 32767);
}

//----------------------------------------------------------------------------------------
// CLogoutParse::ParseLogoutStream
//----------------------------------------------------------------------------------------

CLogoutResponseToken* CLogoutParse::ParseLogoutStream()
// Set up and execute our LOGOUT parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CLogoutResponseToken> 	apParseToken(TH_new CLogoutResponseToken(this));

	Reset();		// Reset ourselves.
	
	// Create the parsing terms individually.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CLogoutResponseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CLogoutResponseToken::dtor
//----------------------------------------------------------------------------------------

CLogoutResponseToken::~CLogoutResponseToken()
{
}

//========================================================================================
// CSelectParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CSelectParse::dtor
//----------------------------------------------------------------------------------------

CSelectParse::~CSelectParse()
{
}

//----------------------------------------------------------------------------------------
// CSelectParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CSelectParse::MakeSubTerms()
// Set up our SELECT parse tree.
{
	// It's not strictly necessary to create each parse term as a local but
	// I do it here for debugging purposes. The indentations shows the
	// relationships between the terms.
	CLiteralTerm* starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 1, 2);
		CParseNub* plc1Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
			CParseNub* plc2Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 1);
				CIntegerTerm* int1Term = TH_new CIntegerTerm(1, 1, eIntegerID, 1, 1);
					CLiteralTerm* exstTerm = TH_new CLiteralTerm("EXISTS", 0, 1, eExistsID);
					CLiteralTerm* rcntTerm = TH_new CLiteralTerm("RECENT", 0, 1, eRecentID);
					CLiteralTerm* expgTerm = TH_new CLiteralTerm("EXPUNGE", 0, 1, eExpungeID, 0, 0, eUnsolicitedID);
					CParseNub* plc3Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 1, 1);
						CLiteralTerm* fetcTerm = TH_new CLiteralTerm("FETCH (FLAGS (", 0, 1, eFetchID, 1, 32767, eUnsolicitedID);
							CKeywordTerm* fflgTerm = TH_new CKeywordTerm(") \t\r", 0, 32767, eFetchFlagID);
						CLiteralTerm* fendTerm = TH_new CLiteralTerm("))", 1, 1);
			CLiteralTerm* okmgTerm = TH_new CLiteralTerm("OK", 0, 1, eOKMessageID, 0, 1);
				CParseNub* plc4Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 3, 3);
					CParseNub* plc5Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
						CLiteralTerm* unsnTerm = TH_new CLiteralTerm("[UNSEEN", 0, 1, eUnseenID);
						CLiteralTerm* uidvTerm = TH_new CLiteralTerm("[UIDVALIDITY", 0, 1, eUIDValidityID);
						CLiteralTerm* uidnTerm = TH_new CLiteralTerm("[UIDNEXT", 0, 1, eUIDNextID);
					CIntegerTerm* int2Term = TH_new CIntegerTerm(1, 1, eIntegerID, 1, 1);
					CLiteralTerm* ebktTerm = TH_new CLiteralTerm("]", 0, 1);
				CParseNub* plc6Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 2, 2);
					CLiteralTerm* permTerm = TH_new CLiteralTerm("[PERMANENTFLAGS (", 1, 1, ePermFlagTagID, 0, 32767);
						CKeywordTerm* pflgTerm = TH_new CKeywordTerm(") \t\r", 0, 32767, eFlagID);
					CLiteralTerm* pendTerm = TH_new CLiteralTerm(")]", 1, 1);
				CLiteralTerm* alrtTerm = TH_new CLiteralTerm("[ALERT]", 0, 1, eOKAlertID, 0, 0, eOKMessageID);
			CParseNub* plc7Term = TH_new CParseNub(0, 1, kNoIdentifier_AC, 2, 2);
				CLiteralTerm* flagTerm = TH_new CLiteralTerm("FLAGS (", 1, 1, eFlagsTagID, 0, 32767);
					CKeywordTerm* flgsTerm = TH_new CKeywordTerm(") \t\r", 0, 32767, eFlagID);
				CLiteralTerm* fen1Term = TH_new CLiteralTerm(")", 1, 1);
			CLiteralTerm* nomgTerm = TH_new CLiteralTerm("NO", 0, 1, eNoMessageID, 1, 1, eNoMessageID);
			CLiteralTerm* badmTerm = TH_new CLiteralTerm("BAD", 0, 1, eBadCommandID, 1, 1, eDoneID);
		CRestOfLineTerm* rol1Term = TH_new CRestOfLineTerm(eMessageID);
	CLiteralTerm* cmdtTerm = TH_new CLiteralTerm(fCommandTag, 0, 1, eCommandTagID, 1, 2, eDoneID);
		CParseNub* plc8Term = TH_new CParseNub(1, 1, kNoIdentifier_AC, 1, 1);
			CLiteralTerm* oktgTerm = TH_new CLiteralTerm("OK", 0, 1, eTaggedOKID, 0, 1);
				CLiteralTerm* rdwrTerm = TH_new CLiteralTerm("[READ-WRITE]", 0, 1, eReadWriteID);
				CLiteralTerm* readTerm = TH_new CLiteralTerm("[READ-ONLY]", 0, 1, eReadOnlyID);
			CLiteralTerm* notgTerm = TH_new CLiteralTerm("NO", 0, 1, eTaggedNoID);
			CLiteralTerm* bdtgTerm = TH_new CLiteralTerm("BAD", 0, 1, eTaggedBadID);
		CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(eMessageID);
	CRestOfLineTerm* rol3Term = TH_new CRestOfLineTerm();

	// Now hook all the terms up together. ('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(plc1Term);
			plc1Term->AddSubTerm(plc2Term);
				plc2Term->AddSubTerm(int1Term);
					int1Term->AddSubTerm(exstTerm);
					int1Term->AddSubTerm(rcntTerm);
					int1Term->AddSubTerm(expgTerm);
					int1Term->AddSubTerm(plc3Term);
						plc3Term->AddSubTerm(fetcTerm);
							fetcTerm->AddSubTerm(fflgTerm);
						plc3Term->AddSubTerm(fendTerm);
			plc1Term->AddSubTerm(okmgTerm);
				okmgTerm->AddSubTerm(plc4Term);
					plc4Term->AddSubTerm(plc5Term);
						plc5Term->AddSubTerm(unsnTerm);
						plc5Term->AddSubTerm(uidvTerm);
						plc5Term->AddSubTerm(uidnTerm);
					plc4Term->AddSubTerm(int2Term);
					plc4Term->AddSubTerm(ebktTerm);
				okmgTerm->AddSubTerm(plc6Term);
					plc6Term->AddSubTerm(permTerm);
						permTerm->AddSubTerm(pflgTerm);
					plc6Term->AddSubTerm(pendTerm);
				okmgTerm->AddSubTerm(alrtTerm);
			plc1Term->AddSubTerm(nomgTerm);
			plc1Term->AddSubTerm(badmTerm);
			plc1Term->AddSubTerm(plc7Term);
				plc7Term->AddSubTerm(flagTerm);
					flagTerm->AddSubTerm(flgsTerm);
				plc7Term->AddSubTerm(fen1Term);
		starTerm->AddSubTerm(rol1Term);
	this->AddSubTerm(cmdtTerm);
		cmdtTerm->AddSubTerm(plc8Term);
			plc8Term->AddSubTerm(oktgTerm);
				oktgTerm->AddSubTerm(rdwrTerm);
				oktgTerm->AddSubTerm(readTerm);
			plc8Term->AddSubTerm(notgTerm);
			plc8Term->AddSubTerm(bdtgTerm);
		cmdtTerm->AddSubTerm(rol2Term);
	this->AddSubTerm(rol3Term, 0, 32767);
}

//----------------------------------------------------------------------------------------
// CSelectParse::ParseSelectStream
//----------------------------------------------------------------------------------------

CSelectResponseToken* CSelectParse::ParseSelectStream()
// Set up and execute our SELECT parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CSelectResponseToken> 	apParseToken(TH_new CSelectResponseToken(this));

	Reset();		// Reset ourselves.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CSelectResponseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CSelectResponseToken::dtor
//----------------------------------------------------------------------------------------

CSelectResponseToken::~CSelectResponseToken()
{
}

//========================================================================================
// CStatusParse
//========================================================================================

//----------------------------------------------------------------------------------------
// CStatusParse::dtor
//----------------------------------------------------------------------------------------

CStatusParse::~CStatusParse()
{
}

//----------------------------------------------------------------------------------------
// CStatusParse::MakeSubTerms
//----------------------------------------------------------------------------------------

void CStatusParse::MakeSubTerms()
// Set up our STATUS parse tree.
{
	CLiteralTerm*	starTerm = TH_new CLiteralTerm("*", 0, 32767, eStarID, 3, 4, eOrdered);
		CLiteralTerm*	statusTerm = TH_new CLiteralTerm("STATUS", 1, 1, eStatusID, 1, 32767);
		CAtomStringTerm*	mboxNameTerm = TH_new CAtomStringTerm(1, 1, eMboxNameID);
		CParenTerm*			paren = TH_new CParenTerm(1, 1, eStatusAttID, 1, 32767);	// status-att
			CLiteralTerm*		messagesTerm = TH_new CLiteralTerm("MESSAGES");
				CIntegerTerm*		messagesIntTerm = TH_new CIntegerTerm(1, 1, eMessageCountID);
			CLiteralTerm*		recentTerm = TH_new CLiteralTerm("RECENT");
				CIntegerTerm*		recentIntTerm = TH_new CIntegerTerm(1, 1, eRecentCountID);
			CLiteralTerm*		uidNextTerm = TH_new CLiteralTerm("UIDNEXT");
				CIntegerTerm*		uidNextIntTerm = TH_new CIntegerTerm(1, 1, eUIDNextID);
			CLiteralTerm*		uidValidityTerm = TH_new CLiteralTerm("UIDVALIDITY");
				CIntegerTerm*		uidValidityIntTerm = TH_new CIntegerTerm(1, 1, eUIDValidityID);
			CLiteralTerm*		unseenTerm = TH_new CLiteralTerm("UNSEEN");
				CIntegerTerm*		unseenIntTerm = TH_new CIntegerTerm(1, 1, eUnseenID);
		CRestOfLineTerm*	rol1Term = TH_new CRestOfLineTerm(eMessageID);
	CTerm*		stdsTerm = MakeStandardStarTerms();
	CTerm*		cmdtTerm = MakeTaggedResponseTerms();
	CRestOfLineTerm* rol2Term = TH_new CRestOfLineTerm(0, 32767);
	
	// Now hook all the terms up together. ('this->' shown for clarification.)
	this->AddSubTerm(starTerm);
		starTerm->AddSubTerm(statusTerm);
		starTerm->AddSubTerm(mboxNameTerm);
		starTerm->AddSubTerm(paren);
			paren->AddSubTerm(messagesTerm);
				messagesTerm->AddSubTerm(messagesIntTerm);
			paren->AddSubTerm(recentTerm);
				recentTerm->AddSubTerm(recentIntTerm);
			paren->AddSubTerm(uidNextTerm);
				uidNextTerm->AddSubTerm(uidNextIntTerm);
			paren->AddSubTerm(uidValidityTerm);
				uidValidityTerm->AddSubTerm(uidValidityIntTerm);
			paren->AddSubTerm(unseenTerm);
				unseenTerm->AddSubTerm(unseenIntTerm);
		starTerm->AddSubTerm(rol1Term);
	this->AddSubTerm(stdsTerm);
	this->AddSubTerm(cmdtTerm);
	this->AddSubTerm(rol2Term);
}

//----------------------------------------------------------------------------------------
// CStatusParse::ParseStatusStream
//----------------------------------------------------------------------------------------

CStatusResponseToken* CStatusParse::ParseStatusStream()
// Set up and execute our STATUS parse tree.
{
	// Create our master token.
	CAutoPtr_AC<CStatusResponseToken> 	apParseToken(TH_new CStatusResponseToken(this));

	Reset();		// Reset ourselves.
	MakeSubTerms();

	// Parse the response.
	bool success = ParseStream(apParseToken);

	return apParseToken.release();
}

//========================================================================================
// CStatusResponseToken
//========================================================================================

//----------------------------------------------------------------------------------------
// CStatusResponseToken::dtor
//----------------------------------------------------------------------------------------

CStatusResponseToken::~CStatusResponseToken()
{
}

//========================================================================================
// Global Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// CollectNilString
//----------------------------------------------------------------------------------------

string CollectNilString(CToken* nilStringToken)
// Collect a string, which may also be a NIL.
{
	CNilStringToken* aNilStringToken = dynamic_cast<CNilStringToken*>(nilStringToken);
	if (aNilStringToken)
		return "";
	else
	{
		CStringToken* aStringToken = dynamic_cast_or_throw_AC(CStringToken*, nilStringToken);
		return aStringToken->GetString();
	}
}

//========================================================================================
// Static initialization
//========================================================================================

const string CAtomStringTerm::sfDelimeters = "\1\2\3\4\5\6\7\10\11\12\13\14\15\16\17\20\21\22\23\24\25\26\27\30\31\32\33\34\35\36\37\177 (){%*\"\\";


//----------------------------------------------------------------------------------------
// End of CIMAPParser.cpp