//----------------------------------------------------------------------------------------
// SimpleHTTPDownload.cpp
// Copyright © 1997-2001 by Apple Computer, Inc., All Rights Reserved.
//----------------------------------------------------------------------------------------

/*
	Contains:	Implementation of the simple HTTP download sample.

	You may incorporate this Apple sample source code into your program(s) without
	restriction. This Apple sample source code has been provided "AS IS" and the
	responsibility for its operation is yours. You are not permitted to redistribute
	this Apple sample source code as "Apple sample source code" after having made
	changes. If you're going to re-distribute the source, we require that you make
	it clear in the source that the code was descended from Apple sample source
	code, but that you've made changes.

	Written by: Quinn "The Eskimo!"	
*/

/*
	Change History:
		03/28/01	Don't use OTAssert or OTDebugStr at all. 
		10/02/00	Cannot resolve OTDebugStr for CWP6.
		05/24/00	Finish separating char I/O from endpoints. 
							Isolate clients from look errors. 
		03/31/00	Use ACS. 
		07/23/99	Updated for Metrowerks Codewarror Pro 2.1
*/

// SimpleHTTPDownload

#ifndef __SimpleHTTPDownload__
#include "SimpleHTTPDownload.h"
#endif

// Network

#ifndef __CTextBuffer__
#include "CTextBuffer.h"
#endif

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __CTCPEndpoint__
#include "CTCPEndpoint.h"
#endif

#ifndef __Transport__
#include "Transport.h"
#endif

// ACS

#ifndef __CThreadYielder_AC__
#include "CThreadYielder_AC.h"
#endif

// Toolbox

#ifndef __FILES__
#include <Files.h>
#endif

#ifndef __OPENTRANSPORT__
#include <OpenTransport.h>
#endif

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

#ifndef __TEXTUTILS__
#include <TextUtils.h>
#endif

// ANSI

//========================================================================================
// Constants
//========================================================================================

enum
{
	kTransferBufferSize = 4096
};

//========================================================================================
// Global Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// SimpleHTTPDownload
//----------------------------------------------------------------------------------------

OSStatus SimpleHTTPDownload(const char *hostName,
							const char *httpCommand,
							const short destFileRefNum)
	// Download a URL from the a web server.  hostName is a pointer
	// to a string that contains the DNS address of the web server.
	// The DNS address must be suffixed by ":<port>", where <port>
	// is the port number the web server is operating on.
	// httpCommand contains the HTTP command to send.  Typically this
	// is of the form:
	//
	//		GET <x> HTTP/1.0\0x0d\0x0a\0x0d\0x0a
	//
	// where <x> is the URL path.  destFileRefNum is the file
	// reference number to which the results of the HTTP command
	// are written.  This routine does not parse the returned HTTP
	// header in any way.  The entire incoming stream goes into
	// the file verbatim.
	//
	// For example, if you were asked to download a URL like:
	//
	//		http://devworld.apple.com/dev/technotes.shtml
	//
	// you would set:
	//
	// 		o hostName to "devworld.apple.com:80" (80 is the
	//		  default port for HTTP.
	//		o httpCommand to "GET /dev/technotes.shtml HTTP/1.0\0x0d\0x0a\0x0d\0x0a"
{
	OSStatus err = noErr;

	CThreadYielder_AC yielder;
	CTCPEndpoint ep(&yielder);

	Boolean bound = false;

	try
	{
		// First allocate a buffer for storing the data as we read it.
		
		CTextBuffer transferBuffer;
		transferBuffer.reallocate(kTransferBufferSize);
		
		// Now open a TCP endpoint.
		
		ep.Open();
		
		// If the endpoint opens successfully...
		
		// Bind the endpoint.  Because we're an outgoing connection,
		// we don't have to bind it to a specific address.
				
		ep.Bind();

		bound = true;
			
		// Initialise the sndCall structure and call OTConnect.  We nil
		// out most of the fields in the sndCall structure because
		// we don't want any special options or connection data.
		// The important field of the sndCall is the addr TNetBuf,
		// which we initialise to the
		
		CDNSAddress hostAddress(hostName);
		ep.Connect(hostAddress);

		// Send the HTTP command to the server.
		
		ep.Send(httpCommand, OTStrLength(httpCommand));
		
		// Now that we have sent the HTTP command, we turn around and
		// receive the data coming back from the server.
		
		long bytesReceived;
		do
		{
			bytesReceived = ep.Receive(transferBuffer, kTransferBufferSize);
			
			// Receive returns the number of bytes received.  Because we're in
			// synchronous mode, it won't return until it's gotten something,
			// or it gets an error.  
			
			if (bytesReceived > 0)
				ThrowIfOSErr_AC(FSWrite(destFileRefNum, &bytesReceived, transferBuffer));

			// We keep running this loop until we get an eof.
		}
		while (bytesReceived >= 0);
	}
	catch (CException_AC& fi)
	{
		err = fi.GetError();
	}
	
	// Clean up.

	if (bound)
	{
		OSStatus junk = ep.Unbind();
		Warning_AC(junk, "SimpleHTTPDownload: OTUnbind failed.");
	}

	{
		OSStatus junk = ep.Close();
		Warning_AC(junk, "SimpleHTTPDownload: OTCloseProvider failed.");
	}

	return (err);
}


//----------------------------------------------------------------------------------------
// End of SimpleHTTPDownload.cpp