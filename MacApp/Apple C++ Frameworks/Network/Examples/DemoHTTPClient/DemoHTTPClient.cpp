//----------------------------------------------------------------------------------------
// DemoHTTPClient.cpp
// Copyright © 1997-2001 by Apple Computer, Inc., All Rights Reserved.
//----------------------------------------------------------------------------------------

/*
	Contains:	A test program for the simple HTTP download sample.

	You may incorporate this Apple sample source code into your program(s) without
	restriction. This Apple sample source code has been provided "AS IS" and the
	responsibility for its operation is yours. You are not permitted to redistribute
	this Apple sample source code as "Apple sample source code" after having made
	changes. If you're going to re-distribute the source, we require that you make
	it clear in the source that the code was descended from Apple sample source
	code, but that you've made changes.
*/

/*
	Change History:
		03/28/01	Don't use OTAssert or OTDebugStr at all. 
		02/05/01	Use CPascalString_AC instead of PLStringFuncs which are
							not available without Carbon. 
		05/17/00	Allow multiple downloads. 
		03/31/00	Use ACS. 
		07/23/99	Karl Groethe	Updated for Metrowerks Codewarror Pro 2.1

	Written by: Quinn "The Eskimo!"	
*/

// DemoHTTPClient

#ifndef __SimpleHTTPDownload__
#include "SimpleHTTPDownload.h"
#endif

// Network

#ifndef __COpenTransport__
#include "COpenTransport.h"
#endif

#ifndef __SimpleHeap__
#include "SimpleHeap.h"
#endif

#ifndef __Transport__
#include "Transport.h"
#endif

// ACS

#ifndef __CCooperativeThread_AC__
#include "CCooperativeThread_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __CThreadRunner_AC__
#include "CThreadRunner_AC.h"
#endif

// Toolbox

#ifndef __DRIVERSERVICES__
#include <DriverServices.h>
#endif

#ifndef __FILES__
#include <Files.h>
#endif

#ifndef __OPENTRANSPORT__
#include <OpenTransport.h>
#endif

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

#ifndef __TEXTUTILS__
#include <TextUtils.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

// ANSI

#ifndef __SIOUX__
#include <SIOUX.h>
#endif

#ifndef _STRING_H
#include <string.h>
#endif

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _CTYPE_H
#include <ctype.h>
#endif

//========================================================================================
// Constants
//========================================================================================

enum
{
	kNotHTTPURLErr = -666,
	kWhatImplementationErr = -667
};

static OSStatus DownloadURL(const char *urlString);

//========================================================================================
// CDownloadSample
//========================================================================================

class CDownloadSample : public CCooperativeThread_AC
{
public:
	CDownloadSample(const char* urlString);
	virtual ~CDownloadSample();

	virtual void Run();

protected:
	const char*		fURL;
};

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CDownloadSample::CDownloadSample(const char* urlString) :
	CCooperativeThread_AC(),
	fURL(urlString)
{
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

CDownloadSample::~CDownloadSample()
{
}

//----------------------------------------------------------------------------------------
// Run
//----------------------------------------------------------------------------------------

void CDownloadSample::Run()
{
	ThrowIfOSErr_AC(DownloadURL(fURL));
}


//========================================================================================
// Global Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// DownloadURL
//----------------------------------------------------------------------------------------

static OSStatus CreateFile(const char *path, FSSpec *destFSSpec)
{
	OSStatus err = noErr;

	const char* fileName = path;
	if (*fileName)
	{
		while (const char* slash = strchr(fileName, '/'))
		{
			if (!*(++slash))
				break;

			fileName = slash;
		}
	}
	
	int nameLen = strlen(fileName);
	if (nameLen && fileName[nameLen-1] == '/')
		--nameLen;

	short num = 0;
	do
	{
		CStr255_AC destFileName;
		if (nameLen)
		{
			destFileName[0] = nameLen;
			strncpy((char*)&destFileName[1], fileName, nameLen);
		}
		else
			destFileName = "\pindex.html";

		if (num > 0)
		{
			CStr255_AC numString;
			NumToString(num, numString);
			destFileName += ' ';
			destFileName += numString;
		}
		++num;

		FSMakeFSSpec(0, 0, destFileName, destFSSpec);
		err = FSpCreate(destFSSpec, 'MSIE', 'TEXT', 0);
	}
	while (err == dupFNErr);

	return err;
}

//----------------------------------------------------------------------------------------
// DownloadURL
//----------------------------------------------------------------------------------------

static OSStatus DownloadURL(const char *urlString)
{
	OSStatus err = noErr;
	
	short destFileRefNum = 0;

	try
	{
		// First check that the urlString begins with "http://"
		if ( strspn(urlString, "http://") != strlen("http://") )
		{
			ThrowError_AC(kNotHTTPURLErr);
		}

		// Now skip over the "http://" and extract the host name.
		// Skip over the "http://".
		urlString += strlen("http://");
		
		// Count the characters before the next slash.
		size_t hostCharCount = strcspn(urlString, "/");
		
		// Extract those characters from the URL into hostName
		//  and then make sure it's null terminated.
		char hostName[256];
		strncpy(hostName, urlString, hostCharCount);
		hostName[hostCharCount] = 0;
		urlString += hostCharCount;
		
		// Add a ":80" to the host name if necessary.
		if ( strchr( hostName, ':' ) == nil ) 
		{
			strcat( hostName, ":80" );
		}

		FSSpec destFSSpec;
		ThrowIfOSErr_AC(CreateFile(urlString, &destFSSpec));
		ThrowIfOSErr_AC(FSpOpenDF(&destFSSpec, fsRdWrPerm, &destFileRefNum));
		
		// Now place the URL into the HTTP command that we send to SimpleHTTPDownload.
		if ( *urlString == 0 )
		{
			urlString = "/";
		}
		char httpGetCommand[256];
//		sprintf(httpGetCommand, "GET %s HTTP/1.0%c%c%c%c", urlString, 13, 10, 13, 10);
		sprintf(httpGetCommand, "GET %s HTTP/1.0\r\nUser-Agent: OTSimpleDownload/2.0d1\r\n\r\n", urlString);
		printf("Calling SimpleHTTPDownload(“%s”, “%s”, %04x).\n", hostName, urlString, destFileRefNum);
		
		OTTimeStamp startTime;
		OTGetTimeStamp(&startTime);
		ThrowIfOSStatus(SimpleHTTPDownload(hostName, httpGetCommand, destFileRefNum));
		UInt32 timeToDownload = OTElapsedMicroseconds(&startTime);

		long fileSize = 0;
		ThrowIfOSErr_AC(GetFPos(destFileRefNum, &fileSize));
		printf("Bytes downloaded: %d.\n", fileSize);
		printf("Time to download: %dus.\n", timeToDownload);
		printf("Bytes per second: %f.\n", (float) fileSize / (((float) timeToDownload) / 1000000.0) );
	}
	catch (CException_AC& fi)
	{
		err = fi.GetError();
	}

	// Clean up.
	if (destFileRefNum != 0)
	{
		FSClose(destFileRefNum);
	}
	if (err != noErr)
	{
		//FSpDelete(&destFSSpec);
	}

	return (err);
}

//========================================================================================
// Global Functions
//========================================================================================

static const char *defaultURLs[10] =
{
	"http://www.apple.com",
	"http://www.apple.com/developer/",
	"http://developer.apple.com/macos/opentransport/",
	"http://developer.apple.com/technotes/index.html",
	"http://developer.apple.com/tools/macapp/",
	"",
	"",
	"",
	"",
	""
};

//----------------------------------------------------------------------------------------
// main
//----------------------------------------------------------------------------------------

void main()
{
	SIOUXSettings.asktosaveonclose = 0;

	printf("Hello Cruel World!\n");
	printf("\n");
	printf("OTDownloadHTTP!\n");
	printf("-- Downloads a URL using OT's thread support\n");
	printf("-- or using notifiers.\n");
	printf("\n");

	try
	{
		InitSimpleHeap();

		CUsingOpenTransport openTransport(true);

		for (UInt32 i = 0; i < 10; i++)
		{
			if ( *defaultURLs[i] != 0 )
			{
				printf("%d> %s\n", i, defaultURLs[i]);
			}
		}

		for (;;)
		{
			printf("\n");
			printf("Enter a URL (or type a number from the above list):\n");
			char urlString[256];
			gets(urlString);
			if ( urlString[0] == 0 )
				break;

			if ( strlen(urlString) == 1 && isdigit(urlString[0]))
				strcpy( urlString, defaultURLs[ urlString[0] - '0' ] );

			if ( urlString[0] == 0 )
				strcpy( urlString, defaultURLs[0] );

			{
				CDownloadSample downloader(urlString);
				downloader.SetIsRefCountable(false);
				CThreadRunner_AC thread(&downloader);

				UInt32 period = TickCount() + 60;
				while (thread->IsAlive())
				{
					if (TickCount() > period)
					{
						printf(".");
						fflush(stdout);
						period = TickCount() + 60;
					}
					SIOUXHandleOneEvent(NULL);
					YieldToAnyThread();
				}
				thread->ThrowIfHasException();
			}
			
			printf("Success.\n");
		}
	}
	catch (CException_AC& fi)
	{
		printf("Failed with error %d.\n", fi.GetError());
	}
	
	printf("Done.  Press command-Q to Quit.\n");
}


//----------------------------------------------------------------------------------------
// End of DemoHTTPClient.cpp