//----------------------------------------------------------------------------------------
// DemoPing.cpp
// Copyright © 1996-2000 by Apple Computer, Inc., All Rights Reserved.
//----------------------------------------------------------------------------------------

/*
	Contains:		A trivial ping implementation.

	You may incorporate this Apple sample source code into your program(s) without
	restriction. This Apple sample source code has been provided "AS IS" and the
	responsibility for its operation is yours. You are not permitted to redistribute
	this Apple sample source code as "Apple sample source code" after having made
	changes. If you're going to re-distribute the source, we require that you make
	it clear in the source that the code was descended from Apple sample source
	code, but that you've made changes.

	Change History (most recent first):
		07/23/99	Karl Groethe	Updated for Metrowerks Codewarror Pro 2.1
				
	Written by: Quinn "The Eskimo!"	
*/

// Network

#ifndef __CNetAddress__
#include "CNetAddress.h"
#endif

#ifndef __COpenTransport__
#include "COpenTransport.h"
#endif

#ifndef __CRawIPEndpoint__
#include "CRawIPEndpoint.h"
#endif

#ifndef __Transport__
#include "Transport.h"
#endif

// ACS

#ifndef __CCooperativeThread_AC__
#include "CCooperativeThread_AC.h"
#endif

#ifndef __CThreadRunner_AC__
#include "CThreadRunner_AC.h"
#endif

#ifndef __CThreadYielder_AC__
#include "CThreadYielder_AC.h"
#endif

#ifndef __TidyHeap_AC__
#include "TidyHeap_AC.h"
#endif

// Toolbox

#ifndef __OPENTRANSPORT__
#include <OpenTransport.h>
#endif

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __MATH64__
#include <Math64.h>
#endif

#ifndef __TIMER__
#include <Timer.h>
#endif

// ANSI

#ifndef __SIOUX__
#include <SIOUX.h>
#endif

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STRING_H
#include <string.h>
#endif

//========================================================================================
// CPingSample
//========================================================================================

class CPingSample : public CCooperativeThread_AC
{
public:
	CPingSample(InetHost dest);
	virtual ~CPingSample();

	static UInt16 ChecksumBuffer(UInt16* buf, size_t len);
	void CreateAndConfigICMP();
	void SendICMP(UInt16 seq_number);
	bool WaitAndPrintICMPs(UInt16 seq_number, OTTimeout timeout);
	virtual void Run();

protected:
	CThreadYielder_AC	fYielder;
	UInt8				fBuffer[5000];	// we use this buffer to hold incoming ICMP packets
	InetHost			fDest;
	CRawIPEndpoint		fEndpoint;
	double_t			fTotalTime;
	int					fCount;
};

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CPingSample::CPingSample(InetHost dest) :
	CCooperativeThread_AC(),
	fYielder(),
	fDest(dest),
	fEndpoint(&fYielder),
	fTotalTime(0),
	fCount(0)
{
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

CPingSample::~CPingSample()
{
}

//----------------------------------------------------------------------------------------
// ChecksumBuffer
//----------------------------------------------------------------------------------------

UInt16 CPingSample::ChecksumBuffer(UInt16* buf, size_t len)
{
	// This checksum implementation requires the buffer to be an even number of bytes long.
	UInt32 sum;
	size_t nwords;
	
	nwords = len / 2;
	sum = 0;
	while (nwords > 0)
	{
		sum += *buf;
		buf++;
		nwords -= 1;
	}
	sum = (sum >> 16 ) + (sum & 0xffff);
	sum += (sum >> 16);

	return ~sum;
}

//----------------------------------------------------------------------------------------
// CreateAndConfigICMP
//----------------------------------------------------------------------------------------

void CPingSample::CreateAndConfigICMP()
{
	fEndpoint.Open();

   	fEndpoint.Bind();
	// no others options to negotiate at this stage
	
	// You might think we need to negotiate the XTI_GENERIC/XTI_PROTOTYPE
	// option to request ICMP packets (ie protocol 2).  This is not
	//  necessary because rawip endpoints default to that protocol.
}

//----------------------------------------------------------------------------------------
// PingPacket
//----------------------------------------------------------------------------------------

enum
{
	kOurMagic = 'Quin'
};

struct PingPacket
{
	UInt8   pType;
	UInt8   pCode;
	UInt16  pChecksum;
	UInt16  pID;
	UInt16  pSeqNum;
	OSType	pMagic;
	OTTimeStamp	pSent;
};
typedef struct PingPacket PingPacket, *PingPacketPtr;

//----------------------------------------------------------------------------------------
// SendICMP
//----------------------------------------------------------------------------------------

void CPingSample::SendICMP(UInt16 seq_number)
{
	CInetAddress dest_addr(fDest);

	PingPacket ping_data;
	ping_data.pType = 8;
	ping_data.pCode = 0;
	ping_data.pChecksum = 0;		// dummy checksum of 0 for purposes of checksum calculation
	ping_data.pID = 666;
	ping_data.pSeqNum = seq_number;
	ping_data.pMagic = kOurMagic;
	OTGetTimeStamp(&ping_data.pSent);

	ping_data.pChecksum = ChecksumBuffer((UInt16 *) &ping_data, sizeof(ping_data));

	fEndpoint.Send(dest_addr, &ping_data, sizeof(ping_data));
}

//----------------------------------------------------------------------------------------
// WaitAndPrintICMPs
//----------------------------------------------------------------------------------------

bool CPingSample::WaitAndPrintICMPs(UInt16 seq_number, OTTimeout timeout)
{
	bool got_response = false;

	// Wait for 'timeout' milliseconds and print out any ICMP packets we get back.
	OTTimeStamp startTime;
	OTGetTimeStamp(&startTime);
	long timeLeft = timeout;
	do
	{
		// Look for a packet...
		InetAddress src_addr;
		CReceived received = fEndpoint.Receive(src_addr, fBuffer, sizeof(fBuffer), timeLeft);
		if (received > 0)
		{
			double_t tripMilliSeconds = 0;

			PingPacketPtr ping_data_ptr = (PingPacketPtr) &fBuffer[20];

			if (ping_data_ptr->pType == 0
				&& ping_data_ptr->pID == 666 
				&& ping_data_ptr->pSeqNum == seq_number 
				&& ping_data_ptr->pMagic == kOurMagic)
			{
				got_response = true;

				UInt64 tripTime = OTElapsedMicroseconds(&ping_data_ptr->pSent);
				tripMilliSeconds = ((double_t)tripTime) / 1000.;

				fTotalTime += tripMilliSeconds;
				++fCount;
			}
			
			// Print out salient information from the packet...
			printf("ICMP from = %d.%d.%d.%d", fBuffer[12], fBuffer[13], fBuffer[14], fBuffer[15]);
			printf(", type = %d", ping_data_ptr->pType);
			printf(", code = %d", ping_data_ptr->pCode);

			if (got_response)
				printf(", time = %f msec\n", tripMilliSeconds);
			else
				printf("but it's not ours!\n");
			
			fflush(stdout);
		}

		fYielder.YieldNow();

		timeLeft = timeout - OTElapsedMilliseconds(&startTime);
	}
	while (timeLeft > 0);

	return got_response;
}

//----------------------------------------------------------------------------------------
// Run
//----------------------------------------------------------------------------------------

void CPingSample::Run()
{
	// Create the endpoint and negotiate the options...
	CreateAndConfigICMP();
	
	// Do the main ping loop...
	
	UInt16 seq_number = 0;
	UInt16 lost = 0;
	do
	{
		unsigned char* dest = (unsigned char*)&fDest;
		printf("\nPinging %d.%d.%d.%d\n", dest[0], dest[1], dest[2], dest[3]);
		SendICMP(seq_number);

		if (!WaitAndPrintICMPs(seq_number, 5000))
			++lost;
	}
	while (++seq_number < 5);

	printf("Ping complete.  %d packets sent.  %d packets lost.  %d%% packet loss.\n", seq_number, lost, lost * 100 / seq_number);
	if (fCount)
		printf("Average time = %f msec\n", fTotalTime / fCount);
}

//========================================================================================
// Global Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// main
//----------------------------------------------------------------------------------------

void main()
{
	OSStatus err = noErr;
	InetSvcRef inet_services = nil;
	
	SIOUXSettings.asktosaveonclose = 0;

	printf("Hello Cruel World!\n");
	
	try
	{
		for (;;)
		{
			CUsingOpenTransport openTransport(true);

			InetHost host_addr = 0;
			{
				char host_name[256];
				printf("Enter name of host to ping:\n");
				gets(host_name);
				if (strlen(host_name) == 0)
					break;

				host_addr = CInetAddress(host_name).fHost;
			}
			
			CThreadRunner_AC pingThread(TH_new CPingSample(host_addr));
			while (pingThread->IsAlive())
			{
				SIOUXHandleOneEvent(NULL);
				YieldToAnyThread();
			}
			pingThread->ThrowIfHasException();
		}
		printf("Success!\n");
	}
	catch (CException_AC& fi)
	{
		OSStatus err = fi.GetError();
		printf("Failure!  Error = %d.\n", err);
	}
	catch (...)
	{
		printf("Exception!\n");
	}
	
	printf("Done.  Press command-Q to Quit.\n");
}


//----------------------------------------------------------------------------------------
// End of DemoPing.cpp
