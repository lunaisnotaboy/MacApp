//----------------------------------------------------------------------------------------
// UPingBehavior.cpp
// Copyright © 2000 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		03/23/00	Give the okay button the same identifier in all dialogs. 
		03/23/00	Rename units. 
		03/21/00	Initial version. 
*/

#ifndef __UPingBehavior__
#include "UPingBehavior.h"
#endif

// DemoNet

#ifndef __DemoNet_r__
#include "DemoNet.r.h"
#endif

#ifndef __UPingDocument__
#include "UPingDocument.h"
#endif

// MacApp

#ifndef __UDIALOG__
#include "UDialog.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif


//========================================================================================
// TPingBehavior
//========================================================================================

//----------------------------------------------------------------------------------------
// Initialize
//----------------------------------------------------------------------------------------

void TPingBehavior::Initialize()
{
	InitUDialog();
}

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TPingBehavior::TPingBehavior(IDType itsIdentifier) :
	TBehavior(itsIdentifier)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TPingBehavior::~TPingBehavior()
{
}

//----------------------------------------------------------------------------------------
// DoSetupMenus
//----------------------------------------------------------------------------------------

void TPingBehavior::DoSetupMenus() // override 
{
	Inherited::DoSetupMenus();
	
	Enable(cPing, true);
}

//----------------------------------------------------------------------------------------
// DoMenuCommand
//----------------------------------------------------------------------------------------

void TPingBehavior::DoMenuCommand(CommandNumber aCommandNumber) // override 
{
	bool handled = false;

	switch (aCommandNumber) 
	{
		case cPing:
			PostPingCommand(aCommandNumber);
			handled = true;
			break;

		default:
			break;
	}

	if (!handled)
		Inherited::DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// PostPingCommand
//----------------------------------------------------------------------------------------

void TPingBehavior::PostPingCommand(CommandNumber aCommandNumber)
{
	CStr255_AC address;
	if (PosePingDialog(address) && (address.Length() > 0))
	{
		fOwner->PostCommand(TH_new TNewPingDocumentCommand(aCommandNumber, address));
	}
}

//----------------------------------------------------------------------------------------
// PosePingDialog
//----------------------------------------------------------------------------------------

bool TPingBehavior::PosePingDialog(CStr255_AC& address)
{
	bool okay = false;

	CAutoPtr_AC<TWindow> dialog = gViewServer->NewTemplateWindow(kPingDialogID, NULL);
	::ThrowIfNULL_AC(dialog);

	IDType dismisser = dialog->PoseModally();
	if (dismisser == 'okay')
	{
		okay = true;
		TEditText* addressText = dynamic_cast_AC(TEditText*, dialog->FindSubView('addr'));
		ThrowIfNonObject_AC(addressText);
		address = addressText->GetText();
	}

	dialog->Close();
	
	return okay;
}


//========================================================================================
// TNewPingDocumentCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TNewPingDocumentCommand::TNewPingDocumentCommand(CommandNumber itsCommandNumber,
												 const CStr255_AC& address) :
	TNewDocumentCommand(itsCommandNumber),
	fAddress(address)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TNewPingDocumentCommand::~TNewPingDocumentCommand()
{
}

//----------------------------------------------------------------------------------------
// DoIt
//----------------------------------------------------------------------------------------

void TNewPingDocumentCommand::DoIt() // override 
{
	TDocument* document = gApplication->OpenNew(fIdentifier);

	TPingDocument* pingDocument = dynamic_cast_AC(TPingDocument*, document);
	ThrowIfNonObject_AC(pingDocument);

	pingDocument->DoPing(fAddress);
}


//----------------------------------------------------------------------------------------
// End of UPingBehavior.cpp
