//----------------------------------------------------------------------------------------
// UWindowHeaderView.cpp
// Copyright © 1998-2000 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		03/14/00	Allow view to be at (0, 0) and same width as its window. 
		03/13/00	Converted from adorner to view so it can handle activates. 
		12/08/99	Include CTempRegion_AC.h and UView.h.
		08/17/99	Change obsoleted macros to ACS versions. 
		03/24/99	Update copyright notice.
*/


#ifndef __UWindowHeaderView__
#include "UWindowHeaderView.h"
#endif

// MacApp

#ifndef __UVIEW__
#include "UView.h"
#endif

// ACS

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

//========================================================================================
// Global Initialization Procedure
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// InitUWindowHeaderView: 
//----------------------------------------------------------------------------------------

void InitUWindowHeaderView()
{
	// So the view can be created by name
	REGISTER_CLASS_AC(TWindowHeaderView);
}


//========================================================================================
// CLASS TWindowHeaderView
//========================================================================================
#undef Inherited

MA_DEFINE_CLASS(TWindowHeaderView);

//----------------------------------------------------------------------------------------
// TWindowHeaderView constructor 
//----------------------------------------------------------------------------------------

TWindowHeaderView::TWindowHeaderView() : 
	TView()
{
}

//----------------------------------------------------------------------------------------
// TWindowHeaderView destructor
//----------------------------------------------------------------------------------------

TWindowHeaderView::~TWindowHeaderView()
{
}
	
//----------------------------------------------------------------------------------------
// TWindowHeaderView::Activate:
//----------------------------------------------------------------------------------------

void TWindowHeaderView::Activate(bool /*entering*/) // override
{
	TWindow* window = GetWindow();
	if (window && window->GetUpdating())
		DrawContents();
	else
		ForceRedraw();
}

//----------------------------------------------------------------------------------------
// TWindowHeaderView::Draw: 
//----------------------------------------------------------------------------------------

void TWindowHeaderView::Draw(const CViewRect& /*area*/) // override
{
	// DrawThemeWindowHeader looks best when it draws a rect starting at (-1, -1) in
	// the window. On our end, it's easier to have the view start at (0, 0) and have the
	// same width as the window. Fix up the rect here so the view can be set up the easy
	// way and it will still look right. 
	CRect_AC extent(GetQDExtent());
	--extent.top;
	--extent.left;
	++extent.right;
	DrawWindowHeader(extent, IsActive() ? kThemeStateActive : kThemeStateDisabled);
}

//----------------------------------------------------------------------------------------
// TWindowHeaderView::InvalidateFrameDifference: 
//----------------------------------------------------------------------------------------

void TWindowHeaderView::InvalidateFrameDifference(const CViewRect& oldFrame,
												  const CViewRect& newFrame) // override
{
	if (oldFrame != newFrame && fSuperView && FocusOnSuperView())
	{
		enum { kMargin = 1 };

		CRect_AC oldQDFrame(fSuperView->ViewToQD(oldFrame));
		oldQDFrame.Inset(kMargin, kMargin);
		CTempRegion_AC oldFrameRgn;
		RectRgn(oldFrameRgn, &oldQDFrame);

		CRect_AC newQDFrame(fSuperView->ViewToQD(newFrame));
		newQDFrame.Inset(kMargin, kMargin);
		CTempRegion_AC newFrameRgn;
		RectRgn(newFrameRgn, &newQDFrame);

		// If it didn't move then only the size difference is invalid if the view
		// doesn't have contents proportional to its size. Otherwise both the regions
		// are invalid
		if (oldFrame[topLeft] == newFrame[topLeft])
			XorRgn(oldFrameRgn, newFrameRgn, newFrameRgn);
		else
			UnionRgn(oldFrameRgn, newFrameRgn, newFrameRgn);
		InsetRgn(newFrameRgn, -kMargin, -kMargin);
		
		fSuperView->Invalidate(newFrameRgn);
	}
}

//----------------------------------------------------------------------------------------
// TWindowHeaderView::DrawWindowHeader: 
//----------------------------------------------------------------------------------------

void TWindowHeaderView::DrawWindowHeader(const CRect_AC& rect, ThemeDrawState state)
{
	::AGADrawThemeWindowHeader(rect, state);
}

//----------------------------------------------------------------------------------------
// End of UWindowHeaderView.cpp
