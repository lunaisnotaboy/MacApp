//----------------------------------------------------------------------------------------
// UTerminalBehavior.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		02/05/01	Required explicit conversion to CString_AC. 
		03/23/00	Initial version. 
*/

#ifndef __UTerminalBehavior__
#include "UTerminalBehavior.h"
#endif

// DemoNet

#ifndef __DemoNet_r__
#include "DemoNet.r.h"
#endif

#ifndef __UTerminalDocument__
#include "UTerminalDocument.h"
#endif

// Network

#ifndef __Ports__
#include "Ports.h"
#endif

// MacApp

#ifndef __UDIALOG__
#include "UDialog.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

// Toolbox

#ifndef __NUMBERFORMATTING__
#include <NumberFormatting.h>
#endif


//========================================================================================
// TTerminalBehavior
//========================================================================================

//----------------------------------------------------------------------------------------
// Initialize
//----------------------------------------------------------------------------------------

void TTerminalBehavior::Initialize()
{
	InitUDialog();
}

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TTerminalBehavior::TTerminalBehavior(IDType itsIdentifier) :
	TBehavior(itsIdentifier)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TTerminalBehavior::~TTerminalBehavior()
{
}

//----------------------------------------------------------------------------------------
// DoSetupMenus
//----------------------------------------------------------------------------------------

void TTerminalBehavior::DoSetupMenus() // override 
{
	Inherited::DoSetupMenus();
	
	Enable(cTerminal, true);
}

//----------------------------------------------------------------------------------------
// DoMenuCommand
//----------------------------------------------------------------------------------------

void TTerminalBehavior::DoMenuCommand(CommandNumber aCommandNumber) // override 
{
	bool handled = false;

	switch (aCommandNumber) 
	{
		case cTerminal:
			PostTerminalCommand(aCommandNumber);
			handled = true;
			break;

		default:
			break;
	}

	if (!handled)
		Inherited::DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// PostTerminalCommand
//----------------------------------------------------------------------------------------

void TTerminalBehavior::PostTerminalCommand(CommandNumber aCommandNumber)
{
	CStr255_AC address(1001, 1); // "macapp.apple.com"
	InetPort port = kTelnetPort;
	if (PoseTerminalDialog(address, port) && (address.Length() > 0))
	{
		fOwner->PostCommand(TH_new TNewTerminalDocumentCommand(aCommandNumber, address, port));
	}
}

//----------------------------------------------------------------------------------------
// PoseTerminalDialog
//----------------------------------------------------------------------------------------

bool TTerminalBehavior::PoseTerminalDialog(CStr255_AC& address, InetPort& port)
{
	bool okay = false;

	CAutoPtr_AC<TWindow> dialog = gViewServer->NewTemplateWindow(kTerminalDialogID, NULL);
	::ThrowIfNULL_AC(dialog);

	TEditText* addressText = dynamic_cast_AC(TEditText*, dialog->FindSubView('addr'));
	ThrowIfNonObject_AC(addressText);
	addressText->SetText(CString_AC(address), kDontRedraw);

	TNumberText* portText = dynamic_cast_AC(TNumberText*, dialog->FindSubView('port'));
	ThrowIfNonObject_AC(portText);
	portText->SetValue(port, kDontRedraw);

	IDType dismisser = dialog->PoseModally();
	if (dismisser == 'okay')
	{
		okay = true;
		address = addressText->GetText();

		port = portText->GetValue();
	}

	dialog->Close();
	
	return okay;
}


//========================================================================================
// TNewTerminalDocumentCommand
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TNewTerminalDocumentCommand::TNewTerminalDocumentCommand(CommandNumber itsCommandNumber,
														 const CStr255_AC& address,
														 InetPort port) :
	TNewDocumentCommand(itsCommandNumber),
	fAddress(address),
	fPort(port)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TNewTerminalDocumentCommand::~TNewTerminalDocumentCommand()
{
}

//----------------------------------------------------------------------------------------
// DoIt
//----------------------------------------------------------------------------------------

void TNewTerminalDocumentCommand::DoIt() // override 
{
	TDocument* document = gApplication->OpenNew(fIdentifier);

	TTerminalDocument* terminalDocument = dynamic_cast_AC(TTerminalDocument*, document);
	ThrowIfNonObject_AC(terminalDocument);

	terminalDocument->Connect(fAddress, fPort);
}


//----------------------------------------------------------------------------------------
// End of UTerminalBehavior.cpp
