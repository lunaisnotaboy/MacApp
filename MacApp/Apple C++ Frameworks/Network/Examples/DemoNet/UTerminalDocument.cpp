//----------------------------------------------------------------------------------------
// UTerminalDocument.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		02/05/01	Required explicit conversion to CString_AC. 
		05/24/00	Isolate clients from look errors. 
		05/23/00	Use ASCII.h constants. 
		05/18/00	Change log to use TWEView. 
							Can join the protocol thread at Close time again. 
		05/16/00	Move message panel into terminal window. 
							Terminal object pushes received data to the event handler. 
		05/15/00	Automatically add a linefeed after every carriage return when
							sending. 
		03/26/00	Message window. 
		03/23/00	Initial version. 
*/

#ifndef __UTerminalDocument__
#include "UTerminalDocument.h"
#endif

// DemoNet

#ifndef __DemoNet_r__
#include "DemoNet.r.h"
#endif

// Network

#ifndef __ASCII__
#include "ASCII.h"
#endif

#ifndef __ULogView__
#include "ULogView.h"
#endif

#ifndef __UTerminalClient__
#include "UTerminalClient.h"
#endif

// MacApp

#ifndef __UEDITTEXT__
#include "UEditText.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif


//========================================================================================
// CLASS TTerminalDocument
//========================================================================================
#undef Inherited
#define Inherited TFileBasedDocument

//MA_DEFINE_CLONE(TTerminalDocument);

//----------------------------------------------------------------------------------------
// Initialize
//----------------------------------------------------------------------------------------

void TTerminalDocument::Initialize()
{
	InitUTEView();
}

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TTerminalDocument::TTerminalDocument(TFile* itsFile, OSType itsCreator) :
	TFileBasedDocument(itsFile, itsCreator),
	fThreadRunner(),
	fLog(NULL),
	fMessage(NULL),
	fSendButton(NULL)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TTerminalDocument::~TTerminalDocument()
{
}

//----------------------------------------------------------------------------------------
// Changed
//----------------------------------------------------------------------------------------

void TTerminalDocument::Changed(ChangeID_AC theChange, void* changeData) // override
{
	TFileBasedDocument::Changed(theChange, changeData);

	switch (theChange)
	{
		case cConnected:
			Connected();
			break;

		case cSent:
			{
				TTerminalSendCommand* sendCommand = reinterpret_cast<TTerminalSendCommand*>(changeData);
				Sent(sendCommand->GetBuffer());
			}
			break;

		case cReceived:
			{
				TTerminalReceiveCommand* receiveCommand = reinterpret_cast<TTerminalReceiveCommand*>(changeData);
				Received(receiveCommand->GetBuffer(), receiveCommand->GetResult());
			}
			break;

		case mClosed:
			Closed();
			break;

		default:
			break;
	}
}

//----------------------------------------------------------------------------------------
// Connected
//----------------------------------------------------------------------------------------

void TTerminalDocument::Connected()
{
//	HandleMenuCommand(cMessage);
//	Receive(1024);
}

//----------------------------------------------------------------------------------------
// Sent
//----------------------------------------------------------------------------------------

void TTerminalDocument::Sent(const CTextBuffer& text)
{
	CTextBuffer::size_type count = text.GetSize();
	if (count > 0)
	{
		fLog.WriteCharBytes(text, count);
		fLog.Flush();
	}
}

//----------------------------------------------------------------------------------------
// Received
//----------------------------------------------------------------------------------------

void TTerminalDocument::Received(const CTextBuffer& text, long result)
{
	if (result >= 0)
	{
		CTextBuffer::size_type count = text.GetSize();
		if (count > 0)
		{
			fLog.WriteCharBytes(text, count);
			fLog.Flush();
		}
		
		//Receive(1024);
	}
}

//----------------------------------------------------------------------------------------
// Closed
//----------------------------------------------------------------------------------------

void TTerminalDocument::Closed()
{
	if (fThreadRunner)
	{
		if (fLog.GetView())
			fLog << "Canceling" << endl_AC;

		fThreadRunner->Join();
	}

	fLog.Flush();
	fLog.SetView(NULL);
}

//----------------------------------------------------------------------------------------
// DoMakeViews
//----------------------------------------------------------------------------------------

void TTerminalDocument::DoMakeViews(bool /*forPrinting*/) // override 
{
	TWindow* aWindow = gViewServer->NewTemplateWindow(kTerminalWindowID, this);
	::ThrowIfNULL_AC(aWindow);

	TView* mainView = aWindow->FindSubView('TeVW');
	if (mainView)
	{
		TH_new TStdPrintHandler(this, mainView, kFixedSize, kFixedSize);
		
		TWEView* logView = dynamic_cast_AC(TWEView*, mainView);
		if (logView)
			fLog.SetView(logView);
	}

	fMessage = dynamic_cast_AC(TTEView*, aWindow->FindSubView('mark'));
	fSendButton = dynamic_cast_AC(TButton*, aWindow->FindSubView('send'));
}

//----------------------------------------------------------------------------------------
// DoEvent
//----------------------------------------------------------------------------------------

void TTerminalDocument::DoEvent(EventNumber eventNumber, TEventHandler* source, TEvent* event) // override 
{
	bool handled = false;

	if ((eventNumber == mButtonHit) && (source == fSendButton))
	{
		Send(fMessage);
		handled = true;
	}

	if (!handled)
		TFileBasedDocument::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// Send
//----------------------------------------------------------------------------------------

void TTerminalDocument::Send(TTEView* message)
{
	ThrowIfNonObject_AC(message);

	Handle textH = message->ExtractText();
	long textHSize = GetHandleSize(textH);
	if (textHSize > 0)
	{
		CTextBuffer buffer;
		buffer.reallocate(textHSize);

		char lineFeed = kLFChar;
		for (long i = 0; i < textHSize; ++i)
		{
			char c = (*textH)[i];
			buffer.append(&c, 1);
			if (c == kCRChar)
				buffer.append(&lineFeed, 1);
		}
		
		Send(buffer, buffer.GetSize());
	}

	message->SetText("");
	message->ForceRedraw();
}

//----------------------------------------------------------------------------------------
// GetTerminalClient
//----------------------------------------------------------------------------------------

TTerminalClient* TTerminalDocument::GetTerminalClient()
{
	if (!fThreadRunner)
		fThreadRunner.reset(TH_new TTerminalClient(this, cReceived, fLog));

	return reinterpret_cast<TTerminalClient*>(fThreadRunner.get());
}

//----------------------------------------------------------------------------------------
// Connect
//----------------------------------------------------------------------------------------

void TTerminalDocument::Connect(ConstStringPtr address, InetPort port)
{
	CStr255_AC title(address);
	if (port)
	{
		CStr255_AC portString;
		NumToString(port, portString);
		title += ':';
		title += portString;
	}
	SetTitle(CString_AC(title));

	CInetAddress hostAddress(address, port);
	TTerminalClient* client = GetTerminalClient();
	(TH_new TTerminalConnectCommand(cConnected, hostAddress, client, this))->Post();
}

//----------------------------------------------------------------------------------------
// Send
//----------------------------------------------------------------------------------------

void TTerminalDocument::Send(const char* text, size_t count)
{
	TTerminalClient* client = GetTerminalClient();
	(TH_new TTerminalSendCommand(cSent, text, count, client, this))->Post();
}

#if 0
	//----------------------------------------------------------------------------------------
	// Receive
	//----------------------------------------------------------------------------------------

	void TTerminalDocument::Receive(size_t maxChars)
	{
		TTerminalClient* client = GetTerminalClient();
		(TH_new TTerminalReceiveCommand(cReceived, maxChars, client, this))->Post();
	}
#endif


//----------------------------------------------------------------------------------------
// End of UTerminalDocument.cpp