//----------------------------------------------------------------------------------------
// UPingDocument.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		02/05/01	Required explicit conversion to CString_AC. 
		05/18/00	Change log to use TWEView. 
		03/23/00	Add terminal window and dialog. 
		03/23/00	Rename units. 
		03/21/00	Move ping UI to TPingBehavior. Remove empty methods. 
					Shut down thread when closing. 
					Move constants to DemoNet.r.h. 
		03/13/00	Hook up progress. 
					Document creates the ping client itself, instead of going through
					a specialized thread runner. Makes it easier to pass document specific
					data to the ping client. 
		03/24/99	Update copyright notice.
*/

#ifndef __UPingDocument__
#include "UPingDocument.h"
#endif

// DemoNet

#ifndef __DemoNet_r__
#include "DemoNet.r.h"
#endif

#ifndef __ULogView__
#include "ULogView.h"
#endif

// Network

#ifndef __UThreadCommand__
#include "UThreadCommand.h"
#endif

// MacApp

#ifndef __UEDITTEXT__
#include "UEditText.h"
#endif

#ifndef __UMACAPPGLOBALS__
#include "UMacAppGlobals.h"
#endif

#ifndef __UMENUMGR__
#include "UMenuMgr.h"
#endif

#ifndef __UPRINTING__
#include "UPrinting.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif

#ifndef __UWINDOW__
#include "UWindow.h"
#endif


//========================================================================================
// CLASS TPingDocument
//========================================================================================
#undef Inherited
#define Inherited TFileBasedDocument

//MA_DEFINE_CLONE(TPingDocument);

//----------------------------------------------------------------------------------------
// TPingDocument::Initialize: 
//----------------------------------------------------------------------------------------

void TPingDocument::Initialize()
{
//	InitUTEView();
}

//----------------------------------------------------------------------------------------
// TPingDocument constructor 
//----------------------------------------------------------------------------------------

TPingDocument::TPingDocument(TFile* itsFile, OSType itsCreator) :
	TFileBasedDocument(itsFile, itsCreator),
	fPingThreadRunner(),
	fLog(NULL)
{
}

//----------------------------------------------------------------------------------------
// TPingDocument destructor
//----------------------------------------------------------------------------------------

TPingDocument::~TPingDocument()
{
}

//----------------------------------------------------------------------------------------
// TPingDocument::Changed
//----------------------------------------------------------------------------------------

void TPingDocument::Changed(ChangeID_AC theChange, void* changeData) // override
{
	TFileBasedDocument::Changed(theChange, changeData);

	if (theChange == mClosed)
	{
		if (fPingThreadRunner)
		{
			if (fLog.GetView())
				fLog << "Canceling" << endl_AC;

			fPingThreadRunner->Join();
		}

		fLog.Flush();
		fLog.SetView(NULL);
	}
	else if (theChange == cPing)
		fPingThreadRunner = NULL;
}

//----------------------------------------------------------------------------------------
// TPingDocument::DoMakeViews:
//----------------------------------------------------------------------------------------

void TPingDocument::DoMakeViews(bool /*forPrinting*/) // override 
{
	TWindow* aWindow = gViewServer->NewTemplateWindow(kPingWindowID, this);
	::ThrowIfNULL_AC(aWindow);

	TView* mainView = aWindow->FindSubView('TeVW');
	if (mainView)
	{
		TH_new TStdPrintHandler(this, mainView, kFixedSize, kFixedSize);
		
		TWEView* theWEView = dynamic_cast_AC(TWEView*, mainView);
		if (theWEView)
			fLog.SetView(theWEView);
	}
}

//----------------------------------------------------------------------------------------
// TPingDocument::DoPing:
//----------------------------------------------------------------------------------------

void TPingDocument::DoPing(const CStr255_AC& hostName)
{
	SetTitle(CString_AC(hostName));

	CInetAddress inetAddress(hostName);
	TPingClient* pingClient = TH_new TPingClient(inetAddress.fHost, fLog);
	TThreadCommand* pingCommand = TH_new TThreadCommand(cPing, pingClient, this, this);
	PostCommand(pingCommand);
	fPingThreadRunner = pingClient;
}


//----------------------------------------------------------------------------------------
// End of UPingDocument.cpp