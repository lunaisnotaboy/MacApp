//----------------------------------------------------------------------------------------
// UMessageWindow.cpp
// Copyright © 2000 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		05/15/00	Allow message window to be associated with a document. 
							Clear our reference when the window is closed. 
		03/24/00	Initial version. 
*/

#ifndef __UMessageWindow__
#include "UMessageWindow.h"
#endif

// DemoNet

#ifndef __DemoNet_r__
#include "DemoNet.r.h"
#endif

#ifndef __UTerminalDocument__
#include "UTerminalDocument.h"
#endif

// MacApp

#ifndef __UBUTTON__
#include "UButton.h"
#endif

#ifndef __UFLOATWINDOW__
#include "UFloatWindow.h"
#endif

#ifndef __UTECOMMANDS__
#include "UTECommands.h"
#endif

#ifndef __UTEVIEW__
#include "UTEView.h"
#endif

#ifndef __UVIEWSERVER__
#include "UViewServer.h"
#endif


//========================================================================================
// TMessageWindowBehavior
//========================================================================================

//----------------------------------------------------------------------------------------
// Initialize
//----------------------------------------------------------------------------------------

void TMessageWindowBehavior::Initialize()
{
	InitUFloatWindow();
}

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TMessageWindowBehavior::TMessageWindowBehavior(IDType itsIdentifier) :
	TBehavior(itsIdentifier),
	fMessageWindow(NULL)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TMessageWindowBehavior::~TMessageWindowBehavior()
{
}

//----------------------------------------------------------------------------------------
// DoSetupMenus
//----------------------------------------------------------------------------------------

void TMessageWindowBehavior::DoSetupMenus() // override 
{
	Inherited::DoSetupMenus();
	
	Enable(cMessage, true);
}

//----------------------------------------------------------------------------------------
// DoMenuCommand
//----------------------------------------------------------------------------------------

void TMessageWindowBehavior::DoMenuCommand(CommandNumber aCommandNumber) // override 
{
	bool handled = false;

	switch (aCommandNumber)
	{
		case cMessage:
			GetMessageWindow();
			handled = true;
			break;

		default:
			break;
	}

	if (!handled)
		Inherited::DoMenuCommand(aCommandNumber);
}

//----------------------------------------------------------------------------------------
// DoUpdate
//----------------------------------------------------------------------------------------

void TMessageWindowBehavior::DoUpdate(ChangeID_AC theChange, MDependable_AC* changedObject,
									  void* changeData, CDependencySpace_AC* dependencySpace) // override 
{
#pragma unused (changeData, dependencySpace)

	if ((theChange == mClosed) && (changedObject == fMessageWindow))
		fMessageWindow = NULL;
	//else
	//	MDependable_AC::DoUpdate(theChange, changedObject, changeData, dependencySpace);
}

//----------------------------------------------------------------------------------------
// GetMessageWindow
//----------------------------------------------------------------------------------------

TWindow* TMessageWindowBehavior::GetMessageWindow()
{
	if (!fMessageWindow)
	{
		TDocument* document = dynamic_cast_AC(TDocument*, fOwner);

		fMessageWindow = gViewServer->NewTemplateWindow(kMessageWindowID, document);
		fMessageWindow->AddDependent(this);
		fMessageWindow->Open();
	}
	else
	{
		if (!fMessageWindow->IsShown())
			fMessageWindow->Show(true, kDontRedraw);

		fMessageWindow->Select();
	}

	return fMessageWindow;
}


//========================================================================================
// TSendMessageBehavior
//========================================================================================

DEFINE_REGISTERED_AC(TSendMessageBehavior);

//----------------------------------------------------------------------------------------
// constructor 
//----------------------------------------------------------------------------------------

TSendMessageBehavior::TSendMessageBehavior(IDType itsIdentifier) :
	TBehavior(itsIdentifier),
	fMessage(NULL),
	fSendButton(NULL)
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

TSendMessageBehavior::~TSendMessageBehavior()
{
}

//----------------------------------------------------------------------------------------
// DoPostCreate
//----------------------------------------------------------------------------------------

void TSendMessageBehavior::DoPostCreate(TDocument* itsDocument) // override 
{
	Inherited::DoPostCreate(itsDocument);

	FindViews();
}

//----------------------------------------------------------------------------------------
// FindViews
//----------------------------------------------------------------------------------------

void TSendMessageBehavior::FindViews()
{
	TView* ownerView = dynamic_cast_AC(TView*, fOwner);
	if (ownerView)
	{
		fMessage = dynamic_cast_AC(TTEView*, ownerView->FindSubView('mark'));
		fSendButton = dynamic_cast_AC(TButton*, ownerView->FindSubView('send'));
	}
}

//----------------------------------------------------------------------------------------
// DoKeyEvent
//----------------------------------------------------------------------------------------

void TSendMessageBehavior::DoKeyEvent(TToolboxEvent* event) // override 
{
	bool handled = false;

	if (event->GetText()[1] == chEnter)
	{
		if (fSendButton)
			fSendButton->HandleEvent(mButtonHit, fMessage, event);

		handled = true;
	}

	if (!handled)
		Inherited::DoKeyEvent(event);
}

//----------------------------------------------------------------------------------------
// DoEvent
//----------------------------------------------------------------------------------------

void TSendMessageBehavior::DoEvent(EventNumber eventNumber,
								   TEventHandler* source,
								   TEvent* event) // override 
{
	bool handled = false;

	if (eventNumber == mButtonHit)
	{
		TButton* button = dynamic_cast_AC(TButton*, source);
		if (button)
		{
			IDType buttonID = button->GetIdentifier();
			if (buttonID == 'send')
			{
				Send(event);
				handled = true;
			}
		}
	}

	if (!handled)
		Inherited::DoEvent(eventNumber, source, event);
}

//----------------------------------------------------------------------------------------
// Send
//----------------------------------------------------------------------------------------

void TSendMessageBehavior::Send(TEvent* event)
{
	if (fMessage)
	{
		TWindow* window = gDispatcher->GetActiveWindow(false);
		if (window)
			window->HandleEvent(cTyping, fMessage, event);
	}
}


//----------------------------------------------------------------------------------------
// End of UMessageWindow.cpp