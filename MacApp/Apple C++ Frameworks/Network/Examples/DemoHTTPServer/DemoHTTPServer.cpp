//----------------------------------------------------------------------------------------
// DemoHTTPServer.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Contains:	A test program for the simple HTTP server code.

	You may incorporate this Apple sample source code into your program(s) without
	restriction. This Apple sample source code has been provided "AS IS" and the
	responsibility for its operation is yours. You are not permitted to redistribute
	this Apple sample source code as "Apple sample source code" after having made
	changes. If you're going to re-distribute the source, we require that you make
	it clear in the source that the code was descended from Apple sample source
	code, but that you've made changes.
*/

/*
	Change History:
		03/28/01	Don't use OTAssert or OTDebugStr at all. 
		04/08/00	Use a thread object for the listener. 
							Add CancelAll to CTCPEndpoint. 
		07/23/99	Karl Groethe	Updated for Metrowerks Codewarror Pro 2.1

	Written by: Quinn "The Eskimo!"	
*/

// Network

#ifndef __CHTTPListenerThread__
#include "CHTTPListenerThread.h"
#endif

#ifndef __CTCPEndpoint__
#include "CTCPEndpoint.h"
#endif

#ifndef __COpenTransport__
#include "COpenTransport.h"
#endif

#ifndef __SimpleHeap__
#include "SimpleHeap.h"
#endif

#ifndef __Transport__
#include "Transport.h"
#endif

// ACS

#ifndef __CThreadYielder_AC__
#include "CThreadYielder_AC.h"
#endif

#ifndef __TemplateArray_AC__
#include "TemplateArray_AC.h"
#endif

#ifndef __Types_AC__
#include "Types_AC.h"
#endif

// Toolbox

#ifndef __FILES__
#include <Files.h>
#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __OPENTRANSPORT__
#include <OpenTransport.h>
#endif

#ifndef __OPENTPTINTERNET__
#include <OpenTptInternet.h>
#endif

#ifndef __TEXTUTILS__
#include <TextUtils.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

// ANSI

#ifndef __SIOUX__
#include <SIOUX.h>
#endif

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STDLIB_H
#include <stdlib.h>
#endif

//========================================================================================
// Global Variables
//========================================================================================

// The only way to tell whether OT supports IP single link
// multihoming is to check the version number.  The feature was
// added in OT 1.3.  The initialisation code sets 
// gHaveIPSingleLinkMultihoming depending on the version number
// to avoid the rest of the code having to call Gestalt repeatedly.

enum
{
	kOTIPSingleLinkMultihomingVersion = 0x01300000
};

static bool gHaveIPSingleLinkMultihoming;

// gLastCallWNE is used to throttle calls to wait next event so that
// we don't call it too often, which can be bad for system performance.

static UInt32 gLastCallWNE = 0;

// gRunningThreads contains the number of running HTTP listeners.
// We spool an HTTP listener for each IP address on the computer.
// Normally you would only spool one listener for the entire machine
// (listening on kOTAnyInetAddress), but we want to actively distinguish
// between each IP address so that we can server different information
// for each IP address.

UInt32 gRunningThreads = 0;

// Yielder

CThreadYielder_AC gYielder;

// When this boolean is to set true, this module assumes that the
// host application is trying to quit and all the threads created by
// this module start dying.  See the associated comment in the
// YieldingNotifier routine.

extern bool gQuitNow = false;

//========================================================================================
// Global Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// RunOneServer
//----------------------------------------------------------------------------------------

static void RunOneServer(InetHost ipAddr)
	// Runs a single HTTP server thread, serving the
	// given ipAddr.
{
	CHTTPListenerThread* listener = TH_new CHTTPListenerThread(&gYielder, ipAddr);
	listener->Start();

	++gRunningThreads;
}

//----------------------------------------------------------------------------------------
// RunServersForInterface
//----------------------------------------------------------------------------------------

static void RunServersForInterface(InetInterfaceInfo* interfaceInfo, SInt32 interfaceIndex)
	// Run HTTP servers for all of the IP addresses associated
	// with the interface denoted by interfaceInfo and interfaceIndex.
	// This routine first starts a server for the primary address
	// of the interface, then iterates through the secondary addresses on
	// the interface, starting a server thread for each one.
{
	// First run the server for the interfaces primary address.
	
	RunOneServer(interfaceInfo->fAddress);

	// Now start a server for each of the interface's secondary
	// addresses.  This stuff can only be done on systems that
	// support IP single link multihoming.

	UInt32 numberOfSecondaryAddresses = interfaceInfo->fIPSecondaryCount;
	
	if (gHaveIPSingleLinkMultihoming && numberOfSecondaryAddresses > 0)
	{
		// Allocate a buffer for the secondary address info.

		TemplateArray_AC<InetHost> secondaryAddressBuffer(numberOfSecondaryAddresses);

		// Ask OT for the list of secondary addresses on this interface.
		ThrowIfOSStatus(OTInetGetSecondaryAddresses(&secondaryAddressBuffer[0], &numberOfSecondaryAddresses, interfaceIndex));
		
		// Start a server for each secondary address.
		
		for (UInt32 addressIndex = 0; addressIndex < numberOfSecondaryAddresses; ++addressIndex)
		{
			RunOneServer(secondaryAddressBuffer[addressIndex]);
		}
	}
}

//----------------------------------------------------------------------------------------
// RunAllHTTPServers
//----------------------------------------------------------------------------------------

static void RunAllHTTPServers()
	// Run HTTP servers for all of the IP addresses on the machine.
	// This routine iterates through the active Internet interfaces, 
	// starting server threads for each active IP address on each
	// interface.
{
	// Force TCP to load by creating a dummy endpoint.  Otherwise,
	// if we're the first TCP application to run, OTInetGetInterfaceInfo
	// will not return any active interfaces )-:
	
	CTCPEndpoint dummyEP(NULL);
	dummyEP.Open();

	// Iterate through the interfaces, starting HTTP servers on each.
	
	SInt32 interfaceIndex = 0; 
	for (;;)
	{
		InetInterfaceInfo info;
		if (OTInetGetInterfaceInfo(&info, interfaceIndex) != noErr)
			break;

		RunServersForInterface(&info, interfaceIndex);
		++interfaceIndex;
	}
}

//----------------------------------------------------------------------------------------
// main
//----------------------------------------------------------------------------------------

void main()
	// The main line of the application.  This routine performs
	// two functions.  At startup, it initialises the network and
	// starts HTTP servers on all the active IP addresses on the machine.
	// After that it goes into a loop calling WaitNextEvent and
	// waiting for all the listener threads to terminate.  Events
	// are handled by sending them to SIOUX, except when the user
	// presses 'q' the routine sets the gQuitNow boolean to force
	// all the server threads to terminate.
{
	SIOUXSettings.asktosaveonclose = 0;

	printf("OTSimpleServerHTTP!\n");
	printf("-- World's dumbest HTTP server.\n");
	printf("-- Press 'q' to stop the server.\n");
	printf("\n");

	gQuitNow = false;
	
	try
	{
		InitSimpleHeap();

		CUsingOpenTransport openTransport(true);

		gHaveIPSingleLinkMultihoming = COpenTransport::OpenTransportVersion() >= kOTIPSingleLinkMultihomingVersion;
		gRunningThreads = 0;
		
		RunAllHTTPServers();
		
		while ( gRunningThreads != 0 )
		{
			if ( TickCount() > (gLastCallWNE + 3) )
			{
				EventRecord event;
				WaitNextEvent(everyEvent, &event, 0, nil);
				if (event.what == keyDown)
				{
					if ( (event.message & charCodeMask) == 'q' )
					{
						gQuitNow = true;
						CTCPEndpoint::CancelAll();
						printf("Setting gQuitNow.\n");
						fflush(stdout);
					}
				}
				SIOUXHandleOneEvent(&event);
				gLastCallWNE = TickCount();
			}
			OSStatus junk = YieldToAnyThread();
			Assertion_AC(junk == noErr, "main: YieldToAnyThread failed");
		}
		
		printf("Success.\n");
	}
	catch (CException_AC& fi)
	{
		printf("Failed with error %d.\n", fi.GetError());
	}

	printf("Done.  Press command-Q to Quit.\n");
}


//----------------------------------------------------------------------------------------
// End of DemoHTTPServer.cpp
