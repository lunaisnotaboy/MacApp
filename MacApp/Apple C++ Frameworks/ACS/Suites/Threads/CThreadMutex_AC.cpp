//----------------------------------------------------------------------------------------
// CThreadMutex_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		02/15/01	Need to include CTidyHeap_AC. 
		01/02/01	Update copyright.
		10/18/00	MrCpp: C++ function pointers are not compatible with C. 
		04/25/00	Include macros that were moved from CMPFailure_AC to
							MPCompatibility_AC. 
		03/09/00	Support unlocking from MP tasks. 
		02/15/00	Asserts. 
		02/03/00	Carbon: Fix includes. 
		01/28/00	Initial version. 
*/

#ifndef __CThreadMutex_AC__
#include "CThreadMutex_AC.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif

#ifndef __CThreadWaitList_AC__
#include "CThreadWaitList_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qWantsMP
	#ifndef __MPCompatibility_AC__
	#include "MPCompatibility_AC.h"
	#endif
#endif


//========================================================================================
// ThreadMutexRecord
//========================================================================================

typedef UInt32 ThreadMutexCount;

struct ThreadMutexRecord : public CThreadWaitList_AC
{
	enum { kInitialSize = 8 };

	ThreadMutexCount	fCount;

	ThreadMutexRecord();
	~ThreadMutexRecord()	{}

	bool Lock(Duration timeout);
	void Unlock();
};

typedef struct ThreadMutexRecord ThreadMutexRecord;

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

ThreadMutexRecord::ThreadMutexRecord()
	:	CThreadWaitList_AC(kInitialSize),
		fCount(0)
{
}

//----------------------------------------------------------------------------------------
// Lock
//----------------------------------------------------------------------------------------

bool ThreadMutexRecord::Lock(Duration timeout)
{
	OSStatus err = noErr;
	
	ThreadBeginCritical();

	ThreadID current = kNoThreadID;
	MacGetCurrentThread(&current);

	if (fDeleted)
	{
		// If the mutex is gone, don't use it
		err = kMPDeletedErr;
	}
	else if ((fCount == 0) || (fHolder == current))
	{
		// If no other thread currently holds the mutex, grab it
		// and increment its usage count. 
		fHolder = current;
		++fCount;
	}
	else if (timeout > 0)
	{
		// If another thread currently holds the mutex, the current thread 
		// is blocked until the mutex is released or until the designated 
		// timeout expires.
		err = CThreadWaitList_AC::Wait(timeout);
	}
	
	ThreadEndCritical();

	if (err != kMPTimeoutErr)
		ThrowIfOSErr_AC(err);

	return (err == noErr);
}

//----------------------------------------------------------------------------------------
// Unlock
//----------------------------------------------------------------------------------------

void ThreadMutexRecord::Unlock()
{
	if (fDeleted)
		ThrowError_AC(kMPDeletedErr);

	ThreadBeginCritical();
	
	// This function decrements the use count of the mutex. 
	// When the use count reaches zero, ownership of the mutex 
	// is released (which allows another thread to use the mutex).

	if (--fCount == 0)
	{
		// If threads are waiting on the mutex, the newest (last queued) thread is
		// unblocked and given ownership of the mutex. 

		if (GetSize() > 0)
		{
			fHolder = Pop();
			fCount = 1;
			SetThreadStateEndCritical(fHolder, kReadyThreadState, fHolder);
			return;
		}
	}

	ThreadEndCritical();
}


//========================================================================================
// CThreadMutex_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

void CThreadMutex_AC::Create()
{
	fIdentifier = TH_new ThreadMutexRecord();
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

void CThreadMutex_AC::Delete()
{
	if (fIdentifier)
	{
		delete fIdentifier;
		fIdentifier = NULL;
	}
}

//----------------------------------------------------------------------------------------
// Lock
//----------------------------------------------------------------------------------------

bool CThreadMutex_AC::Lock(Duration timeout)
{
	AssertNotNULL_AC(fIdentifier);
	return fIdentifier->Lock(timeout);
}

//----------------------------------------------------------------------------------------
// Unlock
//----------------------------------------------------------------------------------------

void CThreadMutex_AC::Unlock()
{
	AssertNotNULL_AC(fIdentifier);
	fIdentifier->Unlock();
}

#if qWantsMP
//----------------------------------------------------------------------------------------
// CThreadMutex_AC::UnlockMP
//----------------------------------------------------------------------------------------

#ifdef __MRC__
extern "C"
#endif
static void* RemoteUnlock(void* parameter)
{
	AssertNotNULL_AC(parameter);
	static_cast<ThreadMutexID>(parameter)->Unlock();
	return NULL;
}

void CThreadMutex_AC::UnlockMP()
{
	if (CurrentTaskIsPreemptive_AC())
	{
		MPFailIfNonObject_AC(fIdentifier);
		MPRemoteCall(RemoteUnlock, fIdentifier, kMPOwningProcessRemoteContext);
	}
	else
		Unlock();
}
#endif

//----------------------------------------------------------------------------------------
// End of CThreadMutex_AC.cpp