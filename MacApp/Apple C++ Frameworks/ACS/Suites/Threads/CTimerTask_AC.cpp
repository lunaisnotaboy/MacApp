//----------------------------------------------------------------------------------------
// CTimerTask_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		04/07/01	[PB] Unused variable 'OSErr err'. 
		01/02/01	No longer need to cast procptrs when creating UPPs. 
		01/02/01	Update copyright.
		12/06/00	Cast around new type safe interfaces that are incorrect for
							functions with register based parameters on classic 68K. 
		11/01/00	[PB] Include MacErrors instead of Errors. 
		10/20/00	Use NewTimerUPP instead of NewTimerProc.
		03/09/00	Add CSimpleTimer_AC. 
		02/03/00	Carbon: Fix includes. 
		02/02/00	Fixes to allow repeated cancellation and restarting. 
		01/27/00	Initial version. 
*/

#ifndef __CTimerTask_AC__
#include "CTimerTask_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __Configuration_AC__
#include "Configuration_AC.h"
#endif

// Toolbox

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif


//========================================================================================
// Global Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// TimeManagerVersion_AC
//----------------------------------------------------------------------------------------

long TimeManagerVersion_AC()
{
	static bool defined;
	static long version;
	if (!defined)
	{
		defined = true;
		OSErr err = Gestalt(gestaltTimeMgrVersion, &version);
#if qProjectBuilder
		(void) err;
#endif
	}
	return version;
}

//----------------------------------------------------------------------------------------
// HasExtendedTimeManager_AC
//----------------------------------------------------------------------------------------

bool HasExtendedTimeManager_AC()
{
	return TimeManagerVersion_AC() >= gestaltExtendedTimeMgr;
}


//========================================================================================
// CTimerTask_AC
//========================================================================================

TimerUPP CTimerTask_AC::fgTimerProc;

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CTimerTask_AC::CTimerTask_AC()
#if q68K
	:	fA5(SetCurrentA5())
#endif
{
	if (!HasExtendedTimeManager_AC())
		ThrowError_AC(kSysSWTooOld);	// Missing critical pieces of System Software.

	if (!fgTimerProc)
#ifdef CALLBACK_API_REGISTER68K
		fgTimerProc = NewTimerUPP(TimerProc);
#else
		fgTimerProc = NewTimerUPP(reinterpret_cast<TimerProcPtr>(TimerProc));
#endif

	qLink = 0;
	qType = 0;
	tmAddr = fgTimerProc;
	tmCount = 0;
	tmWakeUp = 0;
	tmReserved = 0;
}

//----------------------------------------------------------------------------------------
// TimerProc
//----------------------------------------------------------------------------------------

#if q68K
pascal TMTaskPtr GetTMTaskPtr() = {0x2E89};	/* move.l a1,(sp) */

pascal void CTimerTask_AC::TimerProc()
{
	CTimerTask_AC* tmTaskPtr = reinterpret_cast<CTimerTask_AC*>(GetTMTaskPtr());
	long oldA5 = SetA5(tmTaskPtr->fA5);
	tmTaskPtr->DoTimer();
	SetA5(oldA5);
}

#else

pascal void CTimerTask_AC::TimerProc(TMTaskPtr tmTaskPtr)
{
	reinterpret_cast<CTimerTask_AC*>(tmTaskPtr)->DoTimer();
}
#endif


//========================================================================================
// CSimpleTimer_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CSimpleTimer_AC::CSimpleTimer_AC(long count)
	:	CTimerTask_AC(),
		fFired(false)
{
	Install();

	if (count > 0)
		Prime(count);
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

CSimpleTimer_AC::~CSimpleTimer_AC()
{
}

//----------------------------------------------------------------------------------------
// DoTimer
//----------------------------------------------------------------------------------------

void CSimpleTimer_AC::DoTimer()
{
	fFired = true;
}


//----------------------------------------------------------------------------------------
// End of CTimerTask_AC.cpp
