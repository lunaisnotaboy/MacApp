//----------------------------------------------------------------------------------------
// CMPMutex_AC.cpp
// Copyright © 1996-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		09/22/00	Never call MPYield. 
		03/09/00	Allow other threads to run while we're waiting in a 
							cooperative context. 
		02/06/00	Don't use C++ exceptions in an MP task. 
		02/03/00	Carbon: Fix includes. 
		01/28/00	Initial version. 
*/

#ifndef __CMPMutex_AC__
#include "CMPMutex_AC.h"
#endif

#if qWantsMP

// ACS

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif

#ifndef __CTimerTask_AC__
#include "CTimerTask_AC.h"
#endif

// Toolbox

#ifndef __THREADS__
#include <Threads.h>
#endif


//========================================================================================
// CMPMutex_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

void CMPMutex_AC::Create()
{
	MPFailIfOSStatus_AC(MPCreateCriticalRegion(&fIdentifier));
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

void CMPMutex_AC::Delete()
{
	MPFailIfOSStatus_AC(MPDeleteCriticalRegion(fIdentifier));
	fIdentifier = NULL;
}

//----------------------------------------------------------------------------------------
// Lock
//----------------------------------------------------------------------------------------

bool CMPMutex_AC::Lock(Duration timeout)
{
	OSStatus err = kMPTimeoutErr;
	if ((timeout > 0) && !CurrentTaskIsPreemptive_AC())
	{
		// If we're not in a preemptive task, we need to allow other cooperative
		// threads to run while we're waiting. 
		CSimpleTimer_AC timer(timeout);
		do
		{
			err = MPEnterCriticalRegion(fIdentifier, 0);
			if (err != kMPTimeoutErr)
				break;

			YieldToAnyThread();
			//MPYield();
		}
		while (!timer.Fired());
	}
	else
		err = MPEnterCriticalRegion(fIdentifier, timeout);

	if (err != kMPTimeoutErr)
		MPFailIfOSStatus_AC(err);

	return (err == noErr);
}

//----------------------------------------------------------------------------------------
// Unlock
//----------------------------------------------------------------------------------------

void CMPMutex_AC::Unlock()
{
	MPFailIfOSStatus_AC(MPExitCriticalRegion(fIdentifier));
}


#endif // qWantsMP

//----------------------------------------------------------------------------------------
// End of CMPMutex_AC.cpp
