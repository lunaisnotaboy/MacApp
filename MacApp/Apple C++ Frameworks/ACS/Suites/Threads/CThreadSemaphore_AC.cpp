//----------------------------------------------------------------------------------------
// CThreadSemaphore_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		02/15/01	Need to include CTidyHeap_AC. 
		01/02/01	Update copyright.
		11/09/00	[PB] Change initialization order to match declaration. 
		10/18/00	MrCpp: C++ function pointers are not compatible with C. 
		08/08/00	[2510166] In ThreadSemaphoreRecord::Wait detect bad timeout value.
		04/25/00	Include macros that were moved from CMPFailure_AC to
							MPCompatibility_AC. 
		03/09/00	Support signalling from MP tasks. 
		03/06/00	Add CThreadCountedSemaphore and CTempThreadCountedSemaphore. 
		02/15/00	Asserts. 
		02/03/00	Carbon: Fix includes. 
		01/28/00	Initial version. 
*/

#ifndef __CThreadSemaphore_AC__
#include "CThreadSemaphore_AC.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif

#ifndef __CThreadWaitList_AC__
#include "CThreadWaitList_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qWantsMP
	#ifndef __MPCompatibility_AC__
	#include "MPCompatibility_AC.h"
	#endif
#endif

//========================================================================================
// ThreadSemaphoreRecord
//========================================================================================

struct ThreadSemaphoreRecord : public CThreadWaitList_AC
{
	enum { kInitialSize = 8 };

	ThreadSemaphoreCount	fValue;
	ThreadSemaphoreCount	fMaximum;

	ThreadSemaphoreRecord(ThreadSemaphoreCount maximumValue,
						  ThreadSemaphoreCount initialValue);
	~ThreadSemaphoreRecord()	{}

	bool Wait(Duration timeout);
	void Signal();
	void SignalOne();
	void SignalAll();
	
	ThreadSemaphoreCount GetCount() const	{ return fValue; }
};

typedef struct ThreadSemaphoreRecord ThreadSemaphoreRecord;

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

ThreadSemaphoreRecord::ThreadSemaphoreRecord(ThreadSemaphoreCount maximumValue,
											 ThreadSemaphoreCount initialValue)
	:	CThreadWaitList_AC(kInitialSize),
		fValue(initialValue),
		fMaximum(maximumValue)
{
	// Don't allow creating a useless semaphore. 
	Assertion_AC(fMaximum > 0, NULL);
}

//----------------------------------------------------------------------------------------
// Wait
//----------------------------------------------------------------------------------------

bool ThreadSemaphoreRecord::Wait(Duration timeout)
{
	OSStatus err = noErr;
	
	ThreadBeginCritical();

	if (fDeleted)
	{
		// If the semaphore is gone, don't use it
		err = kMPDeletedErr;
	}
	else if (fValue > 0)
	{
		// If the value of the semaphore is greater than zero, the value is decremented 
		// and the function returns with noErr. 
		--fValue;
	}
	else if (timeout > 0)
	{
		// Otherwise, the task is blocked awaiting a signal until the specified 
		// timeout is exceeded.
		err = CThreadWaitList_AC::Wait(timeout);
	}
	else
		err = kMPTimeoutErr;	// Bad timeout value provided.
	
	ThreadEndCritical();

	if (err != kMPTimeoutErr)
		ThrowIfOSErr_AC(err);

	return (err == noErr);
}

//----------------------------------------------------------------------------------------
// Signal
//----------------------------------------------------------------------------------------

void ThreadSemaphoreRecord::Signal()
{
	if (fDeleted)
		ThrowError_AC(kMPDeletedErr);

	ThreadBeginCritical();
	
	fHolder = PopFront();
	if (fHolder != kNoThreadID)
	{
		// If tasks are waiting on the semaphore, the oldest (first queued) task is
		// unblocked so that the corresponding Wait call for that task completes. 
		SetThreadStateEndCritical(fHolder, kReadyThreadState, fHolder);
	}
	else
	{
		// Otherwise, if the value of the semaphore is not already equal to its 
		// maximum value, it is incremented by one. 
		// The next Wait call will succeed immediately. 
		if (fValue < fMaximum)
			++fValue;

		ThreadEndCritical();
	}
}

//----------------------------------------------------------------------------------------
// SignalOne
//----------------------------------------------------------------------------------------

void ThreadSemaphoreRecord::SignalOne()
{
	if (fValue > 0)
		Signal();
}

//----------------------------------------------------------------------------------------
// SignalAll
//----------------------------------------------------------------------------------------

void ThreadSemaphoreRecord::SignalAll()
{
	while (fValue > 0)
		Signal();
}


//========================================================================================
// CThreadSemaphore_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CThreadSemaphore_AC::CThreadSemaphore_AC(ThreadSemaphoreCount maximumValue, ThreadSemaphoreCount initialValue)
	:	fIdentifier(NULL)
{
	Create(maximumValue, initialValue);
}

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

void CThreadSemaphore_AC::Create(ThreadSemaphoreCount maximumValue, ThreadSemaphoreCount initialValue)
{
	fIdentifier = TH_new ThreadSemaphoreRecord(maximumValue, initialValue);
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

void CThreadSemaphore_AC::Delete()
{
	if (fIdentifier)
	{
		delete fIdentifier;
		fIdentifier = NULL;
	}
}

//----------------------------------------------------------------------------------------
// Wait
//----------------------------------------------------------------------------------------

bool CThreadSemaphore_AC::Wait(Duration timeout)
{
	AssertNotNULL_AC(fIdentifier);
	return fIdentifier->Wait(timeout);
}

//----------------------------------------------------------------------------------------
// Signal
//----------------------------------------------------------------------------------------

void CThreadSemaphore_AC::Signal()
{
	AssertNotNULL_AC(fIdentifier);
	fIdentifier->Signal();
}

#if qWantsMP
//----------------------------------------------------------------------------------------
// SignalMP
//----------------------------------------------------------------------------------------

#ifdef __MRC__
extern "C"
#endif
static void* RemoteSignal(void* parameter)
{
	static_cast<ThreadSemaphoreID>(parameter)->Signal();
	return NULL;
}

void CThreadSemaphore_AC::SignalMP()
{
	if (CurrentTaskIsPreemptive_AC())
	{
		MPFailIfNonObject_AC(fIdentifier);
		MPRemoteCall(RemoteSignal, fIdentifier, kMPOwningProcessRemoteContext);
	}
	else
		Signal();
}

#endif // qWantsMP


//========================================================================================
// CThreadCountedSemaphore_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Default Constructor
//----------------------------------------------------------------------------------------

CThreadCountedSemaphore_AC::CThreadCountedSemaphore_AC()
	:	CThreadSemaphore_AC()
{
}

//----------------------------------------------------------------------------------------
// Construct and Create
//----------------------------------------------------------------------------------------

CThreadCountedSemaphore_AC::CThreadCountedSemaphore_AC(ThreadSemaphoreCount maximumValue, ThreadSemaphoreCount initialValue)
	:	CThreadSemaphore_AC(maximumValue, initialValue)
{
}

//----------------------------------------------------------------------------------------
// Copy Constructor
//----------------------------------------------------------------------------------------

CThreadCountedSemaphore_AC::CThreadCountedSemaphore_AC(const CThreadCountedSemaphore_AC& from)
	:	CThreadSemaphore_AC()
{
	fIdentifier = from.fIdentifier;
}

//----------------------------------------------------------------------------------------
// SignalOne
//----------------------------------------------------------------------------------------

void CThreadCountedSemaphore_AC::SignalOne()
{
	AssertNotNULL_AC(fIdentifier);
	fIdentifier->SignalOne();
}

//----------------------------------------------------------------------------------------
// SignalAll
//----------------------------------------------------------------------------------------

void CThreadCountedSemaphore_AC::SignalAll()
{
	AssertNotNULL_AC(fIdentifier);
	fIdentifier->SignalAll();
}

#if qWantsMP
//----------------------------------------------------------------------------------------
// SignalOneMP
//----------------------------------------------------------------------------------------

#ifdef __MRC__
extern "C"
#endif
static void* RemoteSignalOne(void* parameter)
{
	static_cast<ThreadSemaphoreID>(parameter)->SignalOne();
	return NULL;
}

void CThreadCountedSemaphore_AC::SignalOneMP()
{
	if (CurrentTaskIsPreemptive_AC())
	{
		MPFailIfNonObject_AC(fIdentifier);
		MPRemoteCall(RemoteSignalOne, fIdentifier, kMPOwningProcessRemoteContext);
	}
	else
		SignalOne();
}

//----------------------------------------------------------------------------------------
// SignalAllMP
//----------------------------------------------------------------------------------------

#ifdef __MRC__
extern "C"
#endif
static void* RemoteSignalAll(void* parameter)
{
	static_cast<ThreadSemaphoreID>(parameter)->SignalAll();
	return NULL;
}

void CThreadCountedSemaphore_AC::SignalAllMP()
{
	if (CurrentTaskIsPreemptive_AC())
	{
		MPFailIfNonObject_AC(fIdentifier);
		MPRemoteCall(RemoteSignalAll, fIdentifier, kMPOwningProcessRemoteContext);
	}
	else
		SignalAll();
}

#endif // qWantsMP

//----------------------------------------------------------------------------------------
// GetCount
//----------------------------------------------------------------------------------------

ThreadSemaphoreCount CThreadCountedSemaphore_AC::GetCount() const
{
	return fIdentifier ? fIdentifier->GetCount() : 0;
}

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

CThreadCountedSemaphore_AC& CThreadCountedSemaphore_AC::operator=(const CThreadCountedSemaphore_AC& rhs)
{
	fIdentifier = rhs.fIdentifier;

	return *this;
}


//========================================================================================
// CTempThreadCountedSemaphore_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Copy Constructor
//----------------------------------------------------------------------------------------

CTempThreadCountedSemaphore_AC::CTempThreadCountedSemaphore_AC(CThreadCountedSemaphore_AC& from)
	:	CThreadCountedSemaphore_AC()
{
	fIdentifier = from.release();
}

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

CTempThreadCountedSemaphore_AC& CTempThreadCountedSemaphore_AC::operator=(CThreadCountedSemaphore_AC& rhs)
{
	fIdentifier = rhs.release();

	return *this;
}


//----------------------------------------------------------------------------------------
// End of CThreadSemaphore_AC.cpp
