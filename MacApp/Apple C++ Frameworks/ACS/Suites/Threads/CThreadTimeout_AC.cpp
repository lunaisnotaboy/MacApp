//----------------------------------------------------------------------------------------
// CThreadTimeout_AC.cpp
// Copyright © 1993-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		04/07/01	[PB] Unused variable 'OSErr err'. 
		02/28/01	[W] Use DEFINE_API instead of pascal for thread terminator. 
		01/02/01	Update copyright.
		09/20/00	Use MacGetCurrentThread instead of GetCurrentThread and
					add global scope.
		03/09/00	Add CSimpleTimer_AC. 
		02/03/00	Carbon: Fix includes. Need UPP for thread terminator. 
		01/26/00	Ported to ACS from ThreadUtil. 
*/

#ifndef __CThreadTimeout_AC__
#include "CThreadTimeout_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

// Toolbox

#ifndef __MULTIPROCESSING__
#include <Multiprocessing.h>
#endif

#ifndef MP_API_Version
enum {
	kDurationImmediate			= 0L,
	kDurationForever			= 0x7FFFFFFF
};
#endif


//========================================================================================
// CThreadTimeout_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CThreadTimeout_AC::CThreadTimeout_AC(long count)
	:	CSimpleTimer_AC(),
		fAppTask(NULL),
		fThread(kNoThreadID)
{
	ThrowIfOSErr_AC(::GetThreadCurrentTaskRef(&fAppTask));

	ThrowIfOSErr_AC(::MacGetCurrentThread(&fThread));

#if qCarbon
	static ThreadTerminationTPP threadTerminator;
	if (!threadTerminator)
		threadTerminator = NewThreadTerminationUPP(SleepTerminator);

	OSErr err = ::SetThreadTerminator(kCurrentThreadID, threadTerminator, this);
#else
	OSErr err = ::SetThreadTerminator(kCurrentThreadID, SleepTerminator, this);
#endif
#if qProjectBuilder
	(void) err;
#endif

	Install();

	if ((count > 0) && (count < kDurationForever))
		Prime(count);
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

CThreadTimeout_AC::~CThreadTimeout_AC()
{
	// We are now awake, so lets blow this joint
	OSErr err = ::SetThreadTerminator(kCurrentThreadID, nil, nil);
#if qProjectBuilder
	(void) err;
#endif
	Remove();
}

//----------------------------------------------------------------------------------------
// DoTimer
//----------------------------------------------------------------------------------------

void CThreadTimeout_AC::DoTimer()
{
	fFired = true;

	// See if the thread is stopped yet
	ThreadState theThreadState = 0;
	::GetThreadStateGivenTaskRef(fAppTask, fThread, &theThreadState);
	if (theThreadState == kStoppedThreadState)
	{
		// if it is sleeping, mark it for wake up!
		::SetThreadReadyGivenTaskRef(fAppTask, fThread);
	}
}

//----------------------------------------------------------------------------------------
// SleepTerminator
//----------------------------------------------------------------------------------------

DEFINE_API(void) CThreadTimeout_AC::SleepTerminator(ThreadID threadTerminated, void* terminationProcParam)
// This is the terminator task, it is called if the thread we put to sleep
// never wakes up before the thread is terminated.  This removes the time
// manager task from the queue.
{
#pragma unused (threadTerminated)

	static_cast<CThreadTimeout_AC*>(terminationProcParam)->Remove();
}

//========================================================================================
// Global Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// DelayThread
//----------------------------------------------------------------------------------------

pascal void DelayThread(unsigned long millisecDelay)
// This function sets up a time manager task to wake up the sleeping thread after a 
// certain number of milliseconds. It puts the thread to sleep and says to schedule 
// anyone next.
// SIDE EFFECTS:  Destroys any Thread Terminator task that existed for the thread.
{
	if (millisecDelay > 0)
	{
		::ThreadBeginCritical();

		CThreadTimeout_AC myTask(millisecDelay);

		// Hopefully our timer does not fire before we can sleep...
		// ...but if it does, the TM task will re-prime and try again
		ThreadState nextState = myTask.Fired() ? kReadyThreadState : kStoppedThreadState;
		::SetThreadStateEndCritical(kCurrentThreadID, nextState, kNoThreadID);
	}
}


//----------------------------------------------------------------------------------------
// End of CThreadTimeout_AC.cpp
