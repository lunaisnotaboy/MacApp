//----------------------------------------------------------------------------------------
// CThreadQueue_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		02/15/01	Need to include CTidyHeap_AC. 
		02/14/01	Use an STL queue for the notification queue. 
		01/02/01	Update copyright.
		10/18/00	MrCpp: C++ function pointers are not compatible with C. 
		04/25/00	Include macros that were moved from CMPFailure_AC to
							MPCompatibility_AC. 
		03/09/00	Support notifying from MP tasks. 
		02/15/00	Asserts. 
		02/03/00	Carbon: Fix includes. 
		01/31/00	Initial version. 
*/

#ifndef __CThreadQueue_AC__
#include "CThreadQueue_AC.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif

#ifndef __CThreadWaitList_AC__
#include "CThreadWaitList_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qWantsMP
	#ifndef __MPCompatibility_AC__
	#include "MPCompatibility_AC.h"
	#endif
#endif

// ANSI

#ifndef _QUEUE
#include <queue>
#endif

//========================================================================================
// CThreadNotificationQueue
//========================================================================================

typedef std::queue<CThreadNotification_AC> CThreadNotificationQueue;


//========================================================================================
// ThreadQueueRecord
//========================================================================================

struct ThreadQueueRecord : public CThreadWaitList_AC
{
	enum { kInitialSize = 8 };

	CThreadNotificationQueue	fQueue;

	ThreadQueueRecord();
	~ThreadQueueRecord()	{}

	bool Lock(Duration timeout);
	void Unlock();

	bool Wait(CThreadNotification_AC& message, Duration timeout);
	void Notify(const CThreadNotification_AC& message);
};

typedef struct ThreadQueueRecord ThreadQueueRecord;

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

ThreadQueueRecord::ThreadQueueRecord()
	:	CThreadWaitList_AC(kInitialSize),
		fQueue()
{
}

//----------------------------------------------------------------------------------------
// Wait
//----------------------------------------------------------------------------------------

bool ThreadQueueRecord::Wait(CThreadNotification_AC& message, Duration timeout)
{
	OSStatus err = noErr;
	
	ThreadBeginCritical();

	ThreadID current = kNoThreadID;
	MacGetCurrentThread(&current);

	if (fDeleted)
	{
		// If the mutex is gone, don't use it
		err = kMPDeletedErr;
	}
	else
	{
		if (!fQueue.size() && (timeout > 0))
		{
			// If the queue is empty, the current thread is blocked 
			// until the queue is notified or until the designated 
			// timeout expires.
			err = CThreadWaitList_AC::Wait(timeout);
		}
		
		if (!err)
		{
			// If we get here without an error, we can grab the next notification. 
			message = fQueue.front();
			fQueue.pop();
		}
	}

	ThreadEndCritical();

	if (err != kMPTimeoutErr)
		ThrowIfOSErr_AC(err);

	return (err == noErr);
}

//----------------------------------------------------------------------------------------
// Notify
//----------------------------------------------------------------------------------------

void ThreadQueueRecord::Notify(const CThreadNotification_AC& message)
{
	if (fDeleted)
		ThrowError_AC(kMPDeletedErr);

	ThreadBeginCritical();
	
	fQueue.push(message);

	// If threads are waiting on the queue, the newest (last queued) thread is
	// unblocked. 
	if (GetSize() > 0)
	{
		fHolder = Pop();
		SetThreadStateEndCritical(fHolder, kReadyThreadState, fHolder);
		return;
	}

	ThreadEndCritical();
}


//========================================================================================
// CThreadQueue_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

void CThreadQueue_AC::Create()
{
	fIdentifier = TH_new ThreadQueueRecord();
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

void CThreadQueue_AC::Delete()
{
	if (fIdentifier)
	{
		delete fIdentifier;
		fIdentifier = NULL;
	}
}

//----------------------------------------------------------------------------------------
// Wait
//----------------------------------------------------------------------------------------

bool CThreadQueue_AC::Wait(CThreadNotification_AC& message, Duration timeout)
{
	AssertNotNULL_AC(fIdentifier);
	return fIdentifier->Wait(message, timeout);
}

bool CThreadQueue_AC::Wait(void** param1, void** param2, void** param3, Duration timeout)
{
	AssertNotNULL_AC(fIdentifier);
	CThreadNotification_AC message;
	bool okay = fIdentifier->Wait(message, timeout);
	if (okay)
		message.Unpack(param1, param2, param3);

	return okay;
}

//----------------------------------------------------------------------------------------
// Notify
//----------------------------------------------------------------------------------------

void CThreadQueue_AC::Notify(const CThreadNotification_AC& message)
{
	AssertNotNULL_AC(fIdentifier);
	fIdentifier->Notify(message);
}

void CThreadQueue_AC::Notify(void* param1, void* param2, void* param3)
{
	AssertNotNULL_AC(fIdentifier);
	fIdentifier->Notify(CThreadNotification_AC(param1, param2, param3));
}

#if qWantsMP
//----------------------------------------------------------------------------------------
// NotifyMP
//----------------------------------------------------------------------------------------

class CRemoteNotify
{
public:
	CRemoteNotify(ThreadQueueID queue, const CThreadNotification_AC& message);
	~CRemoteNotify() {}

	void Notify()
	{
		fIdentifier->Notify(fMessage);
	}

protected:
	ThreadQueueID			fIdentifier;
	CThreadNotification_AC	fMessage;
};

#ifdef __MRC__
extern "C"
#endif
static void* RemoteNotify(void* parameter)
{
	static_cast<CRemoteNotify*>(parameter)->Notify();
	return NULL;
}

CRemoteNotify::CRemoteNotify(ThreadQueueID queue, const CThreadNotification_AC& message)
	:	fIdentifier(queue),
		fMessage(message)
{
	MPRemoteCall(RemoteNotify, this, kMPOwningProcessRemoteContext);
}

void CThreadQueue_AC::NotifyMP(const CThreadNotification_AC& message)
{
	if (CurrentTaskIsPreemptive_AC())
	{
		MPFailIfNonObject_AC(fIdentifier);
		CRemoteNotify(fIdentifier, message);
	}
	else
		Notify(message);
}

void CThreadQueue_AC::NotifyMP(void* param1, void* param2, void* param3)
{
	NotifyMP(CThreadNotification_AC(param1, param2, param3));
}

#endif // qWantsMP


//----------------------------------------------------------------------------------------
// End of CThreadQueue_AC.cpp
