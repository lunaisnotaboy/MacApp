//----------------------------------------------------------------------------------------
// CThreadYielder_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		02/15/00	Include Events.h.  Scope TickCount.  Call EventAvail instead
					of OSEventAvail.
		02/06/00	Ported from CyberDog to ACS. 
					Change to use exceptions. Split off generic yielder base
					class. Split off YieldIfEvent from YieldIfTime. 
					Change YieldNow to advance by fNumTicks instead of just 1. 
*/

#ifndef __CThreadYielder_AC__
#include "CThreadYielder_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

// Toolbox

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __THREADS__
#include <Threads.h>
#endif

//========================================================================================
// CThreadYielder_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CThreadYielder_AC destructor
//----------------------------------------------------------------------------------------

CThreadYielder_AC::~CThreadYielder_AC()
{
}

//----------------------------------------------------------------------------------------
// CThreadYielder_AC::YieldIfTime
//----------------------------------------------------------------------------------------

bool CThreadYielder_AC::YieldIfTime()
{
	bool yielded = YieldIfEvent();
	if (!yielded)
	{
		yielded = ::TickCount() > fNextYieldTime;
		if (yielded)
			YieldNow();
	}
	return yielded;
}

//----------------------------------------------------------------------------------------
// CThreadYielder_AC::YieldIfEvent
//----------------------------------------------------------------------------------------

bool CThreadYielder_AC::YieldIfEvent()
{
	short eventMask = mDownMask + keyDownMask + autoKeyMask;
	EventRecord event;
	bool yielded = ::EventAvail(eventMask, &event);
	if (yielded)
	{
		ThrowIfOSErr_AC(YieldToThread(kApplicationThreadID));
		fNextYieldTime = (unsigned long)::TickCount() + fNumTicks;
	}

	return yielded;
}

//----------------------------------------------------------------------------------------
// CThreadYielder_AC::YieldNow
//----------------------------------------------------------------------------------------

void CThreadYielder_AC::YieldNow()
{
	fNextYieldTime = (unsigned long)::TickCount() + fNumTicks;
	ThrowIfOSErr_AC(YieldToAnyThread());
}

//----------------------------------------------------------------------------------------
// End of CThreadYielder_AC.cpp
