//----------------------------------------------------------------------------------------
// CMPFailure_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		08/14/01	Scope stdio definitions because cstdio is getting included first. 
		04/07/01	[PB] Comparison between signed and unsigned. 
							Taking address of temporary. 
		01/02/01	Update copyright.
		10/18/00	MrCpp: C++ function pointers are not compatible with C. 
		05/23/00	[2279264] Rename buffer-oriented calls to ProgramBreakText
							and ProgramReportText so as to eliminate all possible ambiguity. 
		05/15/00	CW Pro 6: ambiguous ProgramBreak and ProgramReport overloads. 
							Switch the order of the arguments for the buffer-oriented calls. 
							Namespacing. 
		04/25/00	Rename MultiprocessingSupport_AC to MPCompatibility_AC. 
							Include in implementation not header. 
		04/19/00	Move the MP inlines into MultiprocessingSupport_AC.h to be shared by all.
		03/23/00	static_cast not required in DebugMPFailIfOSStatus_AC.  Use reinterpret_cast
							instead of static_cast in RemoteDebugString_AC.  DebugThrowError_AC not
							available except when qDebugExceptions.
		03/10/00	Include CodeFragments. 
		03/09/00	Add CurrentTaskIsPreemptive_AC, FailIfPreemptive_AC and
							AssertNotPreemptive_AC. Add MPFailIfNonObject_AC. 
		02/15/00	Include CException_AC.h, Utils_AC.h and cstring.
		02/15/00	Add varargs version of MPProgramBreak_AC. 
		02/14/00	Add backwards compatibility glue so we can still build with
							the MP APIs 1.4 / Universal Interfaces 3.2. 
		02/14/00	Add MPProgramBreak_AC and debug version of MPFailIfOSStatus_AC. 
							Have MPFailIfOSStatus_AC throw a C++ exception if it can. 
		02/06/00	Initial version. 
*/

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif

#if qWantsMP

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __MPCompatibility_AC__
#include "MPCompatibility_AC.h"
#endif

#ifndef __ThreadUtilities_AC__
#include "ThreadUtilities_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

// Toolbox

#ifndef __CODEFRAGMENTS__
#include <CodeFragments.h>
#endif

// ANSI

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef __cstring__
#include <cstring>
#endif

using std::strlen;
using std::vsprintf;

//========================================================================================
// Global Functions
//========================================================================================

#if qDebug

//----------------------------------------------------------------------------------------
// DebugMPFailIfOSStatus_AC
//----------------------------------------------------------------------------------------

void DebugMPFailIfOSStatus_AC(OSStatus status, const char* inFile, short inLine)
{
	if (status != noErr)
	{
		MPTaskID current = MPCurrentTaskID();
#if qDebugExceptions
		if (!MPTaskIsPreemptive(current))
		{
			// It's safe to throw from the main task. 
			DebugThrowError_AC(status, inFile, inLine);
		}
		else
#endif
		{
			// Do what we can. 
			MPProgramBreak_AC("File %s, Line %d, Task 0x%0x failing; Error #%ld", 
							  inFile, inLine, current, status);
			MPTerminateTask(current, status);
		}
	}
}

#else

//----------------------------------------------------------------------------------------
// MPFailIfOSStatus_AC
//----------------------------------------------------------------------------------------

void MPFailIfOSStatus_AC(OSStatus status)
{
	if (status != noErr)
	{
		MPTaskID current = MPCurrentTaskID();
		if (!MPTaskIsPreemptive(current))
		{
			// It's safe to throw from the main task. 
			ThrowError_AC(static_cast<OSErr>(status));
		}
		else
		{
			// Do what we can. 
			MPTerminateTask(current, status);
		}
	}
}

#endif // qDebug

#if qDebug

//----------------------------------------------------------------------------------------
// DebugMPFailIfNonObject_AC
//----------------------------------------------------------------------------------------

void DebugMPFailIfNonObject_AC(const void* obj, const char* inFile, short inLine)
{
	if (!obj || Odd_AC(obj))
	{
#if qCoreDebug
		MPProgramBreak_AC("Object that failed discipline: %p", obj);
#endif
		DebugMPFailIfOSStatus_AC(minErr, inFile, inLine);
	}
}

#else

//----------------------------------------------------------------------------------------
// MPFailIfNonObject_AC
//----------------------------------------------------------------------------------------

void MPFailIfNonObject_AC(const void* obj)
{
	if (!obj || Odd_AC(obj))
	{
		MPFailIfOSStatus_AC(minErr);
	}
}

#endif // qDebug

//----------------------------------------------------------------------------------------
// MPProgramBreak_AC
//----------------------------------------------------------------------------------------

#ifdef __MRC__
extern "C" // void* RemoteDebugString_AC(void* parameter);
#endif
static void* RemoteDebugString_AC(void* parameter)
{
	ProgramBreak_AC(reinterpret_cast<ConstStr255Param>(parameter));
	return NULL;
}

void MPProgramBreak_AC(ConstStr255Param msg)
{
	if (!CurrentTaskIsPreemptive_AC())
	{
		// It's safe to report from the main task. 
		ProgramBreak_AC(msg);
	}
	else
#if MPIncludeDefunctServices && (!qCarbon || CALL_NOT_IN_CARBON)
	if ((UInt32)_MPDebugStr != (UInt32)kUnresolvedCFragSymbolAddress)
		_MPDebugStr(msg);
	else
#endif
	if ((UInt32)MPRemoteCall != (UInt32)kUnresolvedCFragSymbolAddress)
		MPRemoteCall(RemoteDebugString_AC, const_cast<unsigned char*>(msg), kMPOwningProcessRemoteContext);
}

//----------------------------------------------------------------------------------------
// MPProgramBreak_AC
//----------------------------------------------------------------------------------------

void MPProgramBreak_AC(const char* format, ...)
{
	va_list args;
	va_start(args, format);
	MPProgramBreak_AC(format, args);
}

//----------------------------------------------------------------------------------------
// MPProgramBreak_AC
//----------------------------------------------------------------------------------------

struct PrintFParams
{
	const char* format;
	va_list args;

	PrintFParams(const char* inFormat, va_list inArgs) : format(inFormat), args(inArgs) {}

	void* PrintF();
};
typedef struct PrintFParams PrintFParams;

#ifdef __MRC__
extern "C"
#endif
static void* RemotePrintF(void* parameter)
{
	return static_cast<PrintFParams*>(parameter)->PrintF();
}

void* PrintFParams::PrintF()
{
	char buffer[256];
	int len = vsprintf(buffer, format, args);
	ProgramBreakText_AC(len, buffer);
	return NULL;
}

void MPProgramBreak_AC(const char* format, va_list args)
{
	if (!CurrentTaskIsPreemptive_AC())
	{
		// It's safe to report from the main task. 
		PrintFParams params(format, args);
		RemotePrintF(&params);
	}
	else if ((UInt32)MPRemoteCall != (UInt32)kUnresolvedCFragSymbolAddress)
	{
		PrintFParams params(format, args);
		MPRemoteCall(RemotePrintF, &params, kMPOwningProcessRemoteContext);
	}
	else
	{
		// Don't have MPRemoteCall. Try outputting the message without formatting. 
		Str255 msg;
		short len = Min_AC(strlen(format), static_cast<size_t>(255));
		MPBlockCopy(const_cast<char*>(format), &msg[1], len);
		msg[0] = len;
		MPProgramBreak_AC(msg);
	}
}


//----------------------------------------------------------------------------------------
// CurrentTaskIsPreemptive_AC
//----------------------------------------------------------------------------------------

bool CurrentTaskIsPreemptive_AC()
{
	bool preemptive = false;
	if (::HasMP_AC())
	{
		MPTaskID currentTask = MPCurrentTaskID();
		preemptive = MPTaskIsPreemptive(currentTask);
	}
	return preemptive;
}

//----------------------------------------------------------------------------------------
// FailIfPreemptive_AC
//----------------------------------------------------------------------------------------

void FailIfPreemptive_AC()
{
	if (CurrentTaskIsPreemptive_AC())
	{
#if qDebugMsg
		MPProgramBreak_AC("\pFailIfPreemptive_AC called from preemptive MP task");
#endif
		MPFailIfOSStatus_AC(minErr);
	}
}

#endif // qWantsMP

//----------------------------------------------------------------------------------------
// End of CMPFailure_AC.cpp
