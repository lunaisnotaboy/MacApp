//----------------------------------------------------------------------------------------
// CMPSemaphore_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		09/22/00	Never call MPYield. 
		03/09/00	Allow other threads to run while we're waiting in a 
							cooperative context. 
		03/06/00	Add CMPCountedSemaphore and CTempMPCountedSemaphore. 
		02/06/00	Don't use C++ exceptions in an MP task. 
		02/03/00	Carbon: Fix includes. 
		01/26/00	Initial version. 
*/

#ifndef __CMPSemaphore_AC__
#include "CMPSemaphore_AC.h"
#endif

#if qWantsMP

// ACS

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif

#ifndef __CTimerTask_AC__
#include "CTimerTask_AC.h"
#endif

// Toolbox

#ifndef __THREADS__
#include <Threads.h>
#endif


//========================================================================================
// CMPSemaphore_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CMPSemaphore_AC::CMPSemaphore_AC(MPSemaphoreCount maximumValue, MPSemaphoreCount initialValue)
	:	fIdentifier(NULL)
{
	Create(maximumValue, initialValue);
}

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

void CMPSemaphore_AC::Create(MPSemaphoreCount maximumValue, MPSemaphoreCount initialValue)
{
	MPFailIfOSStatus_AC(MPCreateSemaphore(maximumValue, initialValue, &fIdentifier));
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

void CMPSemaphore_AC::Delete()
{
	if (fIdentifier)
	{
		MPFailIfOSStatus_AC(MPDeleteSemaphore(fIdentifier));
		fIdentifier = NULL;
	}
}

//----------------------------------------------------------------------------------------
// Wait
//----------------------------------------------------------------------------------------

bool CMPSemaphore_AC::Wait(Duration timeout)
{
	OSStatus err = kMPTimeoutErr;
	if ((timeout > 0) && !CurrentTaskIsPreemptive_AC())
	{
		// If we're not in a preemptive task, we need to allow other cooperative
		// threads to run while we're waiting. 
		CSimpleTimer_AC timer(timeout);
		do
		{
			err = MPWaitOnSemaphore(fIdentifier, 0);
			if (err != kMPTimeoutErr)
				break;

			YieldToAnyThread();
			//MPYield();
		}
		while (!timer.Fired());
	}
	else
		err = MPWaitOnSemaphore(fIdentifier, timeout);

	if (err != kMPTimeoutErr)
		MPFailIfOSStatus_AC(err);

	return (err == noErr);
}

//----------------------------------------------------------------------------------------
// Signal
//----------------------------------------------------------------------------------------

void CMPSemaphore_AC::Signal()
{
	MPFailIfOSStatus_AC(MPSignalSemaphore(fIdentifier));
}


//========================================================================================
// CMPCountedSemaphore_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Default Constructor
//----------------------------------------------------------------------------------------

CMPCountedSemaphore_AC::CMPCountedSemaphore_AC()
	:	CMPSemaphore_AC(),
		fCountLock(),
		fCount(0)
{
}

//----------------------------------------------------------------------------------------
// Construct and Create
//----------------------------------------------------------------------------------------

CMPCountedSemaphore_AC::CMPCountedSemaphore_AC(MPSemaphoreCount maximumValue, MPSemaphoreCount initialValue)
	:	CMPSemaphore_AC(maximumValue, initialValue),
		fCountLock(CTempMPMutex_AC::kCreate),
		fCount(0)
{
}

//----------------------------------------------------------------------------------------
// Copy Constructor
//----------------------------------------------------------------------------------------

CMPCountedSemaphore_AC::CMPCountedSemaphore_AC(const CMPCountedSemaphore_AC& from)
	:	CMPSemaphore_AC(),
		fCountLock(CTempMPMutex_AC::kCreate),
		fCount(0)
{
	CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
	fIdentifier = from.fIdentifier;
	fCount = from.fCount;
}

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

void CMPCountedSemaphore_AC::Create(MPSemaphoreCount maximumValue, MPSemaphoreCount initialValue)
{
	if (!fCountLock)
		fCountLock.Create();

	CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
	fCount = 0;
	CMPSemaphore_AC::Create(maximumValue, initialValue);
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

void CMPCountedSemaphore_AC::Delete()
{
	{
		CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
		fCount = 0;
	}

	CMPSemaphore_AC::Delete();
}

//----------------------------------------------------------------------------------------
// Wait
//----------------------------------------------------------------------------------------

bool CMPCountedSemaphore_AC::Wait(Duration timeout)
{
	{
		CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
		++fCount;
	}
	return CMPSemaphore_AC::Wait(timeout);
}

//----------------------------------------------------------------------------------------
// Signal
//----------------------------------------------------------------------------------------

void CMPCountedSemaphore_AC::Signal()
{
	{
		CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
		--fCount;
	}
	CMPSemaphore_AC::Signal();
}

//----------------------------------------------------------------------------------------
// SignalOne
//----------------------------------------------------------------------------------------

void CMPCountedSemaphore_AC::SignalOne()
{
	CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
	if (fCount > 0)
	{
		--fCount;
		CMPSemaphore_AC::Signal();
	}
}

//----------------------------------------------------------------------------------------
// SignalAll
//----------------------------------------------------------------------------------------

void CMPCountedSemaphore_AC::SignalAll()
{
	CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
	while (fCount > 0)
	{
		--fCount;
		CMPSemaphore_AC::Signal();
	}
}

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

CMPCountedSemaphore_AC& CMPCountedSemaphore_AC::operator=(const CMPCountedSemaphore_AC& rhs)
{
	if (!fCountLock)
		fCountLock.Create();

	CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
	fIdentifier = rhs.fIdentifier;
	fCount = rhs.fCount;

	return *this;
}


//========================================================================================
// CTempMPCountedSemaphore_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Copy Constructor
//----------------------------------------------------------------------------------------

CTempMPCountedSemaphore_AC::CTempMPCountedSemaphore_AC(CMPCountedSemaphore_AC& from)
	:	CMPCountedSemaphore_AC()
{
	if (!fCountLock)
		fCountLock.Create();

	CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
	fCount = from.GetCount();
	fIdentifier = from.release();
}

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

CTempMPCountedSemaphore_AC& CTempMPCountedSemaphore_AC::operator=(CMPCountedSemaphore_AC& rhs)
{
	if (!fCountLock)
		fCountLock.Create();

	CTempMPMutex_AC::CWhileSynchronized entry(fCountLock);
	fCount = rhs.GetCount();
	fIdentifier = rhs.release();

	return *this;
}


#endif // qWantsMP

//----------------------------------------------------------------------------------------
// End of CMPSemaphore_AC.cpp
