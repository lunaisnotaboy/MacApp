//----------------------------------------------------------------------------------------
// CMPThread_AC.cpp
// Copyright © 1996-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		10/18/00	MrCpp: C++ function pointers are not compatible with C. 
		09/22/00	Never call MPYield. 
		04/26/00	Compatibility fixes to build with the 3.2 headers. 
		04/14/00	Use a thread handle in the thread proc so the thread will be
					deleted if nothing else references it when it finishes. 
					Delete the thread object only in a safe context. 
					Don't post an exception if the thread already has one. 
		03/10/00	Include Errors. 
		02/15/00	Add ProgramBreak and FailIf functions. 
		02/14/00	Move code for suspending at start out of the Run method. 
					Developer shouldn't have to call inherited::Run. 
		02/08/00	Post any exceptions that we can catch from the thread. 
					Set the thread's done flag even if it had an exception. 
		02/07/00	Merge context completely into thread. 
		02/04/00	Okay if thread is NULL. 
		02/03/00	Carbon: Fix includes. 
		02/01/00	New implementation. 
		12/08/99	Include CYieldThread_AC.h.  Added ~CMainMPThreadContext_AC.  Use
					MPTaskIDMap instead of CMPThreadContext_AC*.  fMainContext is 
					now a CMainMPThreadContext_AC.  Reworked GetCurrentMPContext.
		05/19/99	Remove StartRoutine and parameter from CreateThreadContext. 
					Make IsAlive, GetRefCount and GetThread const. 
					Move fDone flag to CAbstractThreadContext. 
		05/16/99	Fix wrapper procs to hold the context. 
					Don't create a context in Get. 
		03/24/99	Update copyright notice.
		11/12/98	[2279223] Include <map> instead of <map.h>.
		10/06/98	Clean up includes. 
*/

#ifndef __CMPThread_AC__
#include "CMPThread_AC.h"
#endif

#if qWantsMP

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif

#ifndef __CThreadRunner_AC__
#include "CThreadRunner_AC.h"
#endif

#ifndef __MPCompatibility_AC__
#include "MPCompatibility_AC.h"
#endif

// Toolbox

#ifndef __CODEFRAGMENTS__
#include <CodeFragments.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif


//========================================================================================
// CMPThread_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CMPThread_AC::CMPThread_AC()
	:	CThread_AC(),
		fTaskID(NULL),
		fLock(1, 0)		// Create a binary semaphore with an initial count of zero,
						// so any attempt to wait on it will be sure to block. 
{
}

//----------------------------------------------------------------------------------------
// Copy constructor
//----------------------------------------------------------------------------------------

CMPThread_AC::CMPThread_AC(const CMPThread_AC& source)
	:	CThread_AC(source),
		fTaskID(NULL),
		fLock(1, 0)		// Create a binary semaphore with an initial count of zero,
						// so any attempt to wait on it will be sure to block. 
{
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

CMPThread_AC::~CMPThread_AC()
{
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

#ifdef __MRC__
extern "C"
#endif
static void* RemoteDelete(void* parameter)
{
	::operator delete(parameter);
	return NULL;
}

void CMPThread_AC::operator delete(void* ptr)
{
	if (ptr)
	{
		if (CurrentTaskIsPreemptive_AC())
		{
#if UNIVERSAL_INTERFACES_VERSION >= 0x0330
			if ((UInt32)MPRemoteCall != (UInt32)kUnresolvedCFragSymbolAddress)
#endif
				MPRemoteCall(RemoteDelete, ptr, kMPOwningProcessRemoteContext);
		}
		else
		{
			::operator delete(ptr);
		}
	}
}

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

CThread_AC* CMPThread_AC::Start()
{
	if (!fTermination)
		fTermination.Create();

	if (!fTaskID)
	{
		//ThrowIfNonObject_AC(fThread);
#define kDied reinterpret_cast<void*>('died')
#ifdef __MRC__
		TaskProc entryPoint = reinterpret_cast<TaskProc>(EntryPoint);
		ThrowIfOSErr_AC(MPCreateTask(entryPoint, this, GetStackSize(), fTermination, 
									 kDied, this, GetMPTaskOptions(), &fTaskID));
#else
		ThrowIfOSErr_AC(MPCreateTask(EntryPoint, this, GetStackSize(), fTermination, 
									 kDied, this, GetMPTaskOptions(), &fTaskID));
#endif
	}

	return this;
}

//----------------------------------------------------------------------------------------
// GetMPTaskOptions
//----------------------------------------------------------------------------------------

MPTaskOptions CMPThread_AC::GetMPTaskOptions() const
{
//	MPTaskOptions options = 0;
//	if (CreateSuspended())
//		options |= 1; // kMPCreateTaskSuspendedMask;

	return 0;
}

//----------------------------------------------------------------------------------------
// IsAlive
//----------------------------------------------------------------------------------------

bool CMPThread_AC::IsAlive() const
{
	// Need way to check if it has been killed.
	return ((!fDone) && fTaskID);
}

//----------------------------------------------------------------------------------------
// IsCurrent
//----------------------------------------------------------------------------------------

bool CMPThread_AC::IsCurrent() const
{
	return fTaskID && (fTaskID == Current());
}

//----------------------------------------------------------------------------------------
// Current
//----------------------------------------------------------------------------------------

MPTaskID CMPThread_AC::Current()
{
	return MPCurrentTaskID();
}

//----------------------------------------------------------------------------------------
// Yield
//----------------------------------------------------------------------------------------

void CMPThread_AC::Yield()
{
	//MPYield();
}

//----------------------------------------------------------------------------------------
// Suspend
//----------------------------------------------------------------------------------------

void CMPThread_AC::Suspend()
{
	fLock.Wait(kDurationForever);
}

//----------------------------------------------------------------------------------------
// Resume
//----------------------------------------------------------------------------------------

void CMPThread_AC::Resume()
{
	fLock.Signal();	// Unblock the task.
}

//----------------------------------------------------------------------------------------
// Join
//----------------------------------------------------------------------------------------

void CMPThread_AC::Join()
{
	RequestShutdown();
	if (!IsCurrent())
	{
		while (IsAlive())
			Yield();
	}
}

//----------------------------------------------------------------------------------------
// GetResult
//----------------------------------------------------------------------------------------

OSStatus CMPThread_AC::GetResult(Duration timeout)
{
	CThreadNotification_AC message;
	OSStatus err;
	if (fTermination.Wait(message, timeout))
		err = message.GetResult();
	else
		err = kMPTimeoutErr;

	return err;
}

#if qDebug

//----------------------------------------------------------------------------------------
// DebugFailIf
//----------------------------------------------------------------------------------------

void CMPThread_AC::DebugFailIf(OSStatus status, const char* inFile, short inLine)
{
	DebugMPFailIfOSStatus_AC(status, inFile, inLine);
}

#else

//----------------------------------------------------------------------------------------
// FailIf
//----------------------------------------------------------------------------------------

void CMPThread_AC::FailIf(OSStatus status)
{
	MPFailIfOSStatus_AC(status);
}

#endif // qDebug

//----------------------------------------------------------------------------------------
// ProgramBreak
//----------------------------------------------------------------------------------------

void CMPThread_AC::ProgramBreak(ConstStr255Param msg)
{
	MPProgramBreak_AC(msg);
}

//----------------------------------------------------------------------------------------
// ProgramBreak
//----------------------------------------------------------------------------------------

void CMPThread_AC::ProgramBreak(const char* format, ...)
{
	va_list args;
	va_start(args, format);
	MPProgramBreak_AC(format, args);
}

//----------------------------------------------------------------------------------------
// ProgramBreak
//----------------------------------------------------------------------------------------

void CMPThread_AC::ProgramBreak(const char* format, va_list args)
{
	MPProgramBreak_AC(format, args);
}

//----------------------------------------------------------------------------------------
// EntryPoint
//----------------------------------------------------------------------------------------

OSStatus CMPThread_AC::EntryPoint(void* parameter)
{
	CMPThread_AC* thread = static_cast<CMPThread_AC*>(parameter);
	CThreadHandle_AC threadHandle(thread);

	try
	{
		if (thread->CreateSuspended())
			thread->Suspend();

		thread->Run();
	}
	catch (CException_AC& fi)
	{
		thread->PostException(fi.GetError(), fi.GetExceptionMessage());
		// Do not allow any exceptions to propagate into the Multiprocessor Library
	}
	catch (...)
	{
		if (!thread->fHasException)
			thread->PostException(minErr, 0);
		// Do not allow any exceptions to propagate into the Multiprocessor Library
	}

	thread->fDone = true;
	thread->fTaskID = NULL;

	return noErr;
}

#endif // qWantsMP

//----------------------------------------------------------------------------------------
// End of CMPThread_AC.cpp
