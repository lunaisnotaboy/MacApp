//----------------------------------------------------------------------------------------
// CThreadList_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		04/07/01	[PB] Comparison between signed and unsigned. 
		02/14/01	Eliminate dependencies on CDynamicArray_AC. 
		01/02/01	Update copyright.
		03/19/00	Remember to delete the array space. 
		03/10/00	Include CException_AC, CReporter_AC, MemoryUtils_AC, Utils_AC. 
		03/09/00	New implementation so Delete doesn't deallocate the array when
							the size goes down to zero. Makes it safe to call Pop and PopFront
							(but not PushBack) from an MP task. 
		01/28/00	Initial version. 
*/

#ifndef __CThreadList_AC__
#include "CThreadList_AC.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif


//========================================================================================
// CThreadList_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CThreadList_AC::CThreadList_AC(ArrayIndex initialSize)
	:	fArraySpace(NULL),
		fSize(0),
		fAllocationIncrement(kAllocationIncrement),
		fAllocatedSize(0)
{
	SetArraySize(initialSize);
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

CThreadList_AC::~CThreadList_AC()
{
#if qCoreDebug
	::Warning_AC(fSize == 0, "Deleting a thread list that isn't empty");
#endif
	delete[] fArraySpace;
	fArraySpace = NULL;
	fSize = 0;
	fAllocatedSize = 0;
}

//----------------------------------------------------------------------------------------
// SetArraySize
//----------------------------------------------------------------------------------------

void CThreadList_AC::SetArraySize(ArrayIndex theSize)
{
	if (theSize > fAllocatedSize)
	{
#if qCoreDebug
		if (fAllocationIncrement < 0)
			::ProgramBreak_AC("fAllocationIncrement < 0 !  You have serious problems.");
#endif
		// Round up the # of allocated elements to the next multiple of fAllocationIncrement.
		ArrayIndex newAllocatedSize = theSize;
		if ((theSize > 0) && (fAllocationIncrement > 0))
			newAllocatedSize = ((theSize - 1) / fAllocationIncrement + 1) * fAllocationIncrement;

		if (newAllocatedSize != fAllocatedSize)
		{
			if (newAllocatedSize)
			{
				try
				{
					// This process could be much more efficient if we could use reallocate
					// instead of always doing an allocate/copy/delete. The problem is that
					// TidyHeap doesn't have a reallocate method. We could go around TidyHeap
					// and use the memory heap's reallocate method, but it would be nice if
					// we could continue to have TidyHeap tracking our array space. The other
					// thing that would help is if the memory heap's reallocate method were
					// smarter about shrinking blocks. If the space being freed at the end
					// of the block is large enough, it could be converted to a free block and
					// added to the free list with no need to do any allocation or copying. 
					
					void* newPtr = TH_new ThreadID[newAllocatedSize];

					if (fArraySpace)
					{
						Size moveSize = Min_AC(fSize, theSize);
						moveSize = moveSize * sizeof(ThreadID);
						BlockMove_AC(fArraySpace, newPtr, moveSize);

						delete[] fArraySpace;
					}
					fArraySpace = (ThreadID*)newPtr;
				}
				catch(CException_AC& theException)
				{
					DoCatchMessage_AC(theException);
					if (theSize <= fSize) // shrinking the space, just leave the old pointer, don't fail
						;
					else
						throw; // Growing the space, just leave the old pointer, but fail
				}
			}
		}
		fAllocatedSize = newAllocatedSize;
	}
}

//----------------------------------------------------------------------------------------
// InsertLast
//----------------------------------------------------------------------------------------

void CThreadList_AC::InsertLast(ThreadID item)
{
	if (fSize + 1 > fAllocatedSize)
		SetArraySize(fSize + 1);
	
	fArraySpace[fSize++] = item;
}

//----------------------------------------------------------------------------------------
// Pop
//----------------------------------------------------------------------------------------

ThreadID CThreadList_AC::Pop()
{
	ThreadID item = kNoThreadID;
	if (fSize > 0)
		item = fArraySpace[--fSize];

	return item;
}

//----------------------------------------------------------------------------------------
// PopFront
//----------------------------------------------------------------------------------------

ThreadID CThreadList_AC::PopFront()
{
	ThreadID item = kNoThreadID;
	if (fSize > 0)
	{
		item = fArraySpace[0];
		AtDelete(0);
	}
	return item;
}

//----------------------------------------------------------------------------------------
// GetEqualItemNo
//----------------------------------------------------------------------------------------

CThreadList_AC::ArrayIndex CThreadList_AC::GetEqualItemNo(ThreadID item) const
{
	ArrayIndex index = kEmptyIndex;

	for (ArrayIndex i = 0; i < fSize; ++i)
	{
		if (fArraySpace[i] == item)
		{
			index = i + 1;
			break;
		}
	}

	return index;
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

void CThreadList_AC::Delete(ThreadID item)
{
	ArrayIndex index = GetEqualItemNo(item);
	if (index != kEmptyIndex)
		AtDelete(index);
}

//----------------------------------------------------------------------------------------
// AtDelete
//----------------------------------------------------------------------------------------

void CThreadList_AC::AtDelete(ArrayIndex index)
{
	--fSize;
	for (ArrayIndex i = index - 1; i < fSize; ++i)
		fArraySpace[i] = fArraySpace[i+1];
}


//----------------------------------------------------------------------------------------
// End of CThreadList_AC.cpp
