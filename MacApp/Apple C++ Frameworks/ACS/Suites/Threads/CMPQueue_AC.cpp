//----------------------------------------------------------------------------------------
// CMPQueue_AC.cpp
// Copyright © 1996-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		09/22/00	Never call MPYield. 
		03/09/00	Allow other threads to run while we're waiting in a 
							cooperative context. 
		02/06/00	Don't use C++ exceptions in an MP task. 
		02/03/00	Can't delete a NULL identifier. 
		02/03/00	Carbon: Fix includes. 
		01/28/00	Initial version. 
*/

#ifndef __CMPQueue_AC__
#include "CMPQueue_AC.h"
#endif

#if qWantsMP

// ACS

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif

#ifndef __CTimerTask_AC__
#include "CTimerTask_AC.h"
#endif

// Toolbox

#ifndef __THREADS__
#include <Threads.h>
#endif


//========================================================================================
// CMPQueue_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

void CMPQueue_AC::Create()
{
	MPFailIfOSStatus_AC(MPCreateQueue(&fIdentifier));
}

//----------------------------------------------------------------------------------------
// Delete
//----------------------------------------------------------------------------------------

void CMPQueue_AC::Delete()
{
	if (fIdentifier)
	{
		MPFailIfOSStatus_AC(MPDeleteQueue(fIdentifier));
		fIdentifier = NULL;
	}
}

//----------------------------------------------------------------------------------------
// Wait
//----------------------------------------------------------------------------------------

bool CMPQueue_AC::Wait(CThreadNotification_AC& message, Duration timeout)
{
	return Wait(&message.fParam1, &message.fParam2, &message.fParam3, timeout);
}

bool CMPQueue_AC::Wait(void** param1, void** param2, void** param3, Duration timeout)
{
	OSStatus err = kMPTimeoutErr;
	if ((timeout > 0) && !CurrentTaskIsPreemptive_AC())
	{
		// If we're not in a preemptive task, we need to allow other cooperative
		// threads to run while we're waiting. 
		CSimpleTimer_AC timer(timeout);
		do
		{
			err = MPWaitOnQueue(fIdentifier, param1, param2, param3, 0);
			if (err != kMPTimeoutErr)
				break;

			YieldToAnyThread();
			//MPYield();
		}
		while (!timer.Fired());
	}
	else
		err = MPWaitOnQueue(fIdentifier, param1, param2, param3, timeout);

	if (err != kMPTimeoutErr)
		MPFailIfOSStatus_AC(err);

	return (err == noErr);
}

//----------------------------------------------------------------------------------------
// Notify
//----------------------------------------------------------------------------------------

void CMPQueue_AC::Notify(const CThreadNotification_AC& message)
{
	Notify(message.fParam1, message.fParam2, message.fParam3);
}

void CMPQueue_AC::Notify(void* param1, void* param2, void* param3)
{
	MPFailIfOSStatus_AC(MPNotifyQueue(fIdentifier, param1, param2, param3));
}


#endif // qWantsMP

//----------------------------------------------------------------------------------------
// End of CMPQueue_AC.cpp
