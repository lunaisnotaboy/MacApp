//----------------------------------------------------------------------------------------
// CAtom_AC.cpp
// Copyright © 1996-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		08/14/01	Scope stdio definitions because cstdio is getting included first. 
		04/07/01	[PB] Cannot pass objects of type `CStr255_AC' through `...'. 
		02/20/01	[PB] Suppress unused variable warnings. 
		02/14/01	Include MacMemory instead of Memory_AC. 
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
					Include Dialogs.h to satify ImageCompression.h's need for a DialogRef.
		09/20/00	Removed all pragma segments.
		05/15/00	CW Pro 6: namespacing. 
					Explicitly cast to QTAtom so compiler doesn't think 0 could 
					be a reference. 
		12/07/99	Added extra scope in EqualAtoms.
		06/06/99	Moved into ACS. 
		09/04/98	Added GetSize() to CAtomContainer_AC 
		08/20/98	Try using dout instead of ProgramReport. 
		08/04/98	Use qCoreDebug instead of qDebug. 
		08/04/98	QTClassLib. 
		04/07/98	Stop requiring qBackwardCompatible. 
*/

#ifndef __CAtom_AC__
#include "CAtom_AC.h"
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#if qCoreDebug
	#ifndef __CPascalString_AC__
	#include "CPascalString_AC.h"
	#endif

	#ifndef __dout_AC__
	#include "dout_AC.h"
	#endif
#endif // qCoreDebug

// Toolbox

#ifndef __DIALOGS__
#include <Dialogs.h>
#endif

#ifndef __FIXMATH__
#include <FixMath.h>
#endif

#ifndef __IMAGECOMPRESSION__
#include <ImageCompression.h>
#endif

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif

#ifndef __MOVIES__
#include <Movies.h>
#endif

// ANSI

#if qCoreDebug

#ifndef __STDIO__
#include <stdio.h>
#endif

#ifndef __STDARG__
#include <stdarg.h>
#endif

#endif // qCoreDebug

using std::memcmp;
using std::sprintf;
using std::vsprintf;

//========================================================================================
// CLASS CAtomContainer_AC
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// EqualAtomContainers
//----------------------------------------------------------------------------------------

Boolean CAtomContainer_AC::EqualAtomContainers(QTAtomContainer c1, QTAtomContainer c2)
{
	CTempLockContainer_AC lock1(c1);
	CTempLockContainer_AC lock2(c2);
	return EqualAtoms(c1, kParentAtomIsContainer, c2, kParentAtomIsContainer);
}

//----------------------------------------------------------------------------------------
// EqualAtoms
//----------------------------------------------------------------------------------------

Boolean CAtomContainer_AC::EqualAtoms(QTAtomContainer c1, QTAtom atom1, QTAtomContainer c2, QTAtom atom2)
{
	Boolean same = false;
	{
		// There is an extra scope here so that the control flow can jump to bail
		// without skipping local variable initialization.
		// Compare the types and ids
		{
			QTAtomType atomType1 = 0;
			QTAtomType atomType2 = 0;
			QTAtomID id1 = 0;
			QTAtomID id2 = 0;
			ThrowIfOSErr_AC(QTGetAtomTypeAndID(c1, atom1, &atomType1, &id1));
			ThrowIfOSErr_AC(QTGetAtomTypeAndID(c2, atom2, &atomType2, &id2));
			if ((atomType1 != atomType2) || (id1 != id2))
				goto bail;
		}

		// Compare the number of children
		short count1 = QTCountChildrenOfType(c1, atom1, 0);
		short count2 = QTCountChildrenOfType(c2, atom2, 0);
		if (count1 != count2)
			goto bail;

		if (count1 == 0)
		{
			// Compare the data
			long dataSize1 = 0;
			long dataSize2 = 0;
			Ptr atomData1 = nil;
			Ptr atomData2 = nil;
			ThrowIfOSErr_AC(QTGetAtomDataPtr(c1, atom1, &dataSize1, &atomData1));
			ThrowIfOSErr_AC(QTGetAtomDataPtr(c2, atom2, &dataSize2, &atomData2));
			if ((dataSize1 != dataSize2) || memcmp(atomData1, atomData2, dataSize1))
				goto bail;
		}
		else
		{
			// Compare each child
			QTAtom child1 = 0;
			QTAtom child2 = 0;
			for (short index = 1; index <= count1; ++index)
			{
				ThrowIfOSErr_AC(QTNextChildAnyType(c1, atom1, child1, &child1));
				ThrowIfOSErr_AC(QTNextChildAnyType(c2, atom2, child2, &child2));
		
				if (!EqualAtoms(c1, child1, c2, child2)) goto bail;
			}
		}
		
		same = true;
	}

bail:
	return same;
}

//----------------------------------------------------------------------------------------
// CopyAtomContainer
//----------------------------------------------------------------------------------------

QTAtomContainer CAtomContainer_AC::CopyAtomContainer(QTAtomContainer original)
{
	long count = GetHandleSize(original);
	QTAtomContainer copy = NewHandle(count);
	ThrowIfNULL_AC(copy);
	BlockMove_AC(*original, *copy, count);
	return copy;
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::reset
//----------------------------------------------------------------------------------------

void CAtomContainer_AC::reset()
{
	ThrowIfOSErr_AC( Dispose() );
}

//----------------------------------------------------------------------------------------
// QT Atom Data Support
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::New
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::New()
{
	return QTNewAtomContainer(&fContainer);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::Dispose
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::Dispose()
{
	OSErr err = noErr;
	if (fContainer)
	{
		QTDisposeAtomContainer(fContainer);
		fContainer = nil;
	}
	return err;
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::GetSize
//----------------------------------------------------------------------------------------

long CAtomContainer_AC::GetSize()
{
	return GetHandleSize(fContainer);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::GetNextChildType
//----------------------------------------------------------------------------------------

QTAtomType CAtomContainer_AC::GetNextChildType(QTAtom parentAtom, QTAtomType currentChildType)
{
	return QTGetNextChildType(fContainer, parentAtom, currentChildType);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::CountChildrenOfType
//----------------------------------------------------------------------------------------

short CAtomContainer_AC::CountChildrenOfType(QTAtom parentAtom, QTAtomType childType)
{
	return QTCountChildrenOfType(fContainer, parentAtom, childType);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::FindChildByIndex
//----------------------------------------------------------------------------------------

QTAtom CAtomContainer_AC::FindChildByIndex(QTAtom parentAtom, QTAtomType atomType, short index, QTAtomID* id)
{
	return QTFindChildByIndex(fContainer, parentAtom, atomType, index, id);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::FindChildByID
//----------------------------------------------------------------------------------------

QTAtom CAtomContainer_AC::FindChildByID(QTAtom parentAtom, QTAtomType atomType, QTAtomID id, short* index)
{
	return QTFindChildByID(fContainer, parentAtom, atomType, id, index);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::NextChildAnyType
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::NextChildAnyType(QTAtom parentAtom, QTAtom currentChild, QTAtom* nextChild)
{
	return QTNextChildAnyType(fContainer, parentAtom, currentChild, nextChild);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::SetAtomData
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::SetAtomData(QTAtom atom, long dataSize, const void* atomData)
{
	return QTSetAtomData(fContainer, atom, dataSize, const_cast<void*>(atomData));
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::CopyAtomDataToHandle
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::CopyAtomDataToHandle(QTAtom atom, Handle targetHandle)
{
	return QTCopyAtomDataToHandle(fContainer, atom, targetHandle);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::CopyAtomDataToPtr
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::CopyAtomDataToPtr(QTAtom atom, Boolean sizeOrLessOK, long size, void* targetPtr, long* actualSize)
{
	return QTCopyAtomDataToPtr(fContainer, atom, sizeOrLessOK, size, targetPtr, actualSize);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::GetAtomTypeAndID
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::GetAtomTypeAndID(QTAtom atom, QTAtomType* atomType, QTAtomID* id)
{
	return QTGetAtomTypeAndID(fContainer, atom, atomType, id);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::CopyAtom
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::CopyAtom(QTAtom atom, QTAtomContainer* targetContainer)
{
	return QTCopyAtom(fContainer, atom, targetContainer);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::Lock
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::Lock()
{
	return QTLockContainer(fContainer);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::GetAtomDataPtr
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::GetAtomDataPtr(QTAtom atom, long* dataSize, Ptr* atomData)
{
	return QTGetAtomDataPtr(fContainer, atom, dataSize, atomData);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::Unlock
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::Unlock()
{
	return QTUnlockContainer(fContainer);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::InsertChild
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::InsertChild(QTAtom parentAtom, QTAtomType atomType, QTAtomID id, short index, long dataSize, const void* data, QTAtom* newAtom)
{
	return QTInsertChild(fContainer, parentAtom, atomType, id, index, dataSize, const_cast<void*>(data), newAtom);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::InsertChildren
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::InsertChildren(QTAtom parentAtom, QTAtomContainer childrenContainer)
{
	return QTInsertChildren(fContainer, parentAtom, childrenContainer);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::RemoveAtom
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::RemoveAtom(QTAtom atom)
{
	return QTRemoveAtom(fContainer, atom);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::RemoveChildren
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::RemoveChildren(QTAtom atom)
{
	return QTRemoveChildren(fContainer, atom);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::ReplaceAtom
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::ReplaceAtom(QTAtom targetAtom, QTAtomContainer replacementContainer, QTAtom replacementAtom)
{
	return QTReplaceAtom(fContainer, targetAtom, replacementContainer, replacementAtom);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::SwapAtoms
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::SwapAtoms(QTAtom atom1, QTAtom atom2)
{
	return QTSwapAtoms(fContainer, atom1, atom2);
}

//----------------------------------------------------------------------------------------
// CAtomContainer_AC::SetAtomID
//----------------------------------------------------------------------------------------

OSErr CAtomContainer_AC::SetAtomID(QTAtom atom, QTAtomID newID)
{
	return QTSetAtomID(fContainer, atom, newID);
}


//========================================================================================
// CLASS CTempAtomContainer_AC
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// CTempAtomContainer_AC destructor
//----------------------------------------------------------------------------------------

CTempAtomContainer_AC::~CTempAtomContainer_AC()
{
	reset();
}

//----------------------------------------------------------------------------------------
// CTempAtomContainer_AC::operator=
//----------------------------------------------------------------------------------------

void CTempAtomContainer_AC::operator=(QTAtomContainer inData)
{ 
	if (fContainer != inData)
	{
		reset();
		fContainer = inData;
	}
}

//----------------------------------------------------------------------------------------
// CTempAtomContainer_AC::operator=
//----------------------------------------------------------------------------------------

void CTempAtomContainer_AC::operator=(CTempAtomContainer_AC& inData)
{ 
	if (fContainer != inData)
	{
		reset();
		fContainer = inData.release();
	}
}


//========================================================================================
// CLASS CTempLockContainer_AC
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// CTempLockContainer_AC constructor
//----------------------------------------------------------------------------------------

CTempLockContainer_AC::CTempLockContainer_AC(QTAtomContainer container) :
	CAtomContainer_AC(container)
{
	ThrowIfOSErr_AC( Lock() );
}

//----------------------------------------------------------------------------------------
// CTempLockContainer_AC destructor
//----------------------------------------------------------------------------------------

CTempLockContainer_AC::~CTempLockContainer_AC()
{
	release();
}

//----------------------------------------------------------------------------------------
// CTempLockContainer_AC::release
//----------------------------------------------------------------------------------------

QTAtomContainer CTempLockContainer_AC::release()
{ 
	QTAtomContainer container = fContainer;
	if (fContainer)
	{
		OSErr ignore = Unlock();
#if qProjectBuilder
		(void) ignore;
#endif
		fContainer = nil;
	}
	return container;
}

//----------------------------------------------------------------------------------------
// CTempLockContainer_AC::operator=
//----------------------------------------------------------------------------------------

void CTempLockContainer_AC::operator=(QTAtomContainer container)
{ 
	if (fContainer != container)
	{
		OSErr ignore = Unlock();
#if qProjectBuilder
		(void) ignore;
#endif
		fContainer = container;
		ThrowIfOSErr_AC( Lock() );
	}
}


//========================================================================================
// CLASS CAtomSpec_AC
//========================================================================================

#if qCoreDebug
//----------------------------------------------------------------------------------------
// CAtomSpec_AC::operator CChar63_AC:
//----------------------------------------------------------------------------------------
CAtomSpec_AC::operator CChar63_AC() const
{
	char textPoint[64];
	sprintf (textPoint, "CAtomSpec_AC(%p, %ld)", container, atom);
	return CChar63_AC(textPoint);
}
#endif

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::operator>=:
//----------------------------------------------------------------------------------------
bool CAtomSpec_AC::operator>=(const CAtomSpec_AC& atomSpec) const
{
	return (container > atomSpec.container) ||
		   (container == atomSpec.container && atom >= atomSpec.atom);
}
	
//----------------------------------------------------------------------------------------
// CAtomSpec_AC::operator<=:
//----------------------------------------------------------------------------------------
bool CAtomSpec_AC::operator<=(const CAtomSpec_AC& atomSpec) const
{
	return (container < atomSpec.container) ||
		   (container == atomSpec.container && atom <= atomSpec.atom);
}
	
//----------------------------------------------------------------------------------------
// CAtomSpec_AC::operator>:
//----------------------------------------------------------------------------------------
bool CAtomSpec_AC::operator>(const CAtomSpec_AC& atomSpec) const
{
	return (container > atomSpec.container) ||
		   (container == atomSpec.container && atom > atomSpec.atom);
}
	
//----------------------------------------------------------------------------------------
// CAtomSpec_AC::operator<:
//----------------------------------------------------------------------------------------
bool CAtomSpec_AC::operator<(const CAtomSpec_AC& atomSpec) const
{
	return (container < atomSpec.container) ||
		   (container == atomSpec.container && atom < atomSpec.atom);
}
	
//----------------------------------------------------------------------------------------
// QT Atom Data Support
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::Dispose
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::Dispose()
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).Dispose());
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::GetNextChildType
//----------------------------------------------------------------------------------------

QTAtomType CAtomSpec_AC::GetNextChildType(QTAtomType currentChildType) const
{
	return CAtomContainer_AC(container).GetNextChildType(atom, currentChildType);
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::CountChildrenOfType
//----------------------------------------------------------------------------------------

short CAtomSpec_AC::CountChildrenOfType(QTAtomType childType) const
{
	return CAtomContainer_AC(container).CountChildrenOfType(atom, childType);
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::FindChildByIndex
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::FindChildByIndex(QTAtomType atomType, short index, QTAtomID* id) const
{
	return CAtomSpec_AC(container, CAtomContainer_AC(container).FindChildByIndex(atom, atomType, index, id));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::FindChildByID
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::FindChildByID(QTAtomType atomType, QTAtomID id, short* index) const
{
	return CAtomSpec_AC(container, CAtomContainer_AC(container).FindChildByID(atom, atomType, id, index));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::NextChildAnyType
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::NextChildAnyType(const CAtomSpec_AC& currentChild) const
{
	CAtomSpec_AC nextChild(container, -1);
////	DebugAssert(currentChild.container == container, nil);
	ThrowIfOSErr_AC(CAtomContainer_AC(container).NextChildAnyType(atom, currentChild.atom, &nextChild.atom));
	return nextChild;
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::SetAtomData
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::SetAtomData(long dataSize, const void* atomData)
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).SetAtomData(atom, dataSize, atomData));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::SetAtomData
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::SetAtomData(Handle data)
{
	CTempHandleLock_AC lockData(data);
	long dataSize = GetHandleSize(data);
	SetAtomData(dataSize, *data);
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::CopyAtomDataToHandle
//----------------------------------------------------------------------------------------

Handle CAtomSpec_AC::CopyAtomDataToHandle() const
{
	CTempHandle_AC targetHandle = nil;
	long dataSize = GetAtomDataSize();
	targetHandle = NewHandle(dataSize);
	ThrowIfNULL_AC(targetHandle);
	ThrowIfOSErr_AC(CAtomContainer_AC(container).CopyAtomDataToHandle(atom, targetHandle));
	return targetHandle.release();
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::CopyAtomDataToPtr
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::CopyAtomDataToPtr(Boolean sizeOrLessOK, long size, void* targetPtr, long* actualSize) const
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).CopyAtomDataToPtr(atom, sizeOrLessOK, size, targetPtr, actualSize));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::GetAtomType
//----------------------------------------------------------------------------------------

QTAtomType CAtomSpec_AC::GetAtomType() const
{
	QTAtomType atomType = 0;
	ThrowIfOSErr_AC(CAtomContainer_AC(container).GetAtomTypeAndID(atom, &atomType, nil));
	return atomType;
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::GetAtomID
//----------------------------------------------------------------------------------------

QTAtomID CAtomSpec_AC::GetAtomID() const
{
	QTAtomID id = 0;
	ThrowIfOSErr_AC(CAtomContainer_AC(container).GetAtomTypeAndID(atom, nil, &id));
	return id;
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::CopyAtom
//----------------------------------------------------------------------------------------

QTAtomContainer CAtomSpec_AC::CopyAtom() const
{
	QTAtomContainer targetContainer = nil;
	ThrowIfOSErr_AC(CAtomContainer_AC(container).CopyAtom(atom, &targetContainer));
	return targetContainer;
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::Lock
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::Lock()
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).Lock());
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::GetAtomDataPtr
//----------------------------------------------------------------------------------------

Ptr CAtomSpec_AC::GetAtomDataPtr(long* dataSize)
{
	Ptr atomData = nil;
	ThrowIfOSErr_AC(CAtomContainer_AC(container).GetAtomDataPtr(atom, dataSize, &atomData));
	return atomData;
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::GetAtomDataSize
//----------------------------------------------------------------------------------------

long CAtomSpec_AC::GetAtomDataSize() const
{
	long dataSize = 0;
	ThrowIfOSErr_AC(CAtomContainer_AC(container).GetAtomDataPtr(atom, &dataSize, nil));
	return dataSize;
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::Unlock
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::Unlock()
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).Unlock());
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::InsertChild
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::InsertChild(QTAtomType atomType, QTAtomID id, short index, long dataSize, const void* data)
{
	CAtomSpec_AC newAtom(container, -1);
	ThrowIfOSErr_AC(CAtomContainer_AC(container).InsertChild(atom, atomType, id, index, dataSize, data, &newAtom.atom));
	return newAtom;
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::InsertChild
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::InsertChild(QTAtomType atomType, QTAtomID id, short index, Handle data)
{
	CTempHandleLock_AC dataLock(data);
	long dataSize = GetHandleSize(data);
	return InsertChild(atomType, id, index, dataSize, (data ? *data : nil));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::InsertChild
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::InsertChild(QTAtomType atomType, QTAtomID id, short index)
{
	return InsertChild(atomType, id, index, 0, nil);
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::SetChild
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::SetChild(QTAtomType atomType, QTAtomID id, long dataSize, const void* data)
{
	CAtomSpec_AC newAtom = FindChildByID(atomType, id);
	if (newAtom != QTAtom(0))
	{
		// If it's a container, it already exists so we're ok
		// If it's a leaf, set the data
		if (dataSize > 0)
			newAtom.SetAtomData(dataSize, data);
	}
	else
	{
		// Atom doesn't already exist, so create it. 
		// Could be a container or a leaf. 
		newAtom = InsertChild(atomType, id, 0, dataSize, data);
	}

	return newAtom;
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::SetChild
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::SetChild(QTAtomType atomType, QTAtomID id, Handle data)
{
	CTempHandleLock_AC dataLock(data);
	long dataSize = GetHandleSize(data);
	return SetChild(atomType, id, dataSize, *data);
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::SetChild
//----------------------------------------------------------------------------------------

CAtomSpec_AC CAtomSpec_AC::SetChild(QTAtomType atomType, QTAtomID id)
{
	return SetChild(atomType, id, 0, nil);
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::InsertChildren
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::InsertChildren(QTAtomContainer childrenContainer)
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).InsertChildren(atom, childrenContainer));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::RemoveAtom
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::RemoveAtom()
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).RemoveAtom(atom));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::RemoveChildren
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::RemoveChildren()
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).RemoveChildren(atom));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::ReplaceAtom
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::ReplaceAtom(const CAtomSpec_AC& replacementSpec)
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).ReplaceAtom(atom, replacementSpec.container, replacementSpec.atom));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::SwapAtoms
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::SwapAtoms(const CAtomSpec_AC& atom2)
{
#if qCoreDebug
	Assertion_AC(atom2.container == container, "");
#endif
	ThrowIfOSErr_AC(CAtomContainer_AC(container).SwapAtoms(atom, atom2.atom));
}

//----------------------------------------------------------------------------------------
// CAtomSpec_AC::SetAtomID
//----------------------------------------------------------------------------------------

void CAtomSpec_AC::SetAtomID(QTAtomID newID)
{
	ThrowIfOSErr_AC(CAtomContainer_AC(container).SetAtomID(atom, newID));
}


//========================================================================================
// Debug
//========================================================================================

#if qCoreDebug

//========================================================================================
// CLASS CAtomDump_AC
//========================================================================================
#undef Inherited

CAtomDump_AC* CAtomDump_AC::fTypes;

//----------------------------------------------------------------------------------------
// Static
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// CAtomDump_AC::DeleteAll: 
//----------------------------------------------------------------------------------------

void CAtomDump_AC::DeleteAll()
{
	while (fTypes)
		delete fTypes;
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC::DumpContainer
//----------------------------------------------------------------------------------------

void CAtomDump_AC::DumpContainer(const CAtomSpec_AC& spec, short level)
{
	CAtomSpec_AC atom;
	do
	{
		atom = spec.NextChildAnyType(atom);
		if (atom)
		{
			short children = atom.CountChildrenOfType(0);
			DumpAtom(atom, children, level);
			if (children > 0)
				DumpContainer(atom, level+1);
		}
	} while (atom);
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC::Print
//----------------------------------------------------------------------------------------

void CAtomDump_AC::Print(const char* format, ...)
{
	char buffer[1024];

	va_list args;
	va_start(args, format);
	int n = vsprintf(buffer, format, args);
	va_end(args);

	if (n > 0)
		dout << buffer;
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC::PrintLine
//----------------------------------------------------------------------------------------

void CAtomDump_AC::PrintLine()
{
	dout << endl_AC;
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC::DumpAtom
//----------------------------------------------------------------------------------------

void CAtomDump_AC::DumpAtom(const CAtomSpec_AC& spec, short children, short level)
{
	for (short i = 0; i < level; ++i)
		Print("-");

	Print(" atom %d, type ", spec.atom);
	QTAtomType atomType = spec.GetAtomType();
	PrintAtomType(atomType);

	QTAtomID id = spec.GetAtomID();
	Print(", id ");
	PrintAtomType(id);

	if (children > 0)
	{
		Print(", %d children", children);
		PrintLine();
	}
	else
	{
		long dataSize = spec.GetAtomDataSize();
		Print(", data size = %d", dataSize);
		PrintLine();

		CAtomDump_AC* dumpster = FindDumpster(atomType);
		if (dumpster)
			dumpster->DumpContents(spec, atomType, id, dataSize);
		else
			DumpHex(spec);
	}
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC::FindDumpster: 
//----------------------------------------------------------------------------------------

CAtomDump_AC* CAtomDump_AC::FindDumpster(QTAtomType atomType)
{
	CAtomDump_AC* dumpster = fTypes;
	while (dumpster && (dumpster->fAtomType != atomType))
		dumpster = dumpster->fNext;

	return dumpster;
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC::DumpHex
//----------------------------------------------------------------------------------------

void CAtomDump_AC::DumpHex(const CAtomSpec_AC& spec)
{
	Print("contents =");
	PrintLine();

	CTempLockContainer_AC locker(spec.container);
	long dataSize = 0;
	const long* p = reinterpret_cast_AC(long *, const_cast_AC(CAtomSpec_AC&, spec).GetAtomDataPtr(&dataSize));
	long count = dataSize;
	short across = 0;
	while (count > 0)
	{
		Print(" %0x", *p);
		count -= sizeof(long);
		++p;
		if (++across == 8)
		{
			PrintLine();
			across = 0;
		}
	}
	if (across)
		PrintLine();
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC::PrintAtomType
//----------------------------------------------------------------------------------------

void CAtomDump_AC::PrintAtomType(QTAtomType atomType)
{
	if (atomType > '    ')
		Print("'%.4s'", (char*) &atomType);
	else
		Print("%d", atomType);
}

//----------------------------------------------------------------------------------------
// Instance
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// CAtomDump_AC constructor
//----------------------------------------------------------------------------------------

CAtomDump_AC::CAtomDump_AC(QTAtomType atomType) :
	fNext(nil),
	fAtomType(atomType)
{
	fNext = fTypes;
	fTypes = this;
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC destructor
//----------------------------------------------------------------------------------------

CAtomDump_AC::~CAtomDump_AC()
{
	if (fTypes == this)
	{
		// Remove from head of list
		fTypes = fNext;
		fNext = nil;
	}
	else
	{
		// Find in list
		CAtomDump_AC* prev = fTypes;
		while (prev && (prev->fNext != this))
			prev = prev->fNext;
		
		// Remove from middle of list
		if (prev)
		{
			prev->fNext = fNext;
			fNext = nil;
		}
	}
}

//----------------------------------------------------------------------------------------
// CAtomDump_AC::DumpContents
//----------------------------------------------------------------------------------------

void CAtomDump_AC::DumpContents(const CAtomSpec_AC& spec, QTAtomType atomType,
								QTAtomID id, long dataSize) const
{
#pragma unused (spec, atomType, id, dataSize)
}


//========================================================================================
// CLASS CDumpMatrixAtom_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CDumpMatrixAtom_AC destructor
//----------------------------------------------------------------------------------------

CDumpMatrixAtom_AC::~CDumpMatrixAtom_AC()
{
}

//----------------------------------------------------------------------------------------
// CDumpMatrixAtom_AC::DumpContents
//----------------------------------------------------------------------------------------

void CDumpMatrixAtom_AC::DumpContents(const CAtomSpec_AC& spec, QTAtomType atomType,
									  QTAtomID id, long dataSize) const
{
#pragma unused (atomType, id, dataSize)

	Print("matrix =");
	PrintLine();

	MatrixRecord matrix;
	spec.CopyAtomDataToPtr(false, sizeof(matrix), &matrix);

	const Fixed* m = matrix.matrix[0];
	
	Print(" %12.5f", Fix2X(*m++));
	Print(" %12.5f", Fix2X(*m++));
	Print(" %12.5f", Fix2X(*m++));
	PrintLine();
	Print(" %12.5f", Fix2X(*m++));
	Print(" %12.5f", Fix2X(*m++));
	Print(" %12.5f", Fix2X(*m++));
	PrintLine();
	Print(" %12.5f", Fix2X(*m++));
	Print(" %12.5f", Fix2X(*m++));
	Print(" %12.5f", Fix2X(*m));
	PrintLine();
}


//========================================================================================
// CLASS CDumpStringAtom_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CDumpStringAtom_AC destructor
//----------------------------------------------------------------------------------------

CDumpStringAtom_AC::~CDumpStringAtom_AC()
{
}

//----------------------------------------------------------------------------------------
// CDumpStringAtom_AC::DumpContents
//----------------------------------------------------------------------------------------

void CDumpStringAtom_AC::DumpContents(const CAtomSpec_AC& spec, QTAtomType atomType,
									  QTAtomID id, long dataSize) const
{
#pragma unused (atomType, id, dataSize)

	CStr255_AC name;
	spec.CopyAtomDataToPtr(true, sizeof(name), (unsigned char*) name);

	Print("name = \"%s\"", CChar255_AC(name));
	PrintLine();
}


#endif // qCoreDebug


//----------------------------------------------------------------------------------------
// End of CAtom_AC.cpp
