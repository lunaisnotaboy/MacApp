//----------------------------------------------------------------------------------------
// ChapterTrack_AC.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/02/01	Update copyright.
		06/06/99	Moved into ACS. 
		12/04/98	Clean up for final. 
		06/22/98	Initial version. 
*/

#ifndef __ChapterTrack_AC__
#include "ChapterTrack_AC.h"
#endif

// ACS

// Toolbox

//========================================================================================
// GLOBAL Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// GetChapterTrack_AC
//----------------------------------------------------------------------------------------

Track GetChapterTrack_AC(Movie movie)
{
	Track chapterTrack = nil;

	long trackCount = GetMovieTrackCount(movie);
	for (long i = 1; i <= trackCount; ++i)
	{
		Track t = GetMovieIndTrack(movie, i);
		if (GetTrackEnabled(t))
		{
			chapterTrack = GetTrackReference(t, kTrackReferenceChapterList, 1);
			if (chapterTrack)
				break;
		}
	}

	return chapterTrack;
}

//----------------------------------------------------------------------------------------
// FindChapterTimeByName_AC
//----------------------------------------------------------------------------------------

TimeValue FindChapterTimeByName_AC(Movie movie, ConstStr255Param name)
{
	TimeValue time = -1;

	Track chapterTrack = GetChapterTrack_AC(movie);
	if (chapterTrack)
	{
		Media chapterMedia = GetTrackMedia(chapterTrack);
		MediaHandler textMediaHandler = GetMediaHandler(chapterMedia);
		ComponentResult result;
		result = TextMediaFindNextText(textMediaHandler, (char*)&name[1], name[0],
									   findTextEdgeOK, 0, &time, nil, nil);
	}

	return time;
}


//----------------------------------------------------------------------------------------
// End of ChapterTrack_AC.cpp
