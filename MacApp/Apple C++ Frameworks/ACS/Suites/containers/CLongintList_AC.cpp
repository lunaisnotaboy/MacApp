//----------------------------------------------------------------------------------------
// CLongintList_AC.cpp
// Copyright © 1986-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/01/00	[PB] DonÕt include Packages.h. 
		09/07/00	Added embedded documentation.
		03/24/99	Update copyright notice.
		10/06/98	Clean up includes. 
*/

#ifndef __CLongintList_AC__
#include "CLongintList_AC.h"
#endif

// ACS

#ifndef __Debug_AC__
#include "Debug_AC.h"
#endif

// ANSI

#ifndef __STDLIB__
#include <stdlib.h>
#endif


//========================================================================================
// CLASS CSortedLongintList_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CSortedLongintList_AC destructor
//----------------------------------------------------------------------------------------

CSortedLongintList_AC::~CSortedLongintList_AC()
{
}

//----------------------------------------------------------------------------------------
// CSortedLongintList_AC Clone
//----------------------------------------------------------------------------------------

void* CSortedLongintList_AC::Clone() const
{
	return TH_new CSortedLongintList_AC(*this);
}

//----------------------------------------------------------------------------------------
// CSortedLongintList_AC::At: Return the index'th element of the list.
//----------------------------------------------------------------------------------------

#if qRangeCheck
long CSortedLongintList_AC::At(ArrayIndex_AC index) const
{
	ThrowIfRangeCheck(index, "Range Check in CSortedLongintList_AC.At");

	return *((long*)ComputeAddress(index));
}
#endif

//----------------------------------------------------------------------------------------
// CSortedLongintList_AC::Compare: 
//----------------------------------------------------------------------------------------

CompareResult_AC CSortedLongintList_AC::Compare(long item1, long item2) const
// Compare compares two items in a list. The method compares the ordinal value 
// of the two items and returns one of the constants kItem1LessThanItem2, kItem1EqualItem2,
// or kItem1GreaterThanItem2, according to whether the ordinal value of the first parameter
// is less than, equal to, or greater than the ordinal value of the second parameter.
//
// item1:	Specifies one item to be compared.
// item2:	Specifies the other item to be compared.
//
// Call?		Seldom.
// Override?	Seldom.
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;
	// By default just compare the ordinal value of the items. Subclasses that want to use
	// the items as pointers or other types should override if the comparison is based on
	// the pointed at value
	if (item1 > item2)
		returnVal = kItem1GreaterThanItem2_AC;
	else if (item1 < item2)
		returnVal = kItem1LessThanItem2_AC;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CSortedLongintList_AC::CompareElements: 
//----------------------------------------------------------------------------------------

CompareResult_AC CSortedLongintList_AC::CompareElements(const void* element1,
														const void* element2) const
// CompareElements coerces the elements to compare into pointers to long integers, 
// invokes the Compare function of this objectÕs class, and returns the result of the comparison,
// which is one of the constants kItem1LessThanItem2, kItem1EqualItem2, or kItem1GreaterThanItem2,
// according to whether the ordinal value of the first parameter is less than, equal to, or greater
// than the ordinal value of the second parameter.
//
// Element1:	Specifies one object to be compared.
// Element2:	Specifies the other object to be compared.
//
// Call?		As needed.
// Override?	Seldom.
{
	return Compare(*static_cast<const long*>(element1), *static_cast<const long*>(element2));
}

//----------------------------------------------------------------------------------------
// CSortedLongintList_AC::DoSearch: DON'T use exit to get out of this routine from your
// testLong function or you will be really sad! (our debugger will check for you).
//----------------------------------------------------------------------------------------

bool CSortedLongintList_AC::DoSearch(CompareLongType	testLong,
									 void*				yourDataPtr,
									 ArrayIndex_AC&		index) const
{
	Tester tester(testLong, yourDataPtr, this);
	return tester.DoSearchElement(index);
}

//----------------------------------------------------------------------------------------
// CSortedLongintList_AC::Search: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC CSortedLongintList_AC::Search(CompareLongType testLong, void* yourDataPtr)
{
	ArrayIndex_AC returnVal = kEmptyIndex_AC;

	ArrayIndex_AC index;
	if (DoSearch(testLong, yourDataPtr, index))
		returnVal = index;

	return returnVal;
}


//========================================================================================
// class CSortedLongintList_AC::Tester
//========================================================================================

//----------------------------------------------------------------------------------------
// CSortedLongintList_AC::Tester::TestItem: 
//----------------------------------------------------------------------------------------

CompareResult_AC CSortedLongintList_AC::Tester::TestItem(ArrayIndex_AC anItem,
														 void* yourDataPtr)
{
	Tester* tester = static_cast<Tester*>(yourDataPtr);
	long current = tester->fList->At(anItem);
	return tester->fTestLong(current, tester->fStaticLink);
}


//========================================================================================
// CLASS CLongintList_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CLongintList_AC destructor
//----------------------------------------------------------------------------------------

CLongintList_AC::~CLongintList_AC()
{
}

//----------------------------------------------------------------------------------------
// CLongintList_AC Clone
//----------------------------------------------------------------------------------------

void* CLongintList_AC::Clone() const
{
	return TH_new CLongintList_AC(*this);
}

//----------------------------------------------------------------------------------------
// CLongintList_AC::DoSearchElement: 
//----------------------------------------------------------------------------------------

bool CLongintList_AC::DoSearchElement(CompareIndexType_AC testItem,
									  void* yourDataPtr,
									  ArrayIndex_AC& index) const
{
	// Go back to the linear search method. 
	return CDynamicArray_AC::DoSearchElement(testItem, yourDataPtr, index);
}

//----------------------------------------------------------------------------------------
// CLongintList_AC::InsertElementInOrder: Overridden to do arrival sequence insertion
//----------------------------------------------------------------------------------------

void CLongintList_AC::InsertElementInOrder(const void* elementPtr)
{
	CDynamicArray_AC::InsertElementInOrder(elementPtr);
}

//----------------------------------------------------------------------------------------
// CLongintList_AC::AtPut: 
//----------------------------------------------------------------------------------------

#if qRangeCheck

void CLongintList_AC::AtPut(ArrayIndex_AC index, long newItem)
{
	ThrowIfRangeCheck(index, "Range Check in CLongintList_AC.AtPut");

	// Replace the index'th element of the list.
	*((long*)ComputeAddress(index)) = newItem;
}

#endif


//----------------------------------------------------------------------------------------
// End of CLongintList_AC.cpp
