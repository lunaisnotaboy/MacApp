//----------------------------------------------------------------------------------------
// TemplateArray_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/09/00	[PB] Suppress GCC warnings about unused return variables. 
		07/24/00	CW Pro 6: casting to/from void*. 
		04/21/00	Initial version. 
*/

#ifndef __TemplateArray_AC__
#include "TemplateArray_AC.h"
#endif

//========================================================================================
// TestStruct
//========================================================================================

struct TestStruct
{
	long fData;
	TestStruct() {}
	TestStruct(long data) : fData(data) {}
};

//========================================================================================
// TestSortedArray
//========================================================================================

class TestSortedArray : public TemplateSortedArray_AC<TestStruct>
{
public:
	TestSortedArray(ArrayIndex_AC initialSize = 0);
	virtual ~TestSortedArray();
	virtual void* Clone() const;
	virtual CompareResult_AC Compare(const TestStruct& record1, const TestStruct& record2) const;

	static CompareResult_AC DataEquals(const TestStruct& record, void* yourDataPtr);
	static void Test();
};

TestSortedArray::TestSortedArray(ArrayIndex_AC initialSize) :
	TemplateSortedArray_AC<TestStruct>(initialSize)
{
}

TestSortedArray::~TestSortedArray()
{
}

void* TestSortedArray::Clone() const
{
	return TH_new TestSortedArray(*this);
}

CompareResult_AC TestSortedArray::Compare(const TestStruct& record1, const TestStruct& record2) const
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;

	if (record1.fData > record2.fData)
		returnVal = kItem1GreaterThanItem2_AC;
	else if (record1.fData < record2.fData)
		returnVal = kItem1LessThanItem2_AC;

	return returnVal;
}

CompareResult_AC TestSortedArray::DataEquals(const TestStruct& record, void* yourDataPtr)
{
	long data = reinterpret_cast<long>(yourDataPtr);
	
	CompareResult_AC returnVal = kItemEqualCriteria_AC;
	if (record.fData > data)
		returnVal = kItemGreaterThanCriteria_AC;
	else if (record.fData < data)
		returnVal = kItemLessThanCriteria_AC;

	return returnVal;
}

void TestSortedArray::Test()
{
	TestSortedArray array;
	array.Insert(TestStruct(1));
	array.Insert(TestStruct(2));
	TestStruct s = array[0];
	s = array.At(1);
	s = array.First();
	s = array.Last();
	array.Push(s);
	s = array.Pop();
	ArrayIndex_AC index = array.GetIdentityItemNo(s);
	index = array.GetEqualItemNo(TestStruct(2));
	
	long sum = 0;
	for (TestSortedArray::Iterator iter(&array); iter; ++iter)
	{
		sum += iter->fData;
	}
	
	TestStruct* t = array.DoSearch(DataEquals, reinterpret_cast<void*>(2), index);
#if qProjectBuilder
	(void) t;
#endif
	index = array.Search(DataEquals, reinterpret_cast<void*>(1));

	array.Delete(s);
	array.DeleteAll();
}


//========================================================================================
// TestArray
//========================================================================================

class TestArray : public TemplateArray_AC<TestStruct>
{
public:
	TestArray(ArrayIndex_AC initialSize = 0);
	virtual ~TestArray();
	virtual void* Clone() const;

	static void Test();
};

TestArray::TestArray(ArrayIndex_AC initialSize) :
	TemplateArray_AC<TestStruct>(initialSize)
{
}

TestArray::~TestArray()
{
}

void* TestArray::Clone() const
{
	return TH_new TestArray(*this);
}

void TestArray::Test()
{
	TestArray array;
	array.Insert(TestStruct(1));
	array.Insert(TestStruct(2));
	array.InsertBefore(2, TestStruct(3));
	array.InsertFirst(TestStruct(4));
	array.InsertLast(TestStruct(5));
	TestStruct s = array[0];
	s = array.At(1);
	s = array.First();
	s = array.Last();
	array.Push(s);
	s = array.Pop();
	ArrayIndex_AC index = array.GetIdentityItemNo(s);
	index = array.GetEqualItemNo(TestStruct(2));
	
	long sum = 0;
	for (TestArray::Iterator iter(&array); iter; ++iter)
	{
		sum += iter->fData;
	}

	array.Delete(s);
	array.DeleteAll();
}


//----------------------------------------------------------------------------------------
// End of TemplateArray_AC.cpp