//----------------------------------------------------------------------------------------
// CListIterator_AC.cpp
// Copyright © 1986-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/10/00	Costmetic.
		09/06/00	Added embedded documentation - CArrayIterator_AC::CArrayIterator_AC - strange format.
		03/24/99	Update copyright notice.
		10/06/98	Clean up includes. 
*/

#ifndef __CListIterator_AC__
#include "CListIterator_AC.h"
#endif

// ACS

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

//========================================================================================
// CLASS CArrayIterator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::CArrayIterator_AC: 
//----------------------------------------------------------------------------------------

CArrayIterator_AC::CArrayIterator_AC(const CDynamicArray_AC*	itsDynamicArray,
									 ArrayIndex_AC				itsLowBound,
									 ArrayIndex_AC				itsHighBound,
									 bool						itsForward)
	:	fCurrentIndex(kEmptyIndex_AC),
		fLowBound(itsLowBound),
		fHighBound(itsHighBound),
		fNextLink(NULL),
		fDynamicArray(itsDynamicArray),
		fIterateForward(itsForward)
// CArrayIterator is a constructor that initializes an instance for iteration
// over dynamic arrays.
// Note:	The iterator instance and for loop is enclosed within its own 
// 			block. This technique is required only if two or more iterators could
//			share the same scope, in which case the wrong failure handler could 
// 			be invoked if the scope is not explicitly constrained.
// Note:	Whenever you create a subclass of CArrayIterator, you typically  
// 			add new methods that return the location of the first, current,  
// 			and next entities in the array.
//
// itsDynamicArray:		specifies the instance of TDynamicArray or one of its 
// 						subclasses over whose elements you want to iterate.
// itsLowBound:			specifies the lower boundary for iteration (the lowest 
// 						valid value is 1). If the constructor does not use 
//						this parameter, the lower boundary is 1.
// itsHighBound:		specifies the upper boundary for iteration. If the 
// 						constructor does not use this parameter, the upper 
//						boundary is the number of elements in the list.
// itsForward:			specifies the direction of iteration: true for forward  
// 						iteration and false for backward iteration. If the 
// 						constructor does not use this parameter, the direction 
//						of iteration is forward.
//
// Call?		As needed. You typically define an instance with these parameters
//				when you want to specify the boundary for iteration over elements 
//				in the dynamic array. If you subclass CArrayIterator, you must 
//				call this constructor from the subclass constructor.
{
	CommonInit();
	First();
}

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::CArrayIterator_AC: 
//----------------------------------------------------------------------------------------

CArrayIterator_AC::CArrayIterator_AC(const CDynamicArray_AC* itsDynamicArray, bool itsForward)
	:	fCurrentIndex(kEmptyIndex_AC),
		fLowBound(1),
		fHighBound(LONG_MAX),
		fNextLink(NULL),
		fDynamicArray(itsDynamicArray),
		fIterateForward(itsForward)
// CArrayIterator is a constructor that initializes an instance for iteration
// over dynamic arrays.
// Note:	The iterator instance and for loop is enclosed within its own 
// 			block. This technique is required only if two or more iterators could
//			share the same scope, in which case the wrong failure handler could 
// 			be invoked if the scope is not explicitly constrained.
// Note:	Whenever you create a subclass of CArrayIterator, you typically  
// 			add new methods that return the location of the first, current,  
// 			and next entities in the array.
//
// itsDynamicArray:		specifies the instance of TDynamicArray or one of its 
// 						subclasses over whose elements you want to iterate.
// itsForward:			specifies the direction of iteration: true for forward  
// 						iteration and false for backward iteration. If the 
// 						constructor does not use this parameter, the direction 
//						of iteration is forward.
//
// Call?		As needed. You typically define an instance with these parameters
//				when you want to specify the boundary for iteration over elements 
//				in the dynamic array. If you subclass CArrayIterator, you must 
//				call this constructor from the subclass constructor.
{
	CommonInit();
	First();
}

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::~CArrayIterator_AC: 
//----------------------------------------------------------------------------------------

CArrayIterator_AC::~CArrayIterator_AC()
{
	if (fDynamicArray)
	{
		const_cast<CDynamicArray_AC*>(fDynamicArray)->RemoveIterator(this);
		fDynamicArray = NULL;
	}
	fNextLink = NULL;
}

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::CommonInit: 
//----------------------------------------------------------------------------------------

void CArrayIterator_AC::CommonInit()
{
	ArrayIndex_AC arraySize = fDynamicArray ? fDynamicArray->GetSize() : 0;

	// Restrict the bounds of the iteration to valid values
	fHighBound = MinMax_AC((ArrayIndex_AC) kEmptyIndex_AC, fHighBound, arraySize);
	fLowBound = MinMax_AC(1, fLowBound, fHighBound + 1);

	// empty iteration
	if (fLowBound > fHighBound)
		fLowBound = fHighBound = kEmptyIndex_AC;

	if (fDynamicArray)
	{
		// link me in to the list of iterations in progress
		fNextLink = const_cast<CDynamicArray_AC*>(fDynamicArray)->InstallIterator(this);
	}
}

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::First: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC CArrayIterator_AC::First()
{
	return fCurrentIndex = fIterateForward ? fLowBound : fHighBound;
}

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::Next: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC CArrayIterator_AC::Next()
{
	return fCurrentIndex = fIterateForward
							? ((fCurrentIndex < fHighBound)
								? fCurrentIndex + 1
								: kEmptyIndex_AC)
							: ((fCurrentIndex > fLowBound)
								? fCurrentIndex - 1
								: kEmptyIndex_AC);
}

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::Deleted: 
//----------------------------------------------------------------------------------------

void CArrayIterator_AC::Deleted(ArrayIndex_AC theIndex, ArrayIndex_AC theCount)
{
	// tuck the endpoints of the iteration in to match
	if (theIndex < fLowBound)
		fLowBound = Max_AC(fLowBound - theCount, theIndex);
	// This is equivalent to:
	//      if (the Index + theCount <= fLowBound)
	//              fLowBound -= theCount;
	//              // whole deleted range is below fLowBound
	//      else
	//              fLowBound = theIndex;
	//              // new index of the first element not deleted

	if (theIndex <= fHighBound)
		fHighBound = Max_AC(fHighBound - theCount, theIndex - 1);
	// Similar: theIndex - 1 is the last element not deleted.

	// Now bend the fCurrentIndex to account for the deletion.
	// In case the current item is deleted, we give fCurrentIndex such a
	// value that AFTER calling the method advance it will point to the next
	// element to be processed.
	if (fIterateForward)
	{
		if (theIndex <= fCurrentIndex)
			fCurrentIndex = Max_AC(fCurrentIndex - theCount, theIndex - 1);
	}
	else
	{											// Iterating backwards
		if (theIndex < fCurrentIndex)
			fCurrentIndex = Max_AC(fCurrentIndex - theCount, theIndex);
	}
}

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::Inserted: 
//----------------------------------------------------------------------------------------

void CArrayIterator_AC::Inserted(ArrayIndex_AC theIndex, ArrayIndex_AC theCount)
{
	// bump the endpoints of this iteration out to match
	if (theIndex <= fLowBound)
		fLowBound += theCount;

	if (theIndex <= fHighBound)
		fHighBound += theCount;

	if (fIterateForward)
	{
		// If the inserted element was !in the range yet to be
		// iterated then bend the fCurrentIndex to account for it.
		if (theIndex <= fCurrentIndex)
			fCurrentIndex += theCount;
	}
	else										// Iterating backward 
	{
		// If the inserted element was IN the range yet to be
		// iterated then bend the fCurrentIndex to account for it.
		if (theIndex < fCurrentIndex)
			fCurrentIndex += theCount;
	}
}

//----------------------------------------------------------------------------------------
// CArrayIterator_AC::AbortIteration: 
//----------------------------------------------------------------------------------------

void CArrayIterator_AC::AbortIteration()
{
	fDynamicArray = NULL;

	fCurrentIndex = fLowBound = fHighBound = kEmptyIndex_AC;
}


//========================================================================================
// CLASS CCommonArrayIterator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CCommonArrayIterator_AC::CCommonArrayIterator_AC: 
//----------------------------------------------------------------------------------------

CCommonArrayIterator_AC::CCommonArrayIterator_AC(const CDynamicArray_AC* itsList,
					ArrayIndex_AC itsLowBound, ArrayIndex_AC itsHighBound,
					bool itsForward)
	:	CArrayIterator_AC(itsList, itsLowBound, itsHighBound, itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CCommonArrayIterator_AC::CCommonArrayIterator_AC: 
//----------------------------------------------------------------------------------------

CCommonArrayIterator_AC::CCommonArrayIterator_AC(const CDynamicArray_AC* itsList, bool itsForward)
	:	CArrayIterator_AC(itsList, itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CCommonArrayIterator_AC::First: 
//----------------------------------------------------------------------------------------

void* CCommonArrayIterator_AC::First()
{
	return fCurrentElement = CArrayIterator_AC::First()
								? fDynamicArray->ComputeAddress(fCurrentIndex)
								: NULL;
}

//----------------------------------------------------------------------------------------
// CCommonArrayIterator_AC::Next: 
//----------------------------------------------------------------------------------------

void* CCommonArrayIterator_AC::Next()
{
	return fCurrentElement = CArrayIterator_AC::Next()
								? fDynamicArray->ComputeAddress(fCurrentIndex)
								: NULL;
}

//========================================================================================
// CLASS CCommonVoidIterator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CCommonVoidIterator_AC::CCommonVoidIterator_AC: 
//----------------------------------------------------------------------------------------

CCommonVoidIterator_AC::CCommonVoidIterator_AC(const CDynamicArray_AC* itsList,
					ArrayIndex_AC itsLowBound, ArrayIndex_AC itsHighBound,
					bool itsForward)
	:	CCommonArrayIterator_AC(itsList, itsLowBound, itsHighBound, itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CCommonVoidIterator_AC::CCommonVoidIterator_AC: 
//----------------------------------------------------------------------------------------

CCommonVoidIterator_AC::CCommonVoidIterator_AC(const CDynamicArray_AC* itsList, bool itsForward)
	:	CCommonArrayIterator_AC(itsList, itsForward)
{
	First();
}

//----------------------------------------------------------------------------------------
// CCommonVoidIterator_AC::First: 
//----------------------------------------------------------------------------------------
void* CCommonVoidIterator_AC::First()
{
	return fCurrent = CCommonArrayIterator_AC::First()
						? *static_cast<void**>(CCommonArrayIterator_AC::Current())
						: NULL;
}

//----------------------------------------------------------------------------------------
// CCommonVoidIterator_AC::CCommonVoidIterator_AC: 
//----------------------------------------------------------------------------------------
void* CCommonVoidIterator_AC::Next()
{
	return fCurrent = CCommonArrayIterator_AC::Next()
						? *static_cast<void**>(CCommonArrayIterator_AC::Current())
						: NULL;
}

//----------------------------------------------------------------------------------------
// End of CListIterator_AC.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Update iterators to be OD stylish.
							Split MDestructo out as a separate class
		04/20/96	Remove implementation of CArrayIterator_AC::operator new
		04/18/96	Use post-increment with iterators in while loops
		04/15/96	Added CArrayIterator_AC::AbortIteration() which is called when the CDynamicArray_AC is deleted
							during iteration. Removed CArrayIterator_AC::fPreviousLink since the links are only used as single links.
		----- R10 -----
		03/30/96	FailInfo has a default constructor so failInfo.Reset was redundant in CArrayIterator_AC constructors
		03/30/96	Move trivial (restacking of parameters) constructors to inline
		03/26/96	Cleanup Iterator::More/Reset to use selection operators
		 3/04/96	Removed inlining for  to
		 					reduce code bulk.
		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		----- 3.3b1 -----
		  6/7/94	Add cleanup proc. 
*/