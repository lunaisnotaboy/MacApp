//----------------------------------------------------------------------------------------
// TemplateList_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/10/00	Cosmetic.
		09/07/00	Added embedded documentation - TestSortedList::Compare.
		07/24/00	CW Pro 6: casting to/from void*. 
		04/21/00	Initial version. 
*/

#ifndef __TemplateList_AC__
#include "TemplateList_AC.h"
#endif

// ACS

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif


//========================================================================================
// TestObject
//========================================================================================

struct TestObject
{
	long fData;
	TestObject(long data) : fData(data) {}
};

//========================================================================================
// TestSortedList
//========================================================================================

class TestSortedList : public TemplateSortedList_AC<TestObject>
{
public:
	TestSortedList(ArrayIndex_AC initialSize = 0);
	virtual ~TestSortedList();
	virtual void* Clone() const;
	virtual CompareResult_AC Compare(const TestObject* object1, const TestObject* object2) const;

	static CompareResult_AC DataEquals(const TestObject* object, void* yourDataPtr);
	static void Test();
};

//----------------------------------------------------------------------------------------
// TestSortedList Constructor
//----------------------------------------------------------------------------------------

TestSortedList::TestSortedList(ArrayIndex_AC initialSize)
	:	TemplateSortedList_AC<TestObject>(initialSize)
{
}

//----------------------------------------------------------------------------------------
// TestSortedList Destructor
//----------------------------------------------------------------------------------------

TestSortedList::~TestSortedList()
{
}

//----------------------------------------------------------------------------------------
// TestSortedList::Clone
//----------------------------------------------------------------------------------------

void* TestSortedList::Clone() const
{
	return TH_new TestSortedList(*this);
}

//----------------------------------------------------------------------------------------
// TestSortedList::Compare
//----------------------------------------------------------------------------------------

CompareResult_AC TestSortedList::Compare(const TestObject* object1, const TestObject* object2) const
// Compare method compares two items in a list. The method compares the 
// ordinal value of the two items and returns one of the constants kItem1LessThanItem2,
// kItem1EqualItem2, or kItem1GreaterThanItem2, according to whether the ordinal value
// of the first parameter is less than, equal to, or greater than the ordinal value of
// the second parameter.
//
// item1:	Specifies one item to be compared.
// item2:	Specifies the other item to be compared.
//
// Call?		Seldom. MacApp calls this method from methods that 
//				implement sorting and searching.
// Override?	As needed, for example to compare a field in the 
//				instances. Your override method should return one of the
// 				constants kItem1LessThanItem2, kItem1EqualItem2, or
// 				kItem1GreaterThanItem2, according to whether item1 is
// 				less than, equal to, or greater than item2.
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;

	if (object1->fData > object2->fData)
		returnVal = kItem1GreaterThanItem2_AC;
	else if (object1->fData < object2->fData)
		returnVal = kItem1LessThanItem2_AC;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TestSortedList::DataEquals
//----------------------------------------------------------------------------------------

CompareResult_AC TestSortedList::DataEquals(const TestObject* object, void* yourDataPtr)
{
	long data = reinterpret_cast<long>(yourDataPtr);
	
	CompareResult_AC returnVal = kItemEqualCriteria_AC;
	if (object->fData > data)
		returnVal = kItemGreaterThanCriteria_AC;
	else if (object->fData < data)
		returnVal = kItemLessThanCriteria_AC;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// TestSortedList::Test
//----------------------------------------------------------------------------------------

void TestSortedList::Test()
{
	TestSortedList list;
	list.Insert(TH_new TestObject(1));
	list.Insert(TH_new TestObject(2));
	TestObject* s = list[0];
	s = list.At(1);
	s = list.First();
	s = list.Last();
	list.Push(s);
	s = list.Pop();
	ArrayIndex_AC index = list.GetIdentityItemNo(s);
	CAutoPtr_AC<TestObject> t = TH_new TestObject(2);
	index = list.GetEqualItemNo(t);
	
	long sum = 0;
	for (TestSortedList::Iterator iter(&list); iter; ++iter)
	{
		sum += iter->fData;
	}
	
	t = list.DoSearch(DataEquals, reinterpret_cast<void*>(2), index);
	index = list.Search(DataEquals, reinterpret_cast<void*>(1));

	list.Delete(s);
	list.DeleteAll();
}


//========================================================================================
// TestList
//========================================================================================

class TestList : public TemplateList_AC<TestObject>
{
public:
	TestList(ArrayIndex_AC initialSize = 0);
	virtual ~TestList();
	virtual void* Clone() const;

	static void Test();
};

//----------------------------------------------------------------------------------------
// TestList Constructor
//----------------------------------------------------------------------------------------

TestList::TestList(ArrayIndex_AC initialSize)
	:	TemplateList_AC<TestObject>(initialSize)
{
}

//----------------------------------------------------------------------------------------
// TestList Destructor
//----------------------------------------------------------------------------------------

TestList::~TestList()
{
}

//----------------------------------------------------------------------------------------
// TestList::Clone
//----------------------------------------------------------------------------------------

void* TestList::Clone() const
{
	return TH_new TestList(*this);
}

//----------------------------------------------------------------------------------------
// TestList::Test
//----------------------------------------------------------------------------------------

void TestList::Test()
{
	TestList list;
	list.Insert(TH_new TestObject(1));
	list.Insert(TH_new TestObject(2));
	list.InsertBefore(2, TH_new TestObject(3));
	list.InsertFirst(TH_new TestObject(4));
	list.InsertLast(TH_new TestObject(5));
	TestObject* s = list[0];
	s = list.At(1);
	list.At(2) = TH_new TestObject(6);
	list[2] = TH_new TestObject(7);
	s = list.First();
	s = list.Last();
	list.Push(s);
	s = list.Pop();
	ArrayIndex_AC index = list.GetIdentityItemNo(s);
	CAutoPtr_AC<TestObject> t = TH_new TestObject(2);
	index = list.GetEqualItemNo(t);
	
	long sum = 0;
	for (TestList::Iterator iter(&list); iter; ++iter)
	{
		sum += iter->fData;
	}

	list.Delete(s);
	list.DeleteAll();
}


//----------------------------------------------------------------------------------------
// End of TemplateList_AC.cpp
