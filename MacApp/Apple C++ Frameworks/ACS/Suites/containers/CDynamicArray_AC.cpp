//----------------------------------------------------------------------------------------
// CDynamicArray_AC.cpp
// Copyright © 1986-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/09/01	In DeleteElementsAt, countBytes used only in debug mode. 
		04/07/01	[PB] In ReleaseSwapBuffer, 'void *' is not a pointer-to-object type. 
		01/02/01	Update copyright.
		11/27/00	DeleteElementsAt now shrinks the array size down to the
					allocation increment instead of zero. This should improve
					performance for lists that are frequently emptied. To force
					the array size to zero, call SetArraySize. 
		11/10/00	Cosmetic.
		11/01/00	[PB] Include MacErrors instead of Errors. Don’t include Packages.h. 
		09/08/00	Added embedded documentation.
		09/01/00	Stripped dead code.
		06/01/00	[2477880] Change size calculation in CDynamicArray_AC copy ctor.
		05/30/00	CSortedDynamicArray_AC::GetIdentityElementNo:
					Final comparision check “index != kEmptyIndex_AC” becomes
					“index == kEmptyIndex_AC”.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		04/25/00	[G] static_cast to <long*> in GetIdentityElementNo.
		04/21/00	Export RandomArrayIndex_AC so it can be used in CSortedVoidList_AC. 
		04/10/00	Optimize CSortedDynamicArray_AC::GetIdentityElementNo to look
					at adjacent elements before falling back to a linear search. 
		03/31/00	static_cast, not const_cast of elementPtr in InsertElementsBefore.
					static_cast current to long*, not const long*, in GetIdentityElementNo.
		12/07/99	Corrected qNeedsMC68020 (was: qMC68020).  CSortedDynamicArray_AC
					copy constructor compiler specialization no longer needed.
		03/24/99	Update copyright notice.
		10/06/98	Clean up includes. 
*/

#ifndef __CDynamicArray_AC__
#include "CDynamicArray_AC.h"
#endif

// ACS

#ifndef __CAutoPtr_AC__
#include "CAutoPtr_AC.h"
#endif

#ifndef __CListIterator_AC__
#include "CListIterator_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CStream_AC__
#include "CStream_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// ANSI

#ifndef __STDLIB__
#include <stdlib.h>
#endif

#ifndef __STRING__
#include <string.h>
#endif


//========================================================================================
// GLOBAL Procedures
//========================================================================================

static CompareResult_AC CompareElements_AC(void* element1,
										   void* element2,
										   void* yourDataPtr);

//========================================================================================
// CLASS CDynamicArray_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CDynamicArray_AC constructor
//----------------------------------------------------------------------------------------

CDynamicArray_AC::CDynamicArray_AC(ArrayIndex_AC initialSize, short elementSize)
	:	fArraySpace(NULL),
		fIteratorPtr(NULL),
		fSize(kEmptyIndex_AC),
		fAllocationIncrement(kAllocationIncrement_AC),
		fAllocatedSize(kEmptyIndex_AC),
		fElementSize(elementSize),
		fElementSizeShift(0)
{
#if qCoreDebug
	if (initialSize < kEmptyIndex_AC)
	{
		::ProgramBreak_AC("initialSize must be non-negative!");
		initialSize = kEmptyIndex_AC;
	}

	if (elementSize <= 0)
	{
		::ProgramBreak_AC("In CDynamicArray_AC.CDynamicArray_AC: preposterous element size. (zero or negative)");
		::ThrowError_AC(minErr);
	}
#endif

	// calculate the elementsizeshift that represents the nearest power of 2 
	while (((elementSize - 1) >> fElementSizeShift) > 0)
		++fElementSizeShift;

	SetArraySize(initialSize);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC copy constructor
//----------------------------------------------------------------------------------------

CDynamicArray_AC::CDynamicArray_AC(const CDynamicArray_AC& inDynamicArray)
	:	MStreamable_AC(inDynamicArray),
		fArraySpace(NULL),
		fIteratorPtr(NULL),
		fSize(inDynamicArray.fSize),
		fAllocationIncrement(inDynamicArray.fAllocationIncrement),
		fAllocatedSize(inDynamicArray.fAllocatedSize),
		fElementSize(inDynamicArray.fElementSize),
		fElementSizeShift(inDynamicArray.fElementSizeShift)
{
	if (inDynamicArray.fArraySpace)
	{
		long itsSize = inDynamicArray.fAllocatedSize << inDynamicArray.fElementSizeShift;
		fArraySpace = TH_new char[itsSize];
			
		BlockMove_AC(inDynamicArray.fArraySpace, fArraySpace, itsSize);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC destructor
//----------------------------------------------------------------------------------------

CDynamicArray_AC::~CDynamicArray_AC()
{
	DeleteAll();

	AbortIteration();

	delete[] fArraySpace;
	fArraySpace = NULL;
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC Clone
//----------------------------------------------------------------------------------------

void* CDynamicArray_AC::Clone() const
{
	return TH_new CDynamicArray_AC(*this);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::ReadFrom: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::ReadFrom(CStream_AC* aStream)
{
	MStreamable_AC::ReadFrom(aStream);

	fElementSize = aStream->ReadInteger();
	fElementSizeShift = aStream->ReadInteger();
	fAllocationIncrement = aStream->ReadLong();

	SetArraySize(0);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::WriteTo: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::WriteTo(CStream_AC* aStream) const
{
	MStreamable_AC::WriteTo(aStream);

	aStream->WriteInteger(fElementSize);
	aStream->WriteInteger(fElementSizeShift);
	aStream->WriteLong(fAllocationIncrement);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::operator[]: 
//----------------------------------------------------------------------------------------

void* CDynamicArray_AC::operator[](ArrayIndex_AC index) const
{
#if qRangeCheck
	::Assertion_AC(fArraySpace != NULL, "Whoops! you called CDynamicArray_AC::operator[] for an empty array");
#endif
	return fArraySpace + (index << fElementSizeShift);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::ComputeAddress: 
//----------------------------------------------------------------------------------------

void* CDynamicArray_AC::ComputeAddress(ArrayIndex_AC index) const
// ComputeAddress returns a pointer to the specified element of the array. 
// The index parameter specifies the element whose pointer will be returned. Note that
// the returned value is a direct heap pointer and should be used with care; the heap
// can be compacted across calls that move memory, thus invalidating the pointer.
//
// index:	An ArrayIndex_AC that specifies the element for which the pointer is computed.
//
// Call?		As needed.
// Override?	NEVER, unless you obtain memory from somewhere 
//				other than the object’s handle.
{
#if qRangeCheck
	::Assertion_AC(fArraySpace != NULL, "Whoops! you called CDynamicArray_AC::ComputeAddress for an empty array");
#endif
	return fArraySpace + ((index - 1) << fElementSizeShift);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::DeleteElement: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::DeleteElement(const void* elementPtr)
{
	ArrayIndex_AC index = GetIdentityElementNo(elementPtr);
	if (index != kEmptyIndex_AC)
		DeleteElementsAt(index, 1);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::DeleteElementsAt: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::DeleteElementsAt(ArrayIndex_AC index,
										ArrayIndex_AC count)
// DeleteElementsAt deletes the elements at the specified index and compresses 
// the array.
//
// index:	An ArrayIndex_AC that specifies the element at which deletion starts.
// count:	An ArrayIndex_AC that specifies the number of elements to delete.
//
// Call?		Seldom.
// Override?	NEVER. It is not virtual.
{
#if qRangeCheck
	RangeCheck(index, "Range Check in CDynamicArray_AC.DeleteElementsAt");
#endif

	if (count > kEmptyIndex_AC)
	{
		void* indexPtr = ComputeAddress(index);
		void* nextElementPtr = ComputeAddress(index + count);
		void* lastElementPtr = ComputeAddress(fSize + 1);
	
		if (nextElementPtr < lastElementPtr)		// deleted from middle? Compress the array 
			BlockMoveOverlap_AC(nextElementPtr, indexPtr, reinterpret_cast<ptrdiff_t>(lastElementPtr) - reinterpret_cast<ptrdiff_t>(nextElementPtr));
	
#if qCoreDebug
		ArrayIndex_AC countBytes = count << fElementSizeShift;
		BlockSet_AC(static_cast<Ptr>( lastElementPtr) - countBytes, countBytes, kResizedInitVal_AC);
#endif
	
		ArrayIndex_AC newSize = fSize - count;
		if (newSize > fAllocationIncrement)
		{
			// For efficiency, don't completely delete the array space
			// when deleting elements. 
			// Take up slack if necessary. 
			// Should never fail when shrinking array.
			SetArraySize(newSize, true);	
		}
		fSize = newSize;
	
		// Keep all iterations apprised
		Deleted(index, count);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::DeleteAll: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::DeleteAll()
// DeleteAll deletes all elements from the list and sets fSize to 0, but does 
// not free the list instance itself.
//
// Call?		As needed.
// Override?	NEVER. It is not virtual.
{
	if (fSize)
		DeleteElementsAt(1, fSize);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::GetElement: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::GetElement(ArrayIndex_AC index, void* elementPtr) const
{
#if qRangeCheck
	RangeCheck(index, "Range Check in CDynamicArray_AC::GetElement");
#endif

	if (fElementSize == sizeof(long)) // shortcut for longs
		*static_cast<long*>(elementPtr) = *static_cast<long*>(ComputeAddress(index));
	else
		BlockMove_AC(ComputeAddress(index), (Ptr)elementPtr, fElementSize);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::GetElementsAt: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::GetElementsAt(ArrayIndex_AC index,
									 void* elementPtr,
									 ArrayIndex_AC count) const
{
#if qRangeCheck
	RangeCheck(index, "Range Check in CDynamicArray_AC::GetElementsAt");
#endif

	// The count computation for this move makes sure that if the element size is not
	// a power of 2 that we don't copy more bytes back to the caller than required for a
	// given number of elements sending the caller into orbit and heading straight for the
	// Excedrin.

	// !!! NOTE MULTIPLE (> 1) element moves for non-power of 2 element sizes are not yet
	// supported!

	if (count > kEmptyIndex_AC)
		BlockMove_AC(ComputeAddress(index), (Ptr)elementPtr, ((count - 1) << fElementSizeShift) + fElementSize);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::InsertElementInOrder: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::InsertElementInOrder(const void* elementPtr)
{
	InsertElementsBefore(fSize + 1, elementPtr, 1);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::InsertElementsBefore: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::InsertElementsBefore(ArrayIndex_AC index,
											const void* elementPtr,
											ArrayIndex_AC count)
{
#if qRangeCheck
	RangeCheckInsert(index, "Range Check in CDynamicArray_AC.InsertElementsBefore");
#endif

	if (count > kEmptyIndex_AC)
	{
		if (fSize + count > fAllocatedSize)
			SetArraySize(fSize + count, false);			// make sure there's room if needed 
	
		ArrayIndex_AC countBytes = count << fElementSizeShift;
	
		void* indexPtr = ComputeAddress(index);
		void* nextIndexPtr = ComputeAddress(index + count);
		void* lastElementPtr = ComputeAddress(fSize + 1);
	
		if (index <= fSize)							// clear out a hole? 
			BlockMoveOverlap_AC(indexPtr, nextIndexPtr, reinterpret_cast<ptrdiff_t>(lastElementPtr) - reinterpret_cast<ptrdiff_t>(indexPtr));
	
		// !!! we still don't account for multiple element moves with non power of 2 element sizes.
		// Would it be best to create a MoveElements method and put the smarts in it?
	
		if ((countBytes == sizeof(long))
#if !(qPowerPC || qNeedsMC68020)
		&& !Odd_AC((Ptr)elementPtr) && !Odd_AC(indexPtr) /* test for processor that can't stand odd pointers */
#endif
		)
			*static_cast<long*>(indexPtr) = *static_cast<const long*>(elementPtr);// shortcut for longs 
		else
			BlockMove_AC((Ptr)elementPtr, indexPtr, countBytes);// longcut for shorts (and other sizes) 
	
		fSize += count;
	
		// Keep all iterations apprised
		Inserted(index, count);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::Merge: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::Merge(const CDynamicArray_AC* aDynamicArray)
{
#if qCoreDebug
	if ((fElementSize != aDynamicArray->fElementSize) || (fElementSizeShift != aDynamicArray->fElementSizeShift))
		::ProgramBreak_AC("In CDynamicArray_AC.Merge: fElementSize or fElementSizeShift don't match with the CDynamicArray_AC to merge!");
#endif

	ArrayIndex_AC arraySize = aDynamicArray->GetSize();
	if (arraySize != kEmptyIndex_AC)
	{
		// Force the memory move before the call to ComputeAddress.
		SetArraySize(GetSize() + arraySize, true);
		InsertElementsBefore(GetSize() + 1, aDynamicArray->ComputeAddress(1), arraySize);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::ReplaceElement: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::ReplaceElement(const void* elementPtr, const void* newElement)
{
	DeleteElement(elementPtr);
	InsertElementInOrder(newElement);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::ReplaceElementsAt: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::ReplaceElementsAt(ArrayIndex_AC index,
										 const void* elementPtr,
										 ArrayIndex_AC count)
{
#if qRangeCheck
	RangeCheck(index, "Range Check in CDynamicArray_AC.ReplaceElementsAt");
#endif

	if (count > kEmptyIndex_AC)
		BlockMove_AC((Ptr)elementPtr, ComputeAddress(index), count << fElementSizeShift);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::PopElement: LIFO stack pop
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::PopElement(void* elementPtr)
{
#if qRangeCheck
	RangeCheck(1, "Range Check in CDynamicArray_AC.PopElement");
#endif
	if (fSize > 0)
	{
		GetElement(fSize, elementPtr);
		DeleteElementsAt(fSize, 1);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::SetArraySize: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::SetArraySize(ArrayIndex_AC theSize, bool canShrink)
{
	if ((theSize > fAllocatedSize) || (canShrink && (fAllocatedSize - theSize >= fAllocationIncrement)))
	{
#if qCoreDebug
		if (fAllocationIncrement < 0)
			::ProgramBreak_AC("fAllocationIncrement < 0 !  You have serious problems.");
#endif
		// Round up the # of allocated elements to the next multiple of fAllocationIncrement.
		ArrayIndex_AC newAllocatedSize = theSize;
		if ((theSize > 0) && (fAllocationIncrement > 0))
			newAllocatedSize = ((theSize - 1) / fAllocationIncrement + 1) * fAllocationIncrement;

		if (newAllocatedSize != fAllocatedSize)
		{
			if (newAllocatedSize)
			{
				try
				{
					// This process could be much more efficient if we could use reallocate
					// instead of always doing an allocate/copy/delete. The problem is that
					// TidyHeap doesn't have a reallocate method. We could go around TidyHeap
					// and use the memory heap's reallocate method, but it would be nice if
					// we could continue to have TidyHeap tracking our array space. The other
					// thing that would help is if the memory heap's reallocate method were
					// smarter about shrinking blocks. If the space being freed at the end
					// of the block is large enough, it could be converted to a free block and
					// added to the free list with no need to do any allocation or copying. 
					
					void* newPtr = TH_new char[ newAllocatedSize << fElementSizeShift ];

					if (fArraySpace)
					{
						Size moveSize = Min_AC(fSize, theSize);
						moveSize = moveSize << fElementSizeShift;
						BlockMove_AC(fArraySpace, newPtr, moveSize);

						delete[] fArraySpace;
					}
					fArraySpace = (Ptr)newPtr;
				}
				catch(CException_AC& theException)
				{
					DoCatchMessage_AC(theException);
					if (theSize <= fSize) // shrinking the space, just leave the old pointer, don't fail
						;
					else
						throw; // Growing the space, just leave the old pointer, but fail
				}
			}
			else
			{
				delete[] fArraySpace;
				fArraySpace = NULL;
			}
		}
		fAllocatedSize = newAllocatedSize;
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::DoSearchElement: 
//----------------------------------------------------------------------------------------

bool CDynamicArray_AC::DoSearchElement(CompareIndexType_AC	testItem,
									   void*				yourDataPtr,
									   ArrayIndex_AC&		index) const
{
	bool returnVal = false;

	for (Iterator iter(this); iter.Current(); ++iter)
		if (testItem(iter.Current(), yourDataPtr) == kItem1EqualItem2_AC)
		{
			index = iter.Current();
			returnVal = true;
			break;
		}

	if (!returnVal)
		index = fSize + 1;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::GetIdentityElementNo: Find the first reference to the IDENTITY item in
// the list. If item does not occur, return 0.
//----------------------------------------------------------------------------------------

ArrayIndex_AC CDynamicArray_AC::GetIdentityElementNo(const void* elementPtr) const
{
	ArrayIndex_AC result = 0;

	// Compare the items directly instead of calling CompareElements because
	// the default implementation of CompareElements always returns 'equal' so
	// there may be unsorted subclasses of sorted lists. 
	
	if (fElementSize == sizeof(long)) // shortcut for longs
	{
		for (Iterator iter(this); iter.Current(); ++iter)
		{
			void* current = ComputeAddress(iter.Current());
			if (*static_cast<long*>(current) == *static_cast<const long*>(elementPtr))
			{
				result = iter.Current();
				break;
			}
		}
	}
	else
	{
		for (Iterator iter(this); iter.Current(); ++iter)
		{
			void* current = ComputeAddress(iter.Current());
			if (memcmp(current, elementPtr, fElementSize) == 0)
			{
				result = iter.Current();
				break;
			}
		}
	}

	return result;
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::GetEqualElementNo: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC CDynamicArray_AC::GetEqualElementNo(const void* elementPtr) const
{
	ArrayIndex_AC result = 0;

	for (Iterator iter(this); iter.Current(); ++iter)
	{
		void* current = ComputeAddress(iter.Current());
		if (CompareElements(elementPtr, current) == kItem1EqualItem2_AC)
		{
			result = iter.Current();
			break;
		}
	}

	return result;
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::IdentityElements: 
//----------------------------------------------------------------------------------------

bool CDynamicArray_AC::IdentityElements(const void* element1, const void* element2) const
{
	return (fElementSize == sizeof(long)) ?	// shortcut for longs
		(*static_cast<const long*>(element1) == *static_cast<const long*>(element2)) :
		(memcmp(element1, element2, fElementSize) == 0);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::CompareElements: 
//----------------------------------------------------------------------------------------

CompareResult_AC CDynamicArray_AC::CompareElements(const void* /*element1*/, const void* /*element2*/) const
{
	// By Default consider all items equal 
	return kItem1EqualItem2_AC;
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::Sort: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::Sort()
{
	if (GetSize() > 0)
	{
		void* swapBuffer = GetSwapBuffer();
		QuickSort(1, fSize, &::CompareElements_AC, this, swapBuffer);
		ReleaseSwapBuffer(swapBuffer);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::SortBy: NOTE: This doesn't work with a CompareItems Function that inserts
// or deletes elements.
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::SortElementsBy(CompareElementsType_AC CompareItems,
									  void* yourDataPtr)
{
	if (GetSize() > 0)
	{
		void* swapBuffer = GetSwapBuffer();
		QuickSort(1, fSize, CompareItems, yourDataPtr, swapBuffer);
		ReleaseSwapBuffer(swapBuffer);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::QuickSort: 
//----------------------------------------------------------------------------------------

void* CDynamicArray_AC::GetSwapBuffer()
{
	return (fElementSize == sizeof(long)) ? NULL : TH_new char[fElementSize];
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::QuickSort: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::ReleaseSwapBuffer(void* swapBuffer)
{
	if (fElementSize != sizeof(long))
		delete[] static_cast<char*>(swapBuffer);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::QuickSort: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::SwapElements(void* element1, void* element2, void* swapBuffer)
{
	if (fElementSize == sizeof(long)) // shortcut for longs
	{
		register long swapLong = *static_cast<long*>(element1);
		*static_cast<long*>(element1) = *static_cast<long*>(element2);
		*static_cast<long*>(element2) = swapLong;
	}
	else
	{
		BlockMove_AC(element1, swapBuffer, fElementSize);
		BlockMove_AC(element2, element1, fElementSize);
		BlockMove_AC(swapBuffer, element2, fElementSize);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::QuickSort: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::QuickSort(ArrayIndex_AC beginIndex, // p
								 ArrayIndex_AC endIndex, // r
								 CompareElementsType_AC CompareItems,
								 void* yourDataPtr,
								 void* swapBuffer)
{
	if (beginIndex < endIndex)
	{
		ArrayIndex_AC left = QSRandomPartition(beginIndex, endIndex, CompareItems, yourDataPtr, swapBuffer);
		QuickSort(beginIndex, left, CompareItems, yourDataPtr, swapBuffer);
		QuickSort(left + 1, endIndex, CompareItems, yourDataPtr, swapBuffer);
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::QSPartition: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC CDynamicArray_AC::QSPartition(ArrayIndex_AC beginIndex, // p
											ArrayIndex_AC endIndex, // r
											CompareElementsType_AC CompareItems,
											void* yourDataPtr,
											void* swapBuffer)
{
	if (beginIndex >= endIndex)
		return endIndex;
	{
		void* pivot = ComputeAddress(beginIndex);		// x
		ArrayIndex_AC i = beginIndex - 1;			// p - 1
		ArrayIndex_AC j = endIndex + 1;			// r + 1
		for(;;)
		{
			void* secondKey;
			do
			{
				--j;
				secondKey = ComputeAddress(j);				// A[j]
			} while (CompareItems(pivot, secondKey, yourDataPtr) <= kItem1LessThanItem2_AC);

			do
			{
				++i;
				secondKey = ComputeAddress(i);				// A[i]
			} while (CompareItems(pivot, secondKey, yourDataPtr) >= kItem1GreaterThanItem2_AC);

			if (i < j)
			{
				// Swap the elements
				SwapElements(ComputeAddress(i), ComputeAddress(j), swapBuffer);
			}
			else
				return j;
		}
	}

	return 0;									// this return statement is never executed, but exists to defeat an xlC warning
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::QSRandomPartition: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC CDynamicArray_AC::QSRandomPartition(ArrayIndex_AC beginIndex, // p
												  ArrayIndex_AC endIndex, // r
												  CompareElementsType_AC CompareItems,
												  void* yourDataPtr,
												  void* swapBuffer)
{
	ArrayIndex_AC i = RandomArrayIndex_AC(beginIndex, endIndex);

	// exchange
	SwapElements(ComputeAddress(beginIndex), ComputeAddress(i), swapBuffer);

	return QSPartition(beginIndex, endIndex, CompareItems, yourDataPtr, swapBuffer);
}

//----------------------------------------------------------------------------------------
// RandomArrayIndex_AC: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC RandomArrayIndex_AC(ArrayIndex_AC beginIndex,
								  ArrayIndex_AC endIndex)
{
	ArrayIndex_AC returnVal = beginIndex;
	if (beginIndex != endIndex)
		returnVal += rand() % labs(endIndex - beginIndex);

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CompareObjects: 
//----------------------------------------------------------------------------------------

CompareResult_AC CompareElements_AC(void* element1,
									void* element2,
									void* yourDataPtr)
{
	return static_cast<CDynamicArray_AC*>(yourDataPtr)->CompareElements(element1, element2);
}


//----------------------------------------------------------------------------------------
// Iteration
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::InstallIterator
//----------------------------------------------------------------------------------------

CArrayIterator_AC* CDynamicArray_AC::InstallIterator(CArrayIterator_AC* iterator)
{
	CArrayIterator_AC* nextLink = fIteratorPtr;
	fIteratorPtr = iterator;
	return nextLink;
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::RemoveIterator
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::RemoveIterator(CArrayIterator_AC* iterator)
{
	// Support unlinking from the middle of the list so it's ok if iterators
	// are destroyed in a different order than they were created. For example, 
	// it should be ok to create persistant iterators on the heap. 

	CArrayIterator_AC* previous = NULL;
	CArrayIterator_AC* current = fIteratorPtr;
	while (current)
	{
		if (current == iterator)
		{
			if (previous)
				previous->SetNextLink(iterator->NextLink());
			else
				fIteratorPtr = iterator->NextLink();

			iterator->SetNextLink(NULL);
			break;
		}
		else
		{
			previous = current;
			current = current->NextLink();
		}
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::Deleted: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::Deleted(ArrayIndex_AC theIndex, ArrayIndex_AC theCount) const
{
	CArrayIterator_AC* iterator = fIteratorPtr;
	while (iterator)
	{
		iterator->Deleted(theIndex, theCount);
		iterator = iterator->NextLink();
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::Inserted: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::Inserted(ArrayIndex_AC theIndex, ArrayIndex_AC theCount) const
{
	CArrayIterator_AC* iterator = fIteratorPtr;
	while (iterator)
	{
		iterator->Inserted(theIndex, theCount);
		iterator = iterator->NextLink();
	}
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::AbortIteration: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::AbortIteration() const
{
	CArrayIterator_AC* iterator = fIteratorPtr;
	while (iterator)
	{
		iterator->AbortIteration();
		iterator = iterator->NextLink();
	}
}

//----------------------------------------------------------------------------------------
// Range Checking
//----------------------------------------------------------------------------------------

#if qRangeCheck

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::RangeCheck: 
//----------------------------------------------------------------------------------------

CError_AC CDynamicArray_AC::RangeCheck(ArrayIndex_AC index, const char* debugString) const
{
	CError_AC error;

	if ((index < 1) || (index > fSize))
	{
#if qDebugMsg
		ProgramReport_AC("fSize == %1d  index == %1d\n", fSize, index);
#endif
		if (debugString)
			ProgramBreak_AC(debugString);
		
		error = dsChkErr;
	}
	else
		error = noErr;

	return error;
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::RangeCheckInsert:
//----------------------------------------------------------------------------------------

CError_AC CDynamicArray_AC::RangeCheckInsert(ArrayIndex_AC index, const char* debugString) const
{
	CError_AC error;

	if ((index < 1) || (index > fSize + 1))
	{
#if qDebugMsg
		ProgramReport_AC("fSize == %1d  index == %1d\n", fSize, index);
#endif
		if (debugString)
			ProgramBreak_AC(debugString);

		error = dsChkErr;
	}
	else
		error = noErr;

	return error;
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::ThrowIfRangeCheck: 
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::ThrowIfRangeCheck(ArrayIndex_AC index, const char* debugString) const
{
	ThrowIfError_AC( RangeCheck(index, debugString) );
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::ThrowIfRangeCheckInsert:
//----------------------------------------------------------------------------------------

void CDynamicArray_AC::ThrowIfRangeCheckInsert(ArrayIndex_AC index, const char* debugString) const
{
	ThrowIfError_AC( RangeCheckInsert(index, debugString) );
}

#endif // qRangeCheck


//========================================================================================
// CLASS CDynamicArray_AC::CWhileShrinking
//========================================================================================

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::CWhileShrinking constructor
//----------------------------------------------------------------------------------------

CDynamicArray_AC::CWhileShrinking::CWhileShrinking(CDynamicArray_AC* array) :
	fArray(array),
	fSaveIncrement(array->GetAllocationIncrement())
{
	fArray->SetAllocationIncrement(fArray->GetSize());
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::CWhileShrinking destructor
//----------------------------------------------------------------------------------------

CDynamicArray_AC::CWhileShrinking::~CWhileShrinking()
{
	fArray->SetAllocationIncrement(fSaveIncrement);
	fArray->SetArraySize(fArray->GetSize());
}


//========================================================================================
// CLASS CDynamicArray_AC::CWhileInserting
//========================================================================================

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::CWhileInserting constructor
//----------------------------------------------------------------------------------------

CDynamicArray_AC::CWhileInserting::CWhileInserting(CDynamicArray_AC* array, ArrayIndex_AC increment) :
	fArray(array),
	fSaveIncrement(array->GetAllocationIncrement())
{
	fArray->SetAllocationIncrement(increment);
}

//----------------------------------------------------------------------------------------
// CDynamicArray_AC::CWhileInserting destructor
//----------------------------------------------------------------------------------------

CDynamicArray_AC::CWhileInserting::~CWhileInserting()
{
	fArray->SetAllocationIncrement(fSaveIncrement);
	fArray->SetArraySize(fArray->GetSize());
}


//========================================================================================
// CLASS CSortedDynamicArray_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CSortedDynamicArray_AC destructor
//----------------------------------------------------------------------------------------

CSortedDynamicArray_AC::~CSortedDynamicArray_AC()
{
}

//----------------------------------------------------------------------------------------
// CSortedDynamicArray_AC Clone
//----------------------------------------------------------------------------------------

void* CSortedDynamicArray_AC::Clone() const
{
	return TH_new CSortedDynamicArray_AC(*this);
}

//----------------------------------------------------------------------------------------
// CSortedDynamicArray_AC::DoSearchElement: DON'T use exit to get out of this routine from
// your testItem function or you will be really sad! (our debugger will check for you)
// That's why you can return true to stop enumerating. Signaling Failure is OK too.
//----------------------------------------------------------------------------------------

bool CSortedDynamicArray_AC::DoSearchElement(CompareIndexType_AC	testItem,
											 void*					yourDataPtr,
											 ArrayIndex_AC&			index) const
{
	bool found = false;

	if (fSize == kEmptyIndex_AC)
		index = 1;
	else
	{
		CompareResult_AC aCompareResult;
		Iterator iter(this);
		do
		{
			// (fLowBound + fHighBound) / 2
			iter.fCurrentIndex = (iter.fLowBound + iter.fHighBound) >> 1;

			aCompareResult = testItem(iter.fCurrentIndex, yourDataPtr);

			if (aCompareResult <= kItemGreaterThanCriteria_AC)
				iter.fHighBound = iter.fCurrentIndex - 1;
			else
				iter.fLowBound = iter.fCurrentIndex + 1;

		}
		while (!((aCompareResult == kItemEqualCriteria_AC) || (iter.fLowBound > iter.fHighBound)));

		if (aCompareResult == kItemEqualCriteria_AC)
			found = true;
		else if (aCompareResult >= kItemLessThanCriteria_AC)
			++iter.fCurrentIndex;

		// keep index in range 
		index = ((iter.fCurrentIndex < 1) || (iter.fCurrentIndex > fSize + 1)) ? kEmptyIndex_AC : iter.fCurrentIndex;
	}

	return found;
}

//----------------------------------------------------------------------------------------
// CSortedDynamicArray_AC::InsertElementInOrder: 
//----------------------------------------------------------------------------------------

void CSortedDynamicArray_AC::InsertElementInOrder(const void* elementPtr)
{
	ArrayIndex_AC index;
	Searcher(elementPtr, this).DoSearchElement(index);
	InsertElementsBefore(index, elementPtr, 1);
}

//----------------------------------------------------------------------------------------
// CSortedDynamicArray_AC::GetIdentityElementNo
//----------------------------------------------------------------------------------------

ArrayIndex_AC CSortedDynamicArray_AC::GetIdentityElementNo(const void* elementPtr) const
// GetIdentityElementNo finds the first reference to the IDENTITY item in
// the list. If item does not occur, return kEmptyIndex_AC (0).
{
	// First try a binary search for an equal item. 
	ArrayIndex_AC index = GetEqualElementNo(elementPtr);

	// An equal item is not necessarily the same item. 
	if ((index != kEmptyIndex_AC) && !IdentityElements(ComputeAddress(index), elementPtr))
	{
		ArrayIndex_AC found = kEmptyIndex_AC;

		{
			// Back up until we find the identity item or a non-equal item. 
			for (Iterator iter(this, 1, index - 1, kIterateBackward_AC); iter.Current(); ++iter)
			{
				if (IdentityElements(ComputeAddress(iter.Current()), elementPtr))
				{
					found = iter.Current();
					break;
				}

				if (!CompareElements(ComputeAddress(iter.Current()), elementPtr))
					break;
			}
		}

		if (found == kEmptyIndex_AC)
		{
			// Go forward until we find the identity item or a non-equal item. 
			for (Iterator iter(this, index + 1, fSize); iter.Current(); ++iter)
			{
				if (IdentityElements(ComputeAddress(iter.Current()), elementPtr))
				{
					found = iter.Current();
					break;
				}

				if (!CompareElements(ComputeAddress(iter.Current()), elementPtr))
					break;
			}
		}
		
		index = found;
	}

	// If we haven't found the element by now, it may be out of order. 
	if (index == kEmptyIndex_AC)
	{
		// Fall back to linear search. 
		index = CDynamicArray_AC::GetIdentityElementNo(elementPtr);
	}

	return index;
}

//----------------------------------------------------------------------------------------
// CSortedDynamicArray_AC::GetEqualElementNo: 
//----------------------------------------------------------------------------------------

ArrayIndex_AC CSortedDynamicArray_AC::GetEqualElementNo(const void* elementPtr) const
{
	// Find a reference to an equal item in the list.
	// If item does not occur, return kEmptyIndex_AC (0).
	ArrayIndex_AC index;
	return Searcher(elementPtr, this).DoSearchElement(index) ? index : kEmptyIndex_AC;
}

//========================================================================================
// CLASS CSortedDynamicArray_AC::Searcher
//========================================================================================

//----------------------------------------------------------------------------------------
// CSortedDynamicArray_AC::Searcher::TestItem: 
//----------------------------------------------------------------------------------------

CompareResult_AC CSortedDynamicArray_AC::Searcher::TestItem(ArrayIndex_AC anItem,
															void* yourDataPtr)
{
	const Searcher* searcher = static_cast<Searcher*>(yourDataPtr);
	void* element2 = searcher->fDynamicArray->ComputeAddress(anItem);
	return searcher->fDynamicArray->CompareElements(searcher->fElementPtr, element2);
}


//----------------------------------------------------------------------------------------
// End of CDynamicArray_AC.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		06/17/96	[1357773] Memory Leak in CDynamicArray_AC::ReleaseSwapBuffer
		06/09/96	Removed UStreamable to a separate file from UObject
		06/06/96	Fix Symantec compiler complaint inside of SetArraySize.
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		04/30/96	Remove dependencies on OD mem manager.
		04/30/96	Make all constructors use initialization lists if they weren't already
							doing do. Switch several more empty constructors to inlines.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		 4/20/96	Use operator new to create the CDynamicArray_AC's data
		----- R10 -----
		 3/29/96	made element parameter to InsertElementsBefor/ReplaceElementsAt const
		 3/27/96	Made CDynamicArray_AC::ComputeAddress non-inline
		 3/27/96	Made CDynamicArray_AC primitives non-virtual and inline where possible
		 					and made data members protected
		  3/8/96	[1323793] Changed DisposeHandle to DisposeIfHandle_AC in Free. Added 
		  					SetArraySize(0) to ReadFrom.
		03/04/96	[1325889] Remove bogus comments refering to SetDynamicSize
							and 2.0 compatiblity.
		 2/13/96	Switch to MemHeap from ObjectHeap as part of upgrade to ODMemMgr

		12/19/95	1222953 (Optionally) Used new/delete for TDynamicarray store. Removed Lock method.
		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		----- 3.3b1 -----
		 4/14/95	cosmetic
		 4/12/95	Use #if instead of if for qDebug, qRangeCheck. 
		 					Conditionalize printf on qDebugMsg. 
		 3/17/95	MAVolatile. 
		 3/13/95	Change Free methods to destructors. 
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		02/08/95	replace usage of staticLink with yourDataPtr. 
		02/07/95	Create missing prototypes for static functions used internally. 
		 7/29/92	Add the Lock method that was in TObject to CDynamicArray_AC
*/