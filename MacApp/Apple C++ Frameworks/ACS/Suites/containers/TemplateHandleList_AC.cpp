//----------------------------------------------------------------------------------------
// TemplateHandleList_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/10/00	Cosmetic.
		09/07/00	Added embedded documentation - TestSortedHandleList::Compare.
		08/09/00	Moved include of CTidyHeap_AC.h into header to support
							TH_new in inlines.
		07/24/00	CW Pro 6: casting to/from void*. 
		04/21/00	Initial version. 
*/

#ifndef __TemplateHandleList_AC__
#include "TemplateHandleList_AC.h"
#endif

//========================================================================================
// Structs
//========================================================================================

struct TestRecord
{
	long fData;
};
typedef TestRecord** TestHandle;

static TestHandle NewTestHandle(long data)
{
	TestHandle h = reinterpret_cast<TestHandle>(NewHandle(sizeof(TestRecord)));
	ThrowIfNULL_AC(h);
	(*h)->fData = data;
	return h;
}

//========================================================================================
// TestSortedHandleList
//========================================================================================

class TestSortedHandleList : public TemplateSortedHandleList_AC<TestHandle>
{
public:
	TestSortedHandleList(ArrayIndex_AC initialSize = 0);
	virtual ~TestSortedHandleList();
	virtual void* Clone() const;
	virtual CompareResult_AC Compare(const TestHandle item1, const TestHandle item2) const;

	static CompareResult_AC DataEquals(const TestHandle item, void* yourDataPtr);
	static void Test();
};

//------------------------------------------------------------------------------------
// TestSortedHandleList Constructor
//------------------------------------------------------------------------------------

TestSortedHandleList::TestSortedHandleList(ArrayIndex_AC initialSize)
	:	TemplateSortedHandleList_AC<TestHandle>(initialSize)
{
}

//------------------------------------------------------------------------------------
// TestSortedHandleList Destructor
//------------------------------------------------------------------------------------

TestSortedHandleList::~TestSortedHandleList()
{
}

//------------------------------------------------------------------------------------
// TestSortedHandleList::Clone
//------------------------------------------------------------------------------------

void* TestSortedHandleList::Clone() const
{
	return TH_new TestSortedHandleList(*this);
}

//------------------------------------------------------------------------------------
// TestSortedHandleList::Compare
//------------------------------------------------------------------------------------

CompareResult_AC TestSortedHandleList::Compare(const TestHandle item1, const TestHandle item2) const
// The Compare method compares two items in a list. The method compares the ordinal 
// value of the two items and returns one of the constants kItem1LessThanItem2, kItem1EqualItem2,
// or kItem1GreaterThanItem2, according to whether the ordinal value of the first parameter
// is less than, equal to, or greater than the ordinal value of the second parameter.
//
// item1:	Specifies one item to be compared.
// item2:	Specifies the other item to be compared.
//
// Call?		Seldom.
// Override?	As needed, if you want to compare the data pointed 
//				to by the handles instead of comparing the values
// 				of the handles themselves. In your override method,
// 				you should return one of the constants kItem1LessThanItem2,
// 				kItem1EqualItem2, or kItem1GreaterThanItem2, according to 
// 				whether the first handle is less than, equal to, or greater
// 				than the second handle.
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;

	if ((*item1)->fData > (*item2)->fData)
		returnVal = kItem1GreaterThanItem2_AC;
	else if ((*item1)->fData < (*item2)->fData)
		returnVal = kItem1LessThanItem2_AC;

	return returnVal;
}

//------------------------------------------------------------------------------------
// TestSortedHandleList::DataEquals
//------------------------------------------------------------------------------------

CompareResult_AC TestSortedHandleList::DataEquals(const TestHandle item, void* yourDataPtr)
{
	long data = reinterpret_cast<long>(yourDataPtr);
	
	CompareResult_AC returnVal = kItemEqualCriteria_AC;
	if ((*item)->fData > data)
		returnVal = kItemGreaterThanCriteria_AC;
	else if ((*item)->fData < data)
		returnVal = kItemLessThanCriteria_AC;

	return returnVal;
}

//------------------------------------------------------------------------------------
// TestSortedHandleList::Test
//------------------------------------------------------------------------------------

void TestSortedHandleList::Test()
{
	TestSortedHandleList list;
	list.Insert(NewTestHandle(1));
	list.Insert(NewTestHandle(2));
	TestHandle s = list[0];
	s = list.At(1);
	s = list.First();
	s = list.Last();
	list.Push(s);
	s = list.Pop();
	ArrayIndex_AC index = list.GetIdentityItemNo(s);
	TemplateTempHandle<TestHandle> t = NewTestHandle(2);
	index = list.GetEqualItemNo(t);
	
	long sum = 0;
	for (TestSortedHandleList::Iterator iter(&list); iter; ++iter)
	{
		sum += (*iter)->fData;
	}
	
	t = list.DoSearch(DataEquals, reinterpret_cast<void*>(2), index);
	index = list.Search(DataEquals, reinterpret_cast<void*>(1));

	list.Delete(s);
	list.DeleteAll();
}

//========================================================================================
// TestHandleList
//========================================================================================

class TestHandleList : public TemplateHandleList_AC<TestHandle>
{
public:
	TestHandleList(ArrayIndex_AC initialSize = 0);
	virtual ~TestHandleList();
	virtual void* Clone() const;

	static void Test();
};

//------------------------------------------------------------------------------------
// TestHandleList Constructor
//------------------------------------------------------------------------------------

TestHandleList::TestHandleList(ArrayIndex_AC initialSize)
	:	TemplateHandleList_AC<TestHandle>(initialSize)
{
}

//------------------------------------------------------------------------------------
// TestHandleList Destructor
//------------------------------------------------------------------------------------

TestHandleList::~TestHandleList()
{
}

//------------------------------------------------------------------------------------
// TestHandleList::Clone
//------------------------------------------------------------------------------------

void* TestHandleList::Clone() const
{
	return TH_new TestHandleList(*this);
}

//------------------------------------------------------------------------------------
// TestHandleList::Test
//------------------------------------------------------------------------------------

void TestHandleList::Test()
{
	TestHandleList list;
	list.Insert(NewTestHandle(1));
	list.Insert(NewTestHandle(2));
	list.InsertBefore(2, NewTestHandle(3));
	list.InsertFirst(NewTestHandle(4));
	list.InsertLast(NewTestHandle(5));
	TestHandle s = list[0];
	s = list.At(1);
	list.At(2) = NewTestHandle(6);
	list[2] = NewTestHandle(7);
	s = list.First();
	s = list.Last();
	list.Push(s);
	s = list.Pop();
	ArrayIndex_AC index = list.GetIdentityItemNo(s);
	TemplateTempHandle<TestHandle> t = NewTestHandle(2);
	index = list.GetEqualItemNo(t);
	
	long sum = 0;
	for (TestHandleList::Iterator iter(&list); iter; ++iter)
	{
		sum += (*iter)->fData;
	}

	list.Delete(s);
	list.DeleteAll();
}


//----------------------------------------------------------------------------------------
// End of TemplateHandleList_AC.cpp
