//----------------------------------------------------------------------------------------
// CList_AC.cpp
// Copyright © 1986-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/01/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		11/01/00	[PB] Don't include Packages.h. 
		04/21/00	Split off CSortedVoidList_AC and CVoidList_AC. They contain most
					of the implementation for CSortedList_AC and CList_AC, but they
					don't have a Compare method so a subclass can define its own
					Compare method with typed arguments and not get a warning. 
					Add operator[] and reference version of At. 
					Move conditionally inline implementations out of the class. 
					Optimize array indexing and sorting. 
		03/24/99	Update copyright notice.
*/

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

// Toolbox

// ANSI

#ifndef __STDLIB__
#include <stdlib.h>
#endif


//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// NewList_AC: 
//----------------------------------------------------------------------------------------
CList_AC* NewList_AC()
{
	return TH_new CList_AC;
}

//----------------------------------------------------------------------------------------
// NewSortedList_AC: 
//----------------------------------------------------------------------------------------
CSortedList_AC* NewSortedList_AC()
{
	return TH_new CSortedList_AC;
}

//----------------------------------------------------------------------------------------
// NewAllocatedList_AC: 
//----------------------------------------------------------------------------------------
CList_AC* NewAllocatedList_AC(ArrayIndex_AC iSize)
{
	return TH_new CList_AC(iSize);
}

//----------------------------------------------------------------------------------------
// CompareAddresses: 
//----------------------------------------------------------------------------------------
CompareResult_AC CompareAddresses(const void* item1, const void* item2)
{
	CompareResult_AC returnVal = kItem1EqualItem2_AC;
	if (item1 > item2)
		returnVal = kItem1GreaterThanItem2_AC;
	else if (item1 < item2)
		returnVal = kItem1LessThanItem2_AC;

	return returnVal;
}

//========================================================================================
// CLASS CSortedVoidList_AC
//========================================================================================
//----------------------------------------------------------------------------------------
// CSortedVoidList_AC destructor
//----------------------------------------------------------------------------------------
CSortedVoidList_AC::~CSortedVoidList_AC()
{
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC Clone
//----------------------------------------------------------------------------------------
void* CSortedVoidList_AC::Clone() const
{
	return TH_new CSortedVoidList_AC(*this);
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::[]: Return the index'th element of the list.
//----------------------------------------------------------------------------------------
#if qRangeCheck
void* CSortedVoidList_AC::operator[](ArrayIndex_AC index) const
{
	ThrowIfRangeCheck(index + 1, "Range Check in CSortedVoidList_AC.operator[]");

	return *static_cast<void**>(CDynamicArray_AC::operator[](index));
}
#endif

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::At: Return the index'th element of the list.
//----------------------------------------------------------------------------------------
#if qRangeCheck
void* CSortedVoidList_AC::At(ArrayIndex_AC index) const
{
	ThrowIfRangeCheck(index, "Range Check in CSortedVoidList_AC.At");

	return (reinterpret_cast<void**>(fArraySpace))[index-1];
}
#endif

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::CompareVoids: 
//----------------------------------------------------------------------------------------
CompareResult_AC CSortedVoidList_AC::CompareVoids(const void* item1, const void* item2) const
{
	// By default just compare the ordinal value of the items. Subclasses that want to use
	// the items as pointers or other types should override if the comparison is based on
	// the pointed at value
	return CompareAddresses(item1, item2);
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::CompareElements: 
//----------------------------------------------------------------------------------------
CompareResult_AC CSortedVoidList_AC::CompareElements(const void* element1, const void* element2) const // override 
{
	return CompareVoids(*static_cast<void const * const*>(element1), *static_cast<void const * const*>(element2));
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::DoSearch: DON'T use exit to get out of this routine from your
// testVoid function or you will be really sad! (our debugger will check for you).
//----------------------------------------------------------------------------------------
void* CSortedVoidList_AC::DoSearch(CompareVoidType testVoid, void* yourDataPtr,
								   ArrayIndex_AC& index) const
{
	void* aVoid = NULL;
	Tester tester(testVoid, yourDataPtr, aVoid, this);
	return tester.DoSearchElement(index) ? aVoid : NULL;
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::Search: 
//----------------------------------------------------------------------------------------
ArrayIndex_AC CSortedVoidList_AC::Search(CompareVoidType testVoid, void* yourDataPtr)
{
	ArrayIndex_AC returnVal = kEmptyIndex_AC;

	ArrayIndex_AC index;
	if (DoSearch(testVoid, yourDataPtr, index))
		returnVal = index;

	return returnVal;
}


//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::SortBy: 
//----------------------------------------------------------------------------------------
void CSortedVoidList_AC::SortBy(CompareVoidsType compareVoids, void* yourDataPtr)
{
	if (fSize > 0)
		QuickSort(1, fSize, compareVoids, yourDataPtr);
}

//----------------------------------------------------------------------------------------
// CompareObjects: 
//----------------------------------------------------------------------------------------
static CompareResult_AC CompareObjects(void* object1, void* object2, void* yourDataPtr)
{
	return static_cast<CSortedVoidList_AC*>(yourDataPtr)->CompareVoids(object1, object2);
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::Sort: 
//----------------------------------------------------------------------------------------
void CSortedVoidList_AC::Sort()
{
	if (fSize > 0)
		QuickSort(1, fSize, ::CompareObjects, this);
}

//----------------------------------------------------------------------------------------
// Swap
//----------------------------------------------------------------------------------------

template<class T>
inline void Swap(T* a, T* b)
{
	T temp = *a;
	*a = *b;
	*b = temp;
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::QuickSort: 
//----------------------------------------------------------------------------------------
void CSortedVoidList_AC::QuickSort(ArrayIndex_AC beginIndex, // p
								   ArrayIndex_AC endIndex, // r
								   CompareVoidsType compareVoids,
								   void* yourDataPtr)
{
	if (beginIndex < endIndex)
	{
		ArrayIndex_AC left = QSRandomPartition(beginIndex, endIndex, compareVoids, yourDataPtr);
		QuickSort(beginIndex, left, compareVoids, yourDataPtr);
		QuickSort(left + 1, endIndex, compareVoids, yourDataPtr);
	}
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::QSPartition: 
//----------------------------------------------------------------------------------------
ArrayIndex_AC CSortedVoidList_AC::QSPartition(ArrayIndex_AC beginIndex, // p
											  ArrayIndex_AC endIndex, // r
											  CompareVoidsType compareVoids,
											  void* yourDataPtr)
{
	if (beginIndex >= endIndex)
		return endIndex;

	void* pivot = At(beginIndex);	// x
	ArrayIndex_AC i = beginIndex - 1;	// p - 1
	ArrayIndex_AC j = endIndex + 1;	// r + 1
	for(;;)
	{
		void* secondKey;
		do
		{
			--j;
			secondKey = At(j);	// A[j]
		} while (compareVoids(pivot, secondKey, yourDataPtr) <= kItem1LessThanItem2_AC);

		do
		{
			++i;
			secondKey = At(i);	// A[i]
		} while (compareVoids(pivot, secondKey, yourDataPtr) >= kItem1GreaterThanItem2_AC);

		if (i < j)
		{
			// Swap the elements
			Swap(ComputeAddress(i), ComputeAddress(j));
		}
		else
			return j;
	}

	return 0;	// this return statement is never executed, but exists to defeat an xlC warning
}

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::QSRandomPartition: 
//----------------------------------------------------------------------------------------
ArrayIndex_AC CSortedVoidList_AC::QSRandomPartition(ArrayIndex_AC beginIndex, // p
													ArrayIndex_AC endIndex, // r
													CompareVoidsType compareVoids,
													void* yourDataPtr)
{
	ArrayIndex_AC i = RandomArrayIndex_AC(beginIndex, endIndex);

	// exchange
	Swap(ComputeAddress(beginIndex), ComputeAddress(i));

	return QSPartition(beginIndex, endIndex, compareVoids, yourDataPtr);
}


//========================================================================================
// class CSortedVoidList_AC::Tester
//========================================================================================

//----------------------------------------------------------------------------------------
// CSortedVoidList_AC::Tester::TestItem: 
//----------------------------------------------------------------------------------------
CompareResult_AC CSortedVoidList_AC::Tester::TestItem(ArrayIndex_AC anItem, void* yourDataPtr)
{
	Tester* tester = static_cast<Tester*>(yourDataPtr);
	tester->fVoid = tester->fList->At(anItem);
	return tester->fTestVoid(tester->fVoid, tester->fStaticLink);
}


//========================================================================================
// CLASS CVoidList_AC
//========================================================================================
//----------------------------------------------------------------------------------------
// CVoidList_AC destructor
//----------------------------------------------------------------------------------------
CVoidList_AC::~CVoidList_AC()
{
}

//----------------------------------------------------------------------------------------
// CVoidList_AC Clone
//----------------------------------------------------------------------------------------
void* CVoidList_AC::Clone() const
{
	return TH_new CVoidList_AC(*this);
}

//----------------------------------------------------------------------------------------
// CVoidList_AC::DoSearchElement: 
//----------------------------------------------------------------------------------------
bool CVoidList_AC::DoSearchElement(CompareIndexType_AC testItem, void* yourDataPtr,
								   ArrayIndex_AC& index) const // override
{
	// Go back to the linear search method. 
	return CDynamicArray_AC::DoSearchElement(testItem, yourDataPtr, index);
}

//----------------------------------------------------------------------------------------
// CVoidList_AC::InsertElementInOrder: Overridden to do arrival sequence insertion
//----------------------------------------------------------------------------------------
void CVoidList_AC::InsertElementInOrder(const void* elementPtr) // override
{
	CDynamicArray_AC::InsertElementInOrder(elementPtr);
}

//----------------------------------------------------------------------------------------
// CVoidList_AC::[]: Return the index'th element of the list.
//----------------------------------------------------------------------------------------
#if qRangeCheck
void*& CVoidList_AC::operator[](ArrayIndex_AC index)
{
	ThrowIfRangeCheck(index + 1, "Range Check in CVoidList_AC.operator[]");

	return (reinterpret_cast<void**>(fArraySpace))[index];
}
#endif

//----------------------------------------------------------------------------------------
// CVoidList_AC::At: Return the index'th element of the list.
//----------------------------------------------------------------------------------------
#if qRangeCheck
void*& CVoidList_AC::At(ArrayIndex_AC index)
{
	ThrowIfRangeCheck(index, "Range Check in CVoidList_AC.At");

	return (reinterpret_cast<void**>(fArraySpace))[index-1];
}
#endif

//----------------------------------------------------------------------------------------
// CVoidList_AC::AtPut: 
//----------------------------------------------------------------------------------------
#if qRangeCheck
void CVoidList_AC::AtPut(ArrayIndex_AC index, void* newItem)
{
	ThrowIfRangeCheck(index, "Range Check in CVoidList_AC.AtPut");

	// Replace the index'th element of the list.
	(reinterpret_cast<void**>(fArraySpace))[index-1] = newItem;
}
#endif


//========================================================================================
// CSortedList_AC
//========================================================================================
//----------------------------------------------------------------------------------------
// CSortedList_AC destructor
//----------------------------------------------------------------------------------------
CSortedList_AC::~CSortedList_AC()
{
}

//----------------------------------------------------------------------------------------
// CSortedList_AC Clone
//----------------------------------------------------------------------------------------
void* CSortedList_AC::Clone() const
{
	return TH_new CSortedList_AC(*this);
}

//----------------------------------------------------------------------------------------
// Compare
//----------------------------------------------------------------------------------------
CompareResult_AC CSortedList_AC::Compare(const void* object1, const void* object2) const
{
	return CSortedVoidList_AC::CompareVoids(object1, object2);
}

//----------------------------------------------------------------------------------------
// CompareVoids
//----------------------------------------------------------------------------------------
CompareResult_AC CSortedList_AC::CompareVoids(const void* item1, const void* item2) const // override 
{
	return Compare(item1, item2);
}

//========================================================================================
// CList_AC
//========================================================================================
//----------------------------------------------------------------------------------------
// CList_AC destructor
//----------------------------------------------------------------------------------------
CList_AC::~CList_AC()
{
}

//----------------------------------------------------------------------------------------
// CList_AC Clone
//----------------------------------------------------------------------------------------
void* CList_AC::Clone() const
{
	return TH_new CList_AC(*this);
}

//----------------------------------------------------------------------------------------
// Compare
//----------------------------------------------------------------------------------------
CompareResult_AC CList_AC::Compare(const void* object1, const void* object2) const
{
	return CVoidList_AC::CompareVoids(object1, object2);
}

//----------------------------------------------------------------------------------------
// CompareVoids
//----------------------------------------------------------------------------------------
CompareResult_AC CList_AC::CompareVoids(const void* item1, const void* item2) const // override 
{
	return Compare(item1, item2);
}


//----------------------------------------------------------------------------------------
// End of CList_AC.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/20/96	[1357687] (List) CSortedHandleList_AC::DoSearch won't return NULL
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		06/09/96	Removed UStreamable to a separate file from UObject
		05/02/95	Made CList_AC/THandleList::FreeList deprecated. It will eventually be removed,
							please call FreeAll and then if necessary free the object
		04/18/96	Use post-increment with iterators in while loops
		04/15/96	CList_AC/TLongIntList::DoSearchElement were returning the wrong element
							index for the found element.
		04/15/96	Use "while" style iteration
		----- R10 -----
		04/01/96	Fixed type coercion that SCpp was whining about.
		04/01/96	Fixed bug in CSortedList_AC::SortBy where it wasn't calling the callers
							comparison function with object pointers, but was calling with pointers
							to object pointers.
		03/31/96	Moved Quicksort (and support) to CDynamicArray_AC
		03/30/96	Made all the At/First/Last methods const
		03/27/96	Changed several functions to non-virtual and inlines.
							Conditioned fEltClassDesc on qDebug
		 3/27/96	Made several functions non-virtual inline.
		03/26/96	coerce CStrxxx_AC to const char* to get copies of the strings as c style strings
		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		----- 3.3b1 -----
		 4/12/95	Use #if instead of if qRangeCheck. Conditionalize printf
		 					on qDebugMsg. 
		 3/13/95	Change Free methods to destructors. 
		02/08/95	replace usage of staticLink with yourDataPtr. 
		02/07/95	Create missing prototypes for static functions used internally. 
*/