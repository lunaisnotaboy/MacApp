//----------------------------------------------------------------------------------------
// CGDIterator_AC.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved.
// Portions Copyright © 1996 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		09/22/00	Move graphics device specific functions out of the iterator
					into new class CGraphicsDevice_AC. 
					Add methods for C++ meisters. 
					Add clipTo parameter that controls clipping to the devices. 
					Change saved clip region from a global to a field so the
					iterator can be used reentrantly. 
					Eliminate extra SetClip/GetClip by passing region to ClipTo. 
		09/01/00	Stripped dead code.
		07/31/00	[W] Need something for HasDepth in SupportsPixelDepth and SetDepth
					in SetPixelDepth.
		06/01/00	Added Bounds function.
		07/26/99	Optimization in FindNextValidDevice.
		03/24/99	Update copyright notice.
		10/06/98	Clean up includes. 
*/

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __Configuration_AC__
#include "Configuration_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

// Toolbox

#ifndef __PALETTES__
#include <Palettes.h>
#endif


//========================================================================================
// Constants
//========================================================================================

// To look good in gray we need 4 bits in monochrome, or 8 bits in color.
// This is because 2 bits monochrome is only black, white, plus 2 shades;
// and 4 bits in color is just that plus 12 irrelevant colors.
enum { kDeepGrayscaleBits = 4, kDeepColorBits = 8 };

//========================================================================================
// CGraphicsDevice_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::Bounds
//----------------------------------------------------------------------------------------

CRect_AC CGraphicsDevice_AC::Bounds() const
{
	CRect_AC bounds;

	if (fDevice)
		bounds = (**fDevice).gdRect;

	return bounds;
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::LocalBounds
//----------------------------------------------------------------------------------------

CRect_AC CGraphicsDevice_AC::LocalBounds() const
{
	CRect_AC deviceRect(Bounds());

	::GlobalToLocal(&deviceRect[topLeft]);
	::GlobalToLocal(&deviceRect[botRight]);
	
	return deviceRect;
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::IsColor
//----------------------------------------------------------------------------------------

bool CGraphicsDevice_AC::IsColor() const
{
	return fDevice && ::TestDeviceAttribute(fDevice, gdDevType);
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::IsDeep
//----------------------------------------------------------------------------------------

bool CGraphicsDevice_AC::IsDeep() const
{
	short pixelDepth = Depth();
	return (pixelDepth >= kDeepColorBits) ||
		   ((pixelDepth >= kDeepGrayscaleBits) && !IsColor());	
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::Depth
//----------------------------------------------------------------------------------------

short CGraphicsDevice_AC::Depth() const
{
	short depth = 1;

	if (fDevice)
	{
		PixMapHandle pixMapHandle = (**fDevice).gdPMap;
		if (pixMapHandle && *pixMapHandle)
			depth = (**pixMapHandle).pixelSize;
	}

	return depth;
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::HasDepth
//----------------------------------------------------------------------------------------

bool CGraphicsDevice_AC::HasDepth(short thisDepth, bool inColor) const
{
#if qMSWindows
	#pragma unused (thisDepth, inColor)
	#pragma message("CGraphicsDevice_AC::HasDepth: Need Windows equivalent to HasDepth.")
	return true;
#else
	return fDevice && ::HasDepth(fDevice, thisDepth, 1, inColor ? 1 : 0);
#endif
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::SetDepth
//----------------------------------------------------------------------------------------

void CGraphicsDevice_AC::SetDepth(short newDepth, bool inColor)
{
#if qMSWindows
	#pragma unused (newDepth, inColor)
	#pragma message("CGraphicsDevice_AC::SetDepth: Need Windows equivalent to SetDepth")
#else
	if (fDevice)
		::SetDepth(fDevice, newDepth, 1, inColor ? 1 : 0);
#endif
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::ScreenActive
//----------------------------------------------------------------------------------------

bool CGraphicsDevice_AC::ScreenActive() const
{
	return fDevice &&
		   ::TestDeviceAttribute(fDevice, screenDevice) &&
		   ::TestDeviceAttribute(fDevice, screenActive);
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::Next
//----------------------------------------------------------------------------------------

CGraphicsDevice_AC CGraphicsDevice_AC::Next() const
{
	return fDevice ? ::GetNextDevice(fDevice) : NULL;
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::NextActive
//----------------------------------------------------------------------------------------

CGraphicsDevice_AC CGraphicsDevice_AC::NextActive() const
{
	CGraphicsDevice_AC device = fDevice ? Next() : First();

	while (device && !device.ScreenActive())
		device = device.Next();

	return device;
}

//----------------------------------------------------------------------------------------
// CGraphicsDevice_AC::ClipTo
//----------------------------------------------------------------------------------------

bool CGraphicsDevice_AC::ClipTo(const CRegion_AC& rgn) const
{
	CTempRegion_AC newClip(LocalBounds());
	newClip &= rgn;

	::SetClip(newClip);
	
	return !newClip.IsEmpty();
}


//========================================================================================
// CGDIterator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CGDIterator_AC::CGDIterator_AC
//----------------------------------------------------------------------------------------

CGDIterator_AC::CGDIterator_AC(bool clipTo) :
	fCurrent(NULL),
	fClipTo(clipTo),
	fSavedClipping(NULL)
{
	First();
}

//----------------------------------------------------------------------------------------
// CGDIterator_AC::~CGDIterator_AC
//----------------------------------------------------------------------------------------

CGDIterator_AC::~CGDIterator_AC()
{
	Cleanup();
}

//----------------------------------------------------------------------------------------
// CGDIterator_AC::First
//----------------------------------------------------------------------------------------

CGraphicsDevice_AC* CGDIterator_AC::First()
{
	Setup();

	fCurrent = CGraphicsDevice_AC::First();

	if (fClipTo)
	{
		while (fCurrent && !ClipTo())
		{
			fCurrent = fCurrent.Next();
		}
	}

	return Current();
}

//----------------------------------------------------------------------------------------
// CGDIterator_AC::Main
//----------------------------------------------------------------------------------------

CGraphicsDevice_AC* CGDIterator_AC::Main()
{
	Setup();

	fCurrent = CGraphicsDevice_AC::Main();
	
	if (fClipTo)
	{
		if (!ClipTo())
			fCurrent = NULL;
	}

	return Current();
}

//----------------------------------------------------------------------------------------
// CGDIterator_AC::Current
//----------------------------------------------------------------------------------------

CGraphicsDevice_AC* CGDIterator_AC::Current() const
{
	return fCurrent ? const_cast<CGraphicsDevice_AC*>(&fCurrent) : NULL;
}

//----------------------------------------------------------------------------------------
// CGDIterator_AC::Next
//----------------------------------------------------------------------------------------

CGraphicsDevice_AC* CGDIterator_AC::Next()
{
	fCurrent = fCurrent.Next();

	if (fClipTo)
	{
		while (fCurrent && !ClipTo())
		{
			fCurrent = fCurrent.Next();
		}
	}

	return Current();
}

//----------------------------------------------------------------------------------------
// CGDIterator_AC::Setup
//----------------------------------------------------------------------------------------

void CGDIterator_AC::Setup()
{
	// Save the current clipping so we can put it back in Cleanup
	// and use it as we iterate over each device.
	if (fClipTo)
	{
		if (!fSavedClipping)
			fSavedClipping.MakeRgnHandle();

		::GetClip(fSavedClipping);
	}
}

//----------------------------------------------------------------------------------------
// CGDIterator_AC::ClipTo
//----------------------------------------------------------------------------------------

bool CGDIterator_AC::ClipTo() const
{
	return !fClipTo || (fCurrent && fCurrent.ClipTo(fSavedClipping));
}

//----------------------------------------------------------------------------------------
// CGDIterator_AC::Cleanup
//----------------------------------------------------------------------------------------

void CGDIterator_AC::Cleanup() const
{
	// Restore clipping to what it was when we were constructed.
	if (fClipTo)
		::SetClip(fSavedClipping);
}


//----------------------------------------------------------------------------------------
// End of CGDIterator_AC.cpp
