//----------------------------------------------------------------------------------------
// CLongPoint_AC.cpp
// Copyright © 1996-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/11/01	Implement without template. 
		01/10/01	Revert. 
		01/09/01	Fix the kZeroPt instantiation.
		01/02/01	Update copyright.
		08/17/00	Split CLongPoint_AC and CLongRect_AC off from CLongGeometry_AC. 
*/

#ifndef __CLongPoint_AC__
#include "CLongPoint_AC.h"
#endif

// ACS

#ifndef __CLongRect_AC__
#include "CLongRect_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// Toolbox

#ifndef __LIMITS__
#include <limits.h>
#endif

// ANSI


//========================================================================================
// CLongPoint_AC
//========================================================================================

const CLongPoint_AC CLongPoint_AC::kZeroPt;

#if qDebug
//----------------------------------------------------------------------------------------
// CLongPoint_AC::AsText
//----------------------------------------------------------------------------------------

std::string CLongPoint_AC::AsText() const
{
	std::string text;
	stringprintf(text, "CLongPoint_AC(%d, %d)", h, v);
	return text;
}
#endif // qDebug
	
//----------------------------------------------------------------------------------------
// CLongPoint_AC::ConstrainTo:
//----------------------------------------------------------------------------------------

void CLongPoint_AC::ConstrainTo(const CLongRect_AC& rt)
{
	if (v < rt.top)
		v = rt.top;
	if (v > rt.bottom)
		v = rt.bottom;
	if (h < rt.left)
		h = rt.left;
	if (h > rt.right)
		h = rt.right;
}


//----------------------------------------------------------------------------------------
// End of CLongPoint_AC.cpp