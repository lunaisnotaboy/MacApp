//----------------------------------------------------------------------------------------
// CDrawingEnvironment_AC.cpp
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/28/00	Add CSaveThemeDrawingState_AC. Fix the non-appearance 1.1 case
					to actually save the patterns and to not leak. 
		09/18/00	Add CSaveClipRegion_AC. 
		03/24/99	Update copyright notice.
		10/26/98	Use SetPort_AC instead of SetPort.  Include ImagingUtils_AC.
*/

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

// ACS

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif


//========================================================================================
// CSaveThemeDrawingState_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CSaveThemeDrawingState_AC constructor
//----------------------------------------------------------------------------------------

CSaveThemeDrawingState_AC::CSaveThemeDrawingState_AC(CGrafPtr port) :
	fPort(port),
#if qCarbon
	fSavedState(NULL)
#else
#if qPowerPC
	fSavedState(NULL),
#endif
	fSavedPenPat(NULL),
	fSavedBackPat(NULL)
#endif
{
#if qCarbon
#pragma unused (port)
	::ThrowIfOSErr_AC(::GetThemeDrawingState(&fSavedState));
#else
#if qPowerPC
	if (AppearanceMgrVersion_AC() >= 0x110)
		::ThrowIfOSErr_AC(::GetThemeDrawingState(&fSavedState));
	else
#endif
	{
		fSavedPenPat = NewPixPat();
#if ACCESSOR_CALLS_ARE_FUNCTIONS
		GetPortPenPixPat(fPort, fSavedPenPat);
#else
		CopyPixPat(fPort->pnPixPat, fSavedPenPat);
#endif

		fSavedBackPat = NewPixPat();
#if ACCESSOR_CALLS_ARE_FUNCTIONS
		GetPortBackPixPat(fPort, fSavedBackPat);
#else
		CopyPixPat(fPort->bkPixPat, fSavedBackPat);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// CSaveThemeDrawingState_AC destructor
//----------------------------------------------------------------------------------------

CSaveThemeDrawingState_AC::~CSaveThemeDrawingState_AC()
{
	SetPort_AC(fPort);
#if qCarbon
	if (fSavedState)
		::ThrowIfOSErr_AC(::SetThemeDrawingState(fSavedState, true));
#else
#if qPowerPC
	if (fSavedState)
		::ThrowIfOSErr_AC(::SetThemeDrawingState(fSavedState, true));
	else
#endif
	{
		if (fSavedPenPat)
		{
#if ACCESSOR_CALLS_ARE_FUNCTIONS
			SetPortPenPixPat(fPort, fSavedPenPat);
			DisposePixPat(fSavedPenPat);
#else
			PenPixPat(fSavedPenPat);
#endif
			fSavedPenPat = NULL;
		}

		if (fSavedBackPat)
		{
#if ACCESSOR_CALLS_ARE_FUNCTIONS
			SetPortBackPixPat(fPort, fSavedBackPat);
			DisposePixPat(fSavedBackPat);
#else
			BackPixPat(fSavedBackPat);
#endif
			fSavedBackPat = NULL;
		}
	}
#endif
}


//========================================================================================
// CSaveClipRegion_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CSaveClipRegion_AC constructor
//----------------------------------------------------------------------------------------

CSaveClipRegion_AC::CSaveClipRegion_AC() :
	CTempRegion_AC(GetPortClipTempRegion_AC().release()),
	fSavedPort(GetGrafPtr_AC())
{
}

//----------------------------------------------------------------------------------------
// CSaveClipRegion_AC destructor
//----------------------------------------------------------------------------------------

CSaveClipRegion_AC::~CSaveClipRegion_AC()
{
	::SetPort_AC(fSavedPort); 
	::SetClip(fData);
}


//========================================================================================
// CTempDrawingEnvironment_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CTempDrawingEnvironment_AC constructor
//----------------------------------------------------------------------------------------

CTempDrawingEnvironment_AC::CTempDrawingEnvironment_AC(SaveFlags flags) :
	fSaveFlags(flags),
	fSavedGrafPort(NULL)
{
	Save(fSaveFlags);
}

//----------------------------------------------------------------------------------------
// CTempDrawingEnvironment_AC destructor
//----------------------------------------------------------------------------------------

CTempDrawingEnvironment_AC::~CTempDrawingEnvironment_AC()
{
	Restore(fSaveFlags);
}

//----------------------------------------------------------------------------------------
// CTempDrawingEnvironment_AC::Save
//----------------------------------------------------------------------------------------

void CTempDrawingEnvironment_AC::Save()
{
	fSavedForeColor.GetForeColor();
	fSavedBackColor.GetBackColor();
	::GetPenState(&fSavedPenState);
	fSavedHiliteColor.GetHiliteColor();
	fSavedTextStyle.GetPortTextStyle();
	::GetClip(fSavedClipRgn);
	::GetPort(&fSavedGrafPort);
}

//----------------------------------------------------------------------------------------
// CTempDrawingEnvironment_AC::Save
//----------------------------------------------------------------------------------------

void CTempDrawingEnvironment_AC::Save(SaveFlags flags)
{
	fSaveFlags |= flags;
	if (flags == kSaveAllAttributes)
	{
		Save();
	}
	else
	{	
		if (flags & kSaveForeColor)
			fSavedForeColor.GetForeColor();
		
		if (flags & kSaveBackColor)
			fSavedBackColor.GetBackColor();

		if (flags & kSaveHiliteColor)
			fSavedHiliteColor.GetHiliteColor();
		
		if (flags & kSavePenState)
			::GetPenState(&fSavedPenState);
		
		if (flags & kSaveTextStyle)
			fSavedTextStyle.GetPortTextStyle();

		if (flags & kSaveClipRgn)
			::GetClip(fSavedClipRgn);

		if (flags & kSaveGrafPort)
			GetPort(&fSavedGrafPort);
	}
}
	
//----------------------------------------------------------------------------------------
// CTempDrawingEnvironment_AC::Restore
//----------------------------------------------------------------------------------------

void CTempDrawingEnvironment_AC::Restore()
{
	if (fSaveFlags & kSaveForeColor)
		fSavedForeColor.SetForeColor();
	
	if (fSaveFlags & kSaveBackColor)
		fSavedBackColor.SetBackColor();

	if (fSaveFlags & kSaveHiliteColor)
		fSavedHiliteColor.SetHiliteColor();
	
	if (fSaveFlags & kSavePenState)
		::SetPenState(&fSavedPenState);
		
	if (fSaveFlags & kSaveTextStyle)
		fSavedTextStyle.SetPortTextStyle();

	if (fSaveFlags & kSaveClipRgn)
		::SetClip(fSavedClipRgn);
	
	if (fSaveFlags & kSaveGrafPort)
		::SetPort_AC(fSavedGrafPort);
}

//----------------------------------------------------------------------------------------
// CTempDrawingEnvironment_AC::Restore
//----------------------------------------------------------------------------------------

void CTempDrawingEnvironment_AC::Restore(SaveFlags flags)
{
	if (flags & fSaveFlags & kSaveForeColor)
		fSavedForeColor.SetForeColor();
	
	if (flags & fSaveFlags & kSaveBackColor)
		fSavedBackColor.SetBackColor();

	if (flags & fSaveFlags & kSaveHiliteColor)
		fSavedHiliteColor.SetHiliteColor();
	
	if (flags & fSaveFlags & kSavePenState)
		::SetPenState(&fSavedPenState);
		
	if (flags & fSaveFlags & kSaveTextStyle)
		fSavedTextStyle.SetPortTextStyle();
		
	if (flags & fSaveFlags & kSaveClipRgn)
		::SetClip(fSavedClipRgn);
	
	if (flags & fSaveFlags & kSaveGrafPort)
		::SetPort_AC(fSavedGrafPort);
}


//----------------------------------------------------------------------------------------
// End of CDrawingEnvironment_AC.cpp
