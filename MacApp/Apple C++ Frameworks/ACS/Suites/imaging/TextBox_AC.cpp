//----------------------------------------------------------------------------------------
// TextBox_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		06/28/01	[C] Reimplement TextBox_AC similar to original implementation
					but without the word breaks.
		05/07/01	Comment out pragma messages for Carbon. 
		02/14/01	Don't include Core_AC. 
		01/26/01	QuickDrawText is a system include. 
		01/02/01	Update copyright.
		12/15/00	Made Ptr passed to TextBox_AC const char*.
		11/22/00	Properly type the wordBreak proc. 
					Fix StdNoRect to be a QDRectProcPtr. 
		11/09/00	[PB] Define pTextBoxTE, pTEDefaultWordBreak and StdNoRect only
					if they are used. 
		09/08/00	Rename GetClipRectRgn_AC to GetClipRegionBounds_AC and fix it
					so it gets the rect instead of setting it. 
		08/09/00	Include ImagingUtils_AC.h.
		05/17/00	Update Copyright.
					Update TextBox_AC to start using ACS Carbonized functions
					(still not capable of working in Carbon).
		12/07/99	Fix file name in banner.
		03/24/99	Update copyright notice.
		12/16/98	Add unused in TextBox_AC and rearrange for Windows.
		10/23/98	Carbonize
*/

#ifndef __TextBox_AC__
#include "TextBox_AC.h"
#endif

// ACS

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

// Toolbox

#ifndef __QUICKDRAWTEXT__
#include <QuickDrawText.h>
#endif

#if !qMSWindows

static TEHandle 	pTextBoxTE;
static WordBreakUPP	pTEDefaultWordBreak;

//----------------------------------------------------------------------------------------
// StdNoRect: StdNoRect filters out the Rect drawing calls.
//----------------------------------------------------------------------------------------

static pascal void StdNoRect(GrafVerb verb, const Rect *r)
{
#pragma unused (verb, r)
}

#endif // !qMSWindows

//----------------------------------------------------------------------------------------
// TextBox_AC: 
//----------------------------------------------------------------------------------------
void TextBox_AC(const char* text,
			   short itsLength,
			   const CRect_AC& box,
			   short itsJust,
			   bool autoWrap,
			   WordBreakProcPtr wordBreak,
			   bool eraseFirst,
			   bool spaceForCaret,
			   bool preferOutline)
{
#if qMSWindows
	//#pragma message ( "NOTE: Need to implement proper text drawing in TextBox_AC."  __FILE__)
	#pragma unused (autoWrap, wordBreak, eraseFirst, spaceForCaret, preferOutline)
	// •••  Don't know how to deal with QDProcs in Carbon	--	MB-9810-12-1654
	TETextBox(text, itsLength, box, itsJust);	// for now 
#else

#if qCarbon
	// Carbon does not support the word break UPP.
	#pragma unused (wordBreak)
#endif

	union QuickDrawProcs
	{
		QDProcs theQDProcs;
		CQDProcs theCQDProcs;
	};

	static const short kTextBoxCaretSlopSize = 1;// Since TETextBox uses TE to image the
												// text, we may need to adjust by 1 pixel.
												// Reason: TE draws beginning 1 pixel to
												// the right to allow for the insertion
												// point (which we won't have since this
												// is drawn text, not editable text).
	static const short kMaxTEChars = 32000;		// Actually TE suffers some other
												// limitations as well. Such as
												// misbehaviour and or bombing when the
												// sum of the lineheights > 32k or a
												// linewidth > 32k (overflows QuickDraw
												// space) But these are _MUCH_ more
												// difficult to test for in a quick way

	static QDRectUPP theRectProc;				// This can hang around all the time

	CWhileOutlinePreferred_AC setOP(preferOutline);

	// Create my goodies if necessary 
	if (!pTextBoxTE)
	{
		pTextBoxTE = TENew(box, box);
		if (pTextBoxTE)							// can allocate space for our terecord 
		{
			// • save off several items of interest
			pTEDefaultWordBreak = (*pTextBoxTE)->wordBreak;
		}

		if (!theRectProc)
		{
			theRectProc = NewQDRectUPP(&StdNoRect);
			::ThrowIfNULL_AC(theRectProc);
		}
	}

	if (!pTextBoxTE)				// couldn't allocate the TE handle 
		TETextBox(text, itsLength, box, itsJust);// default to TextBox in low memory 
	else
	{
		WordBreakUPP wbUPP = NULL;

		// Setup the work TE with the necessary parameters 
		FontInfo fInfo;
		::GetFontInfo(&fInfo);	// Need to get font's height and ascent. 

		TERec& workTE = **pTextBoxTE;

		workTE.inPort = GetGrafPtr_AC();					// Current port and its characteristics 

		// Intersect the clip and the requested box
		((CRect_AC &)workTE.viewRect) = GetClipRegionBounds_AC(workTE.inPort) & box;
		((CRect_AC &)workTE.destRect) = box;
		if (!spaceForCaret)
		{
			// Widen the destrect but not the visrect. This lets the 1 pixel wide area to the
			// left of all text and the right of all text go unshown.
			workTE.destRect.left -= kTextBoxCaretSlopSize;
			workTE.destRect.right += kTextBoxCaretSlopSize;
		}

		workTE.txSize = GetPortTextSize_AC(workTE.inPort);
		workTE.txFont = GetPortTextFont_AC(workTE.inPort);
		workTE.txFace = GetPortTextFace_AC(workTE.inPort);
		workTE.fontAscent = fInfo.ascent;
		workTE.lineHeight = fInfo.ascent + fInfo.descent + fInfo.leading;// returns the font height
		workTE.just = itsJust;

		workTE.crOnly = autoWrap ? 0 : -1;			//if >=0, word wrap
													//if <0, new line at Return only

		workTE.wordBreak = pTEDefaultWordBreak;

#if !qCarbon
		if (wordBreak)
		{
			::ThrowIfNULL_AC(wbUPP = NewWordBreakUPP(wordBreak));
			workTE = **pTextBoxTE;				// re-dereference because memory may have moved
			workTE.wordBreak = wbUPP;
		}
#endif

		TESetText(text, Min_AC(itsLength, kMaxTEChars), pTextBoxTE);

		// if called with eraseFirst true, then let TEUpdate image with its built-in EraseRect 
		if (eraseFirst)
			TEUpdate(box, pTextBoxTE);
		else
		{
			/* replace the existing QD procs ( standard or externally supplied )
			  so that the EraseRect in TEUpdate is ignored */
#if qCarbon
			CQDProcsPtr saveQDProcsPtr = GetPortGrafProcs(workTE.inPort);
#else
			QDProcsPtr saveQDProcsPtr = qd.thePort->grafProcs;
#endif
			QuickDrawProcs myQDProcs;
			QDRectUPP saveRectProc;

			if (!saveQDProcsPtr)
			{
#if qCarbon
				SetStdCProcs(&(myQDProcs.theCQDProcs));
				myQDProcs.theCQDProcs.rectProc = theRectProc;
				SetPortGrafProcs(workTE.inPort, &myQDProcs.theCQDProcs);
#else
				if (CRGBColor_AC::IsColorPort())
				{
					SetStdCProcs(&(myQDProcs.theCQDProcs));
					myQDProcs.theCQDProcs.rectProc = theRectProc;
					qd.thePort->grafProcs = (QDProcsPtr) & myQDProcs.theCQDProcs;
				}
				else
				{
					SetStdProcs(&(myQDProcs.theQDProcs));
					myQDProcs.theQDProcs.rectProc = theRectProc;
					qd.thePort->grafProcs = &myQDProcs.theQDProcs;
				}
#endif
			}
			else
			{
#if qCarbon
				saveRectProc = saveQDProcsPtr->rectProc;
				saveQDProcsPtr->rectProc = theRectProc;
#else
				saveRectProc = qd.thePort->grafProcs->rectProc;
				qd.thePort->grafProcs->rectProc = theRectProc;
#endif
			}

			// Now do the imaging 
			TEUpdate(box, pTextBoxTE);

			// Restore the QDProcs 
#if qCarbon
			if (!saveQDProcsPtr)
				SetPortGrafProcs(workTE.inPort, NULL);
			else
				saveQDProcsPtr->rectProc = saveRectProc;
#else
			if (!saveQDProcsPtr)
				qd.thePort->grafProcs = NULL;
			else
				qd.thePort->grafProcs->rectProc = saveRectProc;
#endif
		}

#if !qCarbon
		if (wbUPP)
		{
			DisposeWordBreakUPP(wbUPP);
			wbUPP = NULL;
		}
#endif
	}
#endif
}