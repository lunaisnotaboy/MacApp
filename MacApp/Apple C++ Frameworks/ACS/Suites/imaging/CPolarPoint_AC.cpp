//----------------------------------------------------------------------------------------
// CPolarPoint_AC.cpp
// Copyright © 1998-2001 by Apple Computer. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		02/28/01	[W] Hardcode pi for Windows. 
		01/25/01	Include fp.h to get pi. 
		01/02/01	Update copyright.
		10/18/00	pi is not defined in the MPW headers. 
		09/20/00	Remove conditional on inclusion and usings.
		09/01/00	Changed pragma warning to pragma message.
		08/22/00	Use cmath instead of fp.h when compiling with CodeWarrior. 
		07/24/00	CW Pro 6: namespacing. 
		12/10/99	Carbon: pi isn't available on OS X, causing crashes.  Hard code.
		03/24/99	Update copyright notice.
*/

#ifndef __CPolarPoint_AC__
#include "CPolarPoint_AC.h"
#endif

// Toolbox

#if !qCarbon && !defined(__MRC__) && !defined(__SC__)
	#ifndef __FP__
	#include <fp.h>
	#endif
#endif

// ANSI

#ifndef __cmath__
#include <cmath>
#endif

using std::atan;
using std::cos;
using std::sin;
using std::sqrt;

//========================================================================================
// CLASS CPolarPoint_AC
//========================================================================================

// ---------------------------------------------------------------------------------------
// globals
// ---------------------------------------------------------------------------------------
#if qMSWindows || qCarbon || defined(__MRC__) || defined(__SC__)
//#pragma message ("CPolarPoint_AC.cpp: For Carbon: pi in fp.h not available && causes crash on OS X; hardcoding pi")
float CPolarPoint_AC::pi = 3.14159265;
float CPolarPoint_AC::twoPi = 2 * 3.14159265;
float CPolarPoint_AC::halfPi = 3.14159265 / 2;
#else
float CPolarPoint_AC::pi = ::pi;
float CPolarPoint_AC::twoPi = 2 * ::pi;
float CPolarPoint_AC::halfPi = ::pi / 2;
#endif

// ---------------------------------------------------------------------------------------
void CPolarPoint_AC::Set(const CLongPoint_AC& thePt)
{
	// Special cases first
	if (thePt.h == 0 && thePt.v >= 0)
		fAngle = 0;
	else if (thePt.h == 0 && thePt.v < 0)
		fAngle = pi;
	else if (thePt.h > 0 && thePt.v == 0)
		fAngle = halfPi;
	else if (thePt.h < 0 && thePt.v == 0)
		fAngle = pi * 3 / 2;

	// the fAngle returned by Arc Tangent is defined for positive slopes only.
	// So, after the initial fAngle is computed, adjust it for the quadrant that
	// the coordinates are in.		
	else if (thePt.h > 0 && thePt.v > 0)
		fAngle = atan((float)thePt.h / (float)thePt.v);
	else if (thePt.h > 0 && thePt.v < 0)
		fAngle = atan((float) - thePt.v / (float)thePt.h) + halfPi;
	else if (thePt.h < 0 && thePt.v < 0)
		fAngle = atan((float)thePt.h / (float)thePt.v) + pi;
	else if (thePt.h < 0 && thePt.v > 0)
		fAngle = atan((float)thePt.v / (float) - thePt.h) + pi * 3 / 2;

	fRadius = sqrt((thePt.h * thePt.h) + (thePt.v * thePt.v));
}

// ---------------------------------------------------------------------------------------
CPolarPoint_AC::CPolarPoint_AC(const CPolarPoint_AC& rhs) :
	fAngle(rhs.fAngle),
	fRadius(rhs.fRadius)
{
}

// ---------------------------------------------------------------------------------------
CPolarPoint_AC::operator CLongPoint_AC() const

{
	return CLongPoint_AC(fRadius * sin(fAngle), fRadius * cos(fAngle));
}

//----------------------------------------------------------------------------------------
// Arithmetic operators for CPolarPoint_AC. Addition and subtraction are all that make
// any sense.
//----------------------------------------------------------------------------------------
CPolarPoint_AC& CPolarPoint_AC::operator+=(const CPolarPoint_AC& rhs)
{
	fAngle += rhs.fAngle;
	fRadius += rhs.fRadius;

	return *this;
}


CPolarPoint_AC& CPolarPoint_AC::operator-=(const CPolarPoint_AC& rhs)
{
	if (fAngle >= rhs.fAngle)
		fAngle -= rhs.fAngle;
	else										// assume rhs.fAngle is within one period of fAngle
		fAngle = ((fAngle + twoPi)				/* the period */ - rhs.fAngle);
	fRadius -= rhs.fRadius;

	return *this;
}

CPolarPoint_AC CPolarPoint_AC::operator-() const
{
	return CPolarPoint_AC(-fAngle, -fRadius);
}


//----------------------------------------------------------------------------------------
// Conversions
//----------------------------------------------------------------------------------------
float  CPolarPoint_AC::ToRadians(float inDegrees)
{
	return inDegrees / 360 * twoPi;
}

float  CPolarPoint_AC::ToDegrees(float inRadians)
{
	return  inRadians * 360 / twoPi;
}


//----------------------------------------------------------------------------------------
// End of CPolarPoint_AC.cpp