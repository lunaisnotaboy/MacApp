//----------------------------------------------------------------------------------------
// CFixedPoint_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		01/05/01	Change to use CString_AC instead of std::string.
		01/02/01	Update copyright.
		09/21/00	Don't include "Types_AC.h" -- already in header.
		08/17/00	Replace CCharStr with standard strings. 
		06/06/99	Moved into ACS. 
		12/04/98	Clean up for final. 
		08/04/98	QTClassLib. 
		07/28/98	Change operator const char* to AsString for safety. 
*/

#ifndef __CFixedPoint_AC__
#include "CFixedPoint_AC.h"
#endif

// ACS

#ifndef __CFixedRect_AC__
#include "CFixedRect_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// Toolbox

#ifndef __FIXMATH__
#include <FixMath.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif

// ANSI


//========================================================================================
// CLASS CFixedPoint_AC
//========================================================================================

const CFixedPoint_AC CFixedPoint_AC::kZeroPt(0, 0);			// Constructor keeps this from getting dead-stripped

#if qDebug
//----------------------------------------------------------------------------------------
// CFixedPoint_AC::AsText:
//----------------------------------------------------------------------------------------
CString_AC CFixedPoint_AC::AsText() const
{
	CString_AC text;
	stringprintf(text, "CFixedPoint_AC(%d, %d)", x, y);
	return text;
}
#endif
	
//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator+=:
//----------------------------------------------------------------------------------------
CFixedPoint_AC& CFixedPoint_AC::operator+=(const CFixedPoint_AC& pt)
{
	y += pt.y;
	x += pt.x;

	return *this;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator-=:
//----------------------------------------------------------------------------------------
CFixedPoint_AC& CFixedPoint_AC::operator-=(const CFixedPoint_AC& pt)
{
	y -= pt.y;
	x -= pt.x;

	return *this;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator*=:
//----------------------------------------------------------------------------------------
CFixedPoint_AC& CFixedPoint_AC::operator*=(const CFixedPoint_AC& pt)
{
	y = FixMul(y, pt.y);
	x = FixMul(x, pt.x);

	return *this;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator-=:
//----------------------------------------------------------------------------------------
CFixedPoint_AC& CFixedPoint_AC::operator/=(const CFixedPoint_AC& pt)
{
	y = FixDiv(y, pt.y);
	x = FixDiv(x, pt.x);

	return *this;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator+:
//----------------------------------------------------------------------------------------
CFixedPoint_AC CFixedPoint_AC::operator+(const CFixedPoint_AC& pt) const
{ return CFixedPoint_AC(*this) += pt; }

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator-:
//----------------------------------------------------------------------------------------
CFixedPoint_AC CFixedPoint_AC::operator-(const CFixedPoint_AC& pt) const
{ return CFixedPoint_AC(*this) -= pt; }

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator*:
//----------------------------------------------------------------------------------------
CFixedPoint_AC CFixedPoint_AC::operator*(const CFixedPoint_AC& pt) const
{ return CFixedPoint_AC(*this) *= pt; }

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator-:
//----------------------------------------------------------------------------------------
CFixedPoint_AC CFixedPoint_AC::operator/(const CFixedPoint_AC& pt) const
{ return CFixedPoint_AC(*this) /= pt; }

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator-:
//----------------------------------------------------------------------------------------
CFixedPoint_AC CFixedPoint_AC::operator-() const
{
	return CFixedPoint_AC(-x, -y);
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator++:
//----------------------------------------------------------------------------------------
CFixedPoint_AC& CFixedPoint_AC::operator++()
{
	y += fixed1;
	x += fixed1;

	return *this;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator--:
//----------------------------------------------------------------------------------------
CFixedPoint_AC& CFixedPoint_AC::operator--()
{
	y -= fixed1;
	x -= fixed1;

	return *this;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator>=:
//----------------------------------------------------------------------------------------
bool CFixedPoint_AC::operator>=(const CFixedPoint_AC& pt) const
{
	return y >= pt.y && x >= pt.x;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator<=:
//----------------------------------------------------------------------------------------
bool CFixedPoint_AC::operator<=(const CFixedPoint_AC& pt) const
{
	return y <= pt.y && x <= pt.x;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator>:
//----------------------------------------------------------------------------------------
bool CFixedPoint_AC::operator>(const CFixedPoint_AC& pt) const
{
	return y > pt.y && x > pt.x;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::operator<=:
//----------------------------------------------------------------------------------------
bool CFixedPoint_AC::operator<(const CFixedPoint_AC& pt) const
{
	return y < pt.y && x < pt.x;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::Offset:
//----------------------------------------------------------------------------------------
void CFixedPoint_AC::Offset(Fixed iX, Fixed iY)
{
	y += iY;
	x += iX;
}

//----------------------------------------------------------------------------------------
// CFixedPoint_AC::ConstrainTo:
//----------------------------------------------------------------------------------------
void CFixedPoint_AC::ConstrainTo(const CFixedRect_AC& rt)
{
	if (y < rt.top)
		y = rt.top;
	if (y > rt.bottom)
		y = rt.bottom;
	if (x < rt.left)
		x = rt.left;
	if (x > rt.right)
		x = rt.right;
}


//----------------------------------------------------------------------------------------
// End of CFixedPoint_AC.cpp
