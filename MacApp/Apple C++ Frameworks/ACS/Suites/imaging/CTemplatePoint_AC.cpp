//----------------------------------------------------------------------------------------
// CTemplatePoint_AC.cpp
// Copyright © 1996-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/05/01	Change to use CString_AC instead of std::string.
		01/10/01	Revert. 
		01/09/01	All template functions must be in header so those in the
					implementation file were moved into the header.
		01/02/01	Update copyright.
		08/17/00	Get template to compile in a namespace. 
		08/17/00	Replace CCharStr with standard strings. 
		03/23/00	Implementation moved into header.
		04/15/99	Modified CTemplatePoint_AC<T>::kZeroPt definition.
		03/24/99	Update copyright notice.
*/

#ifndef __CTemplatePoint_AC__
#include "CTemplatePoint_AC.h"
#endif

// ACS

#ifndef __CTemplateRect_AC__
#include "CTemplateRect_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// Toolbox

#ifndef __LIMITS__
#include <limits.h>
#endif

//========================================================================================
// CTemplatePoint_AC<T> method definitions
//========================================================================================

#ifndef __GNUC__
	// •••  GCC doesn't seem to like the following:
	template <class T>
	const typename CTemplatePoint_AC<T> CTemplatePoint_AC<T>::kZeroPt;
#endif

#if qDebug
//----------------------------------------------------------------------------------------
// CTemplatePoint_AC<T>::AsText
//----------------------------------------------------------------------------------------

template <class T>
CString_AC CTemplatePoint_AC<T>::AsText() const
{
	CString_AC text;
	stringprintf(text, "CTemplatePoint_AC(%d, %d)", h, v);
	return text;
}
#endif // qDebug
	
//----------------------------------------------------------------------------------------
// CTemplatePoint_AC<T>::ConstrainTo:
//----------------------------------------------------------------------------------------

template <class T>
void CTemplatePoint_AC<T>::ConstrainTo(const CTemplateRect_AC<T>& rt)
{
	if (v < rt.top)
		v = rt.top;
	if (v > rt.bottom)
		v = rt.bottom;
	if (h < rt.left)
		h = rt.left;
	if (h > rt.right)
		h = rt.right;
}


//----------------------------------------------------------------------------------------
// End of CTemplatePoint_AC.cpp
