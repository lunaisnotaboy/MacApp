//----------------------------------------------------------------------------------------
// CPoint_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/05/01	Change to use CString_AC instead of std::string.
		01/02/01	Update copyright.
		08/17/00	Replace CCharStr with standard strings. 
		03/31/00	[G] Do not implement AsText.
		02/22/00	Changed CPoint_AC::AsText to be defined for qDebug
					instead of qCoreDebug since some usage comes in for qDebug.
		03/24/99	Update copyright notice.
		10/07/98	Change operator const char* to operator CChar63_AC. 
*/

#ifndef __CPoint_AC__
#include "CPoint_AC.h"
#endif

// ACS

#ifndef __CRect_AC__
#include "CRect_AC.h"
#endif

#ifndef __Types_AC__
#include "Types_AC.h"
#endif

#ifndef __StdStringUtils_AC__
#include "StdStringUtils_AC.h"
#endif

// ANSI


//========================================================================================
// CLASS CPoint_AC
//========================================================================================

const CPoint_AC CPoint_AC::kZeroPt(0, 0);			// Constructor keeps this from getting dead-stripped

#if qDebug
//----------------------------------------------------------------------------------------
// CPoint_AC::AsText:
//----------------------------------------------------------------------------------------
CString_AC CPoint_AC::AsText() const
{
	CString_AC text;
	stringprintf(text, "CPoint_AC(%d, %d)", h, v);
	return text;
}
#endif // qDebug
	
//----------------------------------------------------------------------------------------
// CPoint_AC::operator+=:
//----------------------------------------------------------------------------------------
CPoint_AC& CPoint_AC::operator+=(const CPoint_AC& pt)
{
	v += pt.v;
	h += pt.h;

	return *this;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator-=:
//----------------------------------------------------------------------------------------
CPoint_AC& CPoint_AC::operator-=(const CPoint_AC& pt)
{
	v -= pt.v;
	h -= pt.h;

	return *this;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator*=:
//----------------------------------------------------------------------------------------
CPoint_AC& CPoint_AC::operator*=(const CPoint_AC& pt)
{
	v *= pt.v;
	h *= pt.h;

	return *this;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator-=:
//----------------------------------------------------------------------------------------
CPoint_AC& CPoint_AC::operator/=(const CPoint_AC& pt)
{
	v /= pt.v;
	h /= pt.h;

	return *this;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator+:
//----------------------------------------------------------------------------------------
CPoint_AC CPoint_AC::operator+(const CPoint_AC& pt) const
{ return CPoint_AC(*this) += pt; }

//----------------------------------------------------------------------------------------
// CPoint_AC::operator-:
//----------------------------------------------------------------------------------------
CPoint_AC CPoint_AC::operator-(const CPoint_AC& pt) const
{ return CPoint_AC(*this) -= pt; }

//----------------------------------------------------------------------------------------
// CPoint_AC::operator*:
//----------------------------------------------------------------------------------------
CPoint_AC CPoint_AC::operator*(const CPoint_AC& pt) const
{ return CPoint_AC(*this) *= pt; }

//----------------------------------------------------------------------------------------
// CPoint_AC::operator-:
//----------------------------------------------------------------------------------------
CPoint_AC CPoint_AC::operator/(const CPoint_AC& pt) const
{ return CPoint_AC(*this) /= pt; }

//----------------------------------------------------------------------------------------
// CPoint_AC::operator-:
//----------------------------------------------------------------------------------------
CPoint_AC CPoint_AC::operator-() const
{
	return CPoint_AC(-h, -v);
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator++:
//----------------------------------------------------------------------------------------
CPoint_AC& CPoint_AC::operator++()
{
	++v;
	++h;

	return *this;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator--:
//----------------------------------------------------------------------------------------
CPoint_AC& CPoint_AC::operator--()
{
	--v;
	--h;

	return *this;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator>=:
//----------------------------------------------------------------------------------------
bool CPoint_AC::operator>=(const CPoint_AC& pt) const
{
	return v >= pt.v && h >= pt.h;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator<=:
//----------------------------------------------------------------------------------------
bool CPoint_AC::operator<=(const CPoint_AC& pt) const
{
	return v <= pt.v && h <= pt.h;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator>:
//----------------------------------------------------------------------------------------
bool CPoint_AC::operator>(const CPoint_AC& pt) const
{
	return v > pt.v && h > pt.h;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::operator<=:
//----------------------------------------------------------------------------------------
bool CPoint_AC::operator<(const CPoint_AC& pt) const
{
	return v < pt.v && h < pt.h;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::Offset:
//----------------------------------------------------------------------------------------
void CPoint_AC::Offset(short iH, short iV)
{
	v += iV;
	h += iH;
}

//----------------------------------------------------------------------------------------
// CPoint_AC::ConstrainTo:
//----------------------------------------------------------------------------------------
void CPoint_AC::ConstrainTo(const CRect_AC& rt)
{
	if (v < rt.top)
		v = rt.top;
	if (v > rt.bottom)
		v = rt.bottom;
	if (h < rt.left)
		h = rt.left;
	if (h > rt.right)
		h = rt.right;
}


/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		 4/26/96	Made C/VPoint/Rect default constructors set the point/rect to a cleared value. Made
		 					clearing very fast/compact. Eliminated the now unnecessary hand clearing of C/VPoint/Rects.
		 4/26/96	Removed inlining of standalone operators (*+-/|&). They are still defined in terms
		 					of their assignment operator equivalents, but the compilers just aren't smart
							enough to inline them properly yet.
		 4/24/96	Added Numerous utility routines and made the C/V versions orthoganal
		 4/24/96	Added CPoint_AC/VPoint++/--
		 4/15/96	Added CRect/VRect::&=/|= operators
		----- R10 -----
		 4/10/96	Cut the cheating down a little. We can use FP loads and stores to move
		 					data, but unless the data is valid FP then we can't do raw compares.
		 4/08/96	Added more cheating in ==/!= operators
		 3/26/96	Made CPoint_AC/CRect/VPoint/VRect::char* operator return a const char*
		 3/26/96	Made CPoint_AC/CRect/VPoint/VRect::char* operator which is only used for debugging
		 					an inline so it could return the c style string on the stack
		 3/04/96	Made empty CPoint_AC constructor inline again. It used to be
							outlined because CFront claimed that some expression was too complex,
							but we don't care about CFront anymore (yea!).
							Made CPoint_AC and CRect selector operators inline to reduce code bulk (they just resolve
							addresses!). Made CPoint_AC and CRect constructors and conversion
							operators inline to reduce code bulk.
		 2/27/96	Derive CRect from Rect so it is really compatible. 
		 					Same for CPoint_AC. 
		----- 3.3b1 -----
		 3/03/95	Include PascalString.h for use of MABlockMove.
		02/22/95	1222850 MacApp should use MABlockMove and MABlockMoveOverlap everywhere
		 7/12/94	Change the Contains methods so a point on the bottom or
							right edge is not in the rect (more like QuickDraw). 
							Fix suggested by Carsten Brinkschulte. 
*/


//----------------------------------------------------------------------------------------
// End of CPoint_AC.cpp
