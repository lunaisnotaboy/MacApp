//----------------------------------------------------------------------------------------
// CPascalString_AC.cpp
// Copyright � 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/18/01	Added using std::...
		06/05/01	Include CMultiLocal_AC.h.
		05/02/01	Trace string conversions. 
					Define kEmptyString_AC as an empty string. 
		01/20/01	Eliminate std::string conversion operators.  Don't include string.h.
		01/19/01	Revert. 
		01/05/01	Change to use CString_AC instead of std::string.  Don�t include string.h.
		01/02/01	Update copyright.
		12/26/00	Move standard string conversion out of line for easier debugging. 
					Add CopyFrom methods that take a standard string. 
		12/26/00	[W] Reworked CompareText_AC.  Added AddLineFeeds and StripLineFeeds.
		11/27/00	[G] Customize kEmptyString_AC.
		06/14/00	Eliminate unnecessary GetRegionCode calls.
		06/06/00	[2477988] Fix string length calculation in
					CPascalStr_AC::CopyFrom(const char* str).
		03/16/00	[G] Do not define kEmptyString_AC.
		08/18/99	Check for NULL return value from CMultiLocale_AC::GetString.
		03/24/99	Update copyright notice.
		10/06/98	Clean up includes. 
*/

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

// ACS


#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif
#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

// usings

using std::strlen;
using std::strcmp;
using std::strstr;

//----------------------------------------------------------------------------------------
// static data members
//----------------------------------------------------------------------------------------
Handle CPascalStr_AC::fgItl2Handle;

//----------------------------------------------------------------------------------------
// Template Instantiations
//----------------------------------------------------------------------------------------

// Instantiate Template classes for all String types declared in <Types.h>
template class TemplatePascalStr<Str255>;
template class TemplatePascalStr<Str63>;
template class TemplatePascalStr<Str32>;
template class TemplatePascalStr<Str31>;
template class TemplatePascalStr<Str27>;
template class TemplatePascalStr<Str15>;

// Extras that also get commonly used
template class TemplatePascalStr<Str8>;
template class TemplatePascalStr<Str2>;

//----------------------------------------------------------------------------------------
// Constants
//----------------------------------------------------------------------------------------

//========================================================================================
// CStringTrace_AC
//========================================================================================

#if qTraceStrings
bool CStringTrace_AC::fgTrace;

//----------------------------------------------------------------------------------------
// CStringTrace_AC::Print
//----------------------------------------------------------------------------------------

void CStringTrace_AC::Print(const char* inString, const char* inFile, short inLine)
{
	ProgramReport_AC("File \"%s\"; Line %d; # \"%s\"\n", inFile, inLine, inString);
}

void CStringTrace_AC::Print(const unsigned char* inString, const char* inFile, short inLine)
{
	char temp[256];
	int n = inString[0];
	BlockMove_AC(&inString[1], temp, n);
	temp[n] = 0;
	ProgramReport_AC("File \"%s\"; Line %d; # \"\\p%s\"\n", inFile, inLine, temp);
}

void CStringTrace_AC::Print(const std::string& inString, const char* inFile, short inLine)
{
	ProgramReport_AC("File \"%s\"; Line %d; # string(\"%s\")\n", inFile, inLine, inString.c_str());
}

void CStringTrace_AC::Print(const CPascalStr_AC& inString, const char* inFile, short inLine)
{
	char temp[256];
	int n = inString[0];
	BlockMove_AC(&inString[1], temp, n);
	temp[n] = 0;
	ProgramReport_AC("File \"%s\"; Line %d; # CPascalStr_AC(\"%s\")\n", inFile, inLine, temp);
}

#endif // qTraceStrings

//========================================================================================
// CLASS CCharStr_AC
//========================================================================================
//----------------------------------------------------------------------------------------
// CCharStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CCharStr_AC::CopyFrom(const unsigned char* str, unsigned char maxLength)
{
	if (!str)
		*(char*)this = 0;
	else
	{
		size_t possibleLength = str[0];
		possibleLength = possibleLength < maxLength ? possibleLength : maxLength;

		BlockMove_AC(&str[1], this, possibleLength);
		reinterpret_cast<char*>(this)[possibleLength] = 0;
	}
}

//----------------------------------------------------------------------------------------
// CCharStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CCharStr_AC::CopyFrom(const char* str, size_t maxLength)
{
	if (!str)
		*(char*)this = 0;
	else
	{
		size_t possibleLength = strlen(str);
		possibleLength = possibleLength < maxLength ? possibleLength : maxLength;

		BlockMove_AC(str, this, possibleLength);
		reinterpret_cast<char*>(this)[possibleLength] = 0;
	}
}

//----------------------------------------------------------------------------------------
// CCharStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CCharStr_AC::CopyFrom(const void* str, size_t forLength)
{
	if (!str)
		*(char*)this = 0;
	else
	{
		//
		// NOTE: there is _NO_ maxlength protection here, be careful!
		// However, since Length() is an unsigned char
		// its maximum value is kStr255Len anyways.
		//
		BlockMove_AC(str, this, forLength);
		reinterpret_cast<char*>(this)[forLength] = 0;
	}
}

//----------------------------------------------------------------------------------------
// CCharStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CCharStr_AC::CopyFrom(const std::string& str, size_t maxLength)
{
	size_t possibleLength = str.length();
	possibleLength = possibleLength < maxLength ? possibleLength : maxLength;
	if (possibleLength > 0)
		BlockMove_AC(str.data(), this, possibleLength);
	reinterpret_cast<char*>(this)[possibleLength] = 0;
}

//----------------------------------------------------------------------------------------
// CCharStr_AC::Length
//----------------------------------------------------------------------------------------

size_t CCharStr_AC::Length() const
{ 
	return strlen(reinterpret_cast<const char*>(this)); 
}

#if 0
// ���

//----------------------------------------------------------------------------------------
// CCharStr_AC::operator std::string
//----------------------------------------------------------------------------------------
CCharStr_AC::operator std::string() const
{ 
	return std::string(reinterpret_cast<const char*>(this));
}

#endif

//========================================================================================
// CLASS CPascalStr_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(const unsigned char* str, unsigned char maxLength)
{
	if (!str)
		Length() = 0;
	else
	{
		unsigned char possibleLength = str[0];
		possibleLength = possibleLength < maxLength ? possibleLength : maxLength;

		Length() = possibleLength;
		BlockMove_AC(&str[1], &(*this)[1], Length());
	}
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(const char* str, unsigned char maxLength)
{
	if (!str)
		Length() = 0;
	else
	{
		unsigned char possibleLength = static_cast<unsigned char>(strlen(str));
		possibleLength = possibleLength < maxLength ? possibleLength : maxLength;

		Length() = possibleLength;
		BlockMove_AC(str, &(*this)[1], Length());
	}	
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(const void* str, unsigned char forLength)
{
	//
	// NOTE: there is _NO_ maxlength protection here, be careful!
	// However, since Length() is an unsigned char
	// its maximum value is kStr255Len anyways.
	//
	if (!str)
		Length() = 0;
	else
	{
		Length() = forLength;
		BlockMove_AC(str, &(*this)[1], Length());
	}
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(const unsigned char* str)
{
	//
	// NOTE: there is _NO_ maxlength protection here, be careful!
	// However, since Length() is an unsigned char
	// its maximum value is kStr255Len anyways.
	//
	if (!str)
		Length() = 0;
	else
	{
		Length() = str[0];
		BlockMove_AC(&str[1], &(*this)[1], Length());
	}
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(const char* str)
{
	//
	// NOTE: there is _NO_ maxlength protection here, be careful!
	// However, since Length() is an unsigned char
	// its maximum value is kStr255Len anyways.
	//
	if (!str)
		Length() = 0;
	else
	{
        size_t len = strlen(str);
        Length() = len < 255 ? len : 255;
		BlockMove_AC(str, &(*this)[1], Length());
	}
}

#if !(qPowerPC || qNeedsMC68020)
//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(unsigned long id)
{
	//
	// NOTE: there is _NO_ maxlength protection here, be careful!
	// However, since Length() is an unsigned char
	// its maximum value is kStr255Len anyways.
	//
	Length() = sizeof(id);
	BlockMove_AC(&id, &(*this)[1], Length());
}
#endif


#if !(qPowerPC || qNeedsMC68020)
//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(unsigned short num)
{
	//
	// NOTE: there is _NO_ maxlength protection here, be careful!
	// However, since Length() is an unsigned char
	// its maximum value is kStr255Len anyways.
	//
	Length() = sizeof(num);
	BlockMove_AC(&num, &(*this)[1], Length());
}
#endif

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(short strListID, short index, unsigned char maxLength)
{
	CStr255_AC toolBoxString;
	CMultiLocale_AC::GetIndString(toolBoxString, strListID, index);

	CopyFrom(toolBoxString, maxLength);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFromSTR(ResNumber STRID, unsigned char maxLength)
{
	Length() = 0;
	StringHandle toolBoxString = CMultiLocale_AC::GetString(STRID);

	// Use cast to force usage of CopyFrom(const unsigned char* str, unsigned char maxLength).
	if (toolBoxString)
		CopyFrom(reinterpret_cast<unsigned char*>(*toolBoxString), maxLength);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(const Handle inHandle, unsigned char maxLength)
{
	if (inHandle)
	{
		Size handleSize = GetHandleSize(inHandle);
		Size sizeToCopy = handleSize > maxLength ? maxLength : handleSize;
		CopyFrom(reinterpret_cast<void*>(*inHandle), static_cast<unsigned char>(sizeToCopy));
	}
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyFrom
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyFrom(const std::string& str, unsigned char maxLength)
{
	size_t possibleLength = str.length();
	possibleLength = possibleLength < maxLength ? possibleLength : maxLength;
	Length() = possibleLength;
	if (possibleLength > 0)
		BlockMove_AC(str.data(), &(*this)[1], Length());
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyTo
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyTo(unsigned char* str) const
{
	if (str)
		BlockMove_AC(&(*this)[0], str, Length() + 1);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyTo
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyTo(char* str) const
{
	if (str)
	{
		BlockMove_AC(&(*this)[1], str, Length());
		str[Length()] = 0;	// Add null terminations
	}
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::CopyTo
//----------------------------------------------------------------------------------------

void CPascalStr_AC::CopyTo(void* str) const
{
	if (str)
		BlockMove_AC(&(*this)[1], str, Length());
}
//----------------------------------------------------------------------------------------
// CPascalStr_AC::GetMaxLength:
//----------------------------------------------------------------------------------------

unsigned char CPascalStr_AC::GetMaxLength(unsigned char pos, unsigned char length) const
{
	short testLength = Length() - pos + kLengthByte;

	testLength = (length > testLength) ? testLength : length;

	if (testLength < 0)
		testLength = 0;
		
	return static_cast<unsigned char>(testLength);
}

#if 0
// ���

//----------------------------------------------------------------------------------------
// CPascalStr_AC::operator std::string
//----------------------------------------------------------------------------------------

CPascalStr_AC::operator std::string() const
{
	return std::string(reinterpret_cast<const char*>(&(*this)[1]), Length());
}

#endif

//----------------------------------------------------------------------------------------
// CPascalStr_AC::ToULong
//----------------------------------------------------------------------------------------

unsigned long CPascalStr_AC::ToULong() const
{
	unsigned long	returnVal = 0;
	unsigned long	myLength = Length();
	if (myLength)
		BlockMove_AC(&(*this)[1], &returnVal, (sizeof(returnVal) < myLength) ? sizeof(returnVal) : myLength);
	
	return returnVal;
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::ToULong
//----------------------------------------------------------------------------------------

unsigned short CPascalStr_AC::ToUShort() const
{
	unsigned short	returnVal = 0;
	unsigned long	myLength = Length();
	if (myLength)
		BlockMove_AC(&(*this)[1], &returnVal, (sizeof(returnVal) < myLength) ? sizeof(returnVal) : myLength);
	
	return returnVal;
}

//----------------------------------------------------------------------------------------
// Bottleneck CompareText function.
//----------------------------------------------------------------------------------------

short CPascalStr_AC::CompareText_AC(const void* aPtr, const void* bPtr, short aLen, short bLen)
{
	#if !qMSWindows
		return ::CompareText(aPtr, bPtr, aLen, bLen, CPascalStr_AC::fgItl2Handle);
	#else
		if (aLen == 0 && bLen == 0)
			return 0;
		else if (aLen == 0)
			return -1;
		else if (bLen == 0)
			return 1;
		else
		{
			short result = ::strncmp(reinterpret_cast<const char*>(aPtr), reinterpret_cast<const char*>(bPtr),
							 aLen < bLen ? aLen : bLen);
			if (result == 0)
			{
				if (aLen < bLen)
					return  -1;
				else if (bLen < aLen)
					return 1;
			}
			return result;
		}
	#endif
}

//----------------------------------------------------------------------------------------
// Definitions for relational string operators helpers
//----------------------------------------------------------------------------------------

short CPascalStr_AC::CPascalStrCompare(const CPascalStr_AC& s1, const CPascalStr_AC& s2)
{
	return CompareText_AC(&s1[1], &s2[1], s1.Length(), s2.Length());
}

short CPascalStr_AC::CPascalStrCompare(const CPascalStr_AC& s1, const char* s2)
{
	return CompareText_AC(&s1[1], s2, s1.Length(), s2 ? strlen(s2) : 0);
}

short CPascalStr_AC::CPascalStrCompare(const CPascalStr_AC& s1, unsigned char ch)
{
	return CompareText_AC(&s1[1], &ch, s1.Length(), 1);
}

short CPascalStr_AC::CPascalStrCompare(const char* s1, const CPascalStr_AC& s2)
{
	return CompareText_AC(s1, &s2[1], s1 ? strlen(s1) : 0, s2.Length());
}

short CPascalStr_AC::CPascalStrCompare(unsigned char ch, const CPascalStr_AC& s2)
{
	return CompareText_AC(&ch, &s2[1], 1, s2.Length());
}


//----------------------------------------------------------------------------------------
// CPascalStr_AC::operator+:
//----------------------------------------------------------------------------------------

CStr255_AC operator+(const CPascalStr_AC& s1, const CPascalStr_AC& s2)
{
	CStr255_AC newStr;

	if (s1.Length() + s2.Length() > kStr255Len)
		newStr.Length() = kStr255Len;
	else
		newStr.Length() = s1.Length() + s2.Length();
		
	BlockMove_AC(&s1[1], &newStr[1], s1.Length());
	BlockMove_AC(&s2[1], &newStr[s1.Length() + kLengthByte], newStr.Length() - s1.Length());

	return newStr;
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::operator+:
//----------------------------------------------------------------------------------------

CStr255_AC operator+(const CPascalStr_AC& s1, const char* s2)
{
	CStr255_AC newStr;
	short s2Len = (s2) ? static_cast<short>(strlen(s2)) : 0;

	if (s1.Length() + s2Len > kStr255Len)
		newStr.Length() = kStr255Len;
	else
		newStr.Length() = s1.Length() + s2Len;
		
	BlockMove_AC(&s1[1], &newStr[1], s1.Length());
	BlockMove_AC(s2, &newStr[s1.Length() + kLengthByte], newStr.Length() - s1.Length());

	return newStr;
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::operator+:
//----------------------------------------------------------------------------------------

CStr255_AC operator+(const CPascalStr_AC& s1, unsigned char ch)
{
	CStr255_AC newStr;
	short s2Len = 1;

	if (s1.Length() + s2Len > kStr255Len)
		newStr.Length() = kStr255Len;
	else
		newStr.Length() = s1.Length() + s2Len;
		
	BlockMove_AC(&s1[1], &newStr[1], s1.Length());
	BlockMove_AC(&ch, &newStr[s1.Length() + kLengthByte], newStr.Length() - s1.Length());

	return newStr;
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::operator+:
//----------------------------------------------------------------------------------------
CStr255_AC operator+(const CPascalStr_AC& s1, const unsigned char* s2)
{
	return s1 + *reinterpret_cast<const CPascalStr_AC*>(s2);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::operator+:
//----------------------------------------------------------------------------------------

CStr255_AC operator+(const char* s1, const CPascalStr_AC& s2)
{
	CStr255_AC newStr;
	short s1Len = (s1) ? static_cast<short>(strlen(s1)) : 0;

	if (s1Len + s2.Length() > kStr255Len)
		newStr.Length() = kStr255Len;
	else
		newStr.Length() = s1Len + s2.Length();
		
	BlockMove_AC(s1, &newStr[1], s1Len);
	BlockMove_AC(&s2[1], &newStr[s1Len + kLengthByte], newStr.Length() - s1Len);

	return newStr;
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::operator+:
//----------------------------------------------------------------------------------------

CStr255_AC operator+(unsigned char ch, const CPascalStr_AC& s2)
{
	CStr255_AC newStr;
	short s1Len = 1;

	if (s1Len + s2.Length() > kStr255Len)
		newStr.Length() = kStr255Len;
	else
		newStr.Length() = s1Len + s2.Length();
		
	BlockMove_AC(&ch, &newStr[1], s1Len);
	BlockMove_AC(&s2[1], &newStr[s1Len + kLengthByte], newStr.Length() - s1Len);

	return newStr;
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::operator+:
//----------------------------------------------------------------------------------------

CStr255_AC operator+(const unsigned char* s1, const CPascalStr_AC& s2)
{
	return *reinterpret_cast<const CPascalStr_AC*>(s1) + s2;
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::Insert
//----------------------------------------------------------------------------------------

void CPascalStr_AC::Insert(const char* insStr, unsigned char insStrLength, unsigned char pos, unsigned char maxLength)
{
	if (insStr)
	{
		int shortPos = pos;		// Was: short.
		if (shortPos > Length() + 1)
		{
#if qDebugMsg
			::ProgramReport_AC("CPascalStr_AC::Insert: Insert position greater than length of CPascalStr_AC.\n");
#endif
			if (Length() < maxLength)	
				shortPos = Length() + 1;
		}
	
#if qDebugMsg
		if (static_cast<short>(Length()) + insStrLength > maxLength)
			::ProgramReport_AC("CPascalStr_AC::Insert: CPascalStr_AC truncated during insert call.\n");	
#endif
	
		short usableLengthOfInsertString;
		short endPosOfInsertString;
		short usableLengthOfShiftedString;
		
		if (shortPos + insStrLength > maxLength)
			usableLengthOfInsertString = maxLength - shortPos + 1;
		else
			usableLengthOfInsertString = insStrLength;
		endPosOfInsertString = shortPos + usableLengthOfInsertString - 1;
		
		if ((endPosOfInsertString + 1) + (Length() - shortPos + 1) > maxLength)
			usableLengthOfShiftedString = maxLength - endPosOfInsertString;
		else
			usableLengthOfShiftedString = Length() - shortPos + 1;
			
		BlockMoveOverlap_AC(&(*this)[shortPos], &(*this)[endPosOfInsertString + 1], usableLengthOfShiftedString);
		BlockMove_AC(insStr, &(*this)[shortPos], usableLengthOfInsertString);
		Length() = usableLengthOfShiftedString + endPosOfInsertString;
	}
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::Insert
//----------------------------------------------------------------------------------------

void CPascalStr_AC::Insert(const char* insStr, unsigned char pos, unsigned char maxLength)
{
	if (insStr)
		Insert(insStr, strlen(insStr), pos, maxLength);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::Insert
//----------------------------------------------------------------------------------------

void CPascalStr_AC::Insert(const char* insStr, unsigned char pos)
{
	if (insStr)
		Insert(insStr, strlen(insStr), pos, kStr255Len);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::Insert
//----------------------------------------------------------------------------------------

void CPascalStr_AC::Insert(const CPascalStr_AC& insStr, unsigned char pos, unsigned char maxLength)
{
	Insert(reinterpret_cast<const char*>(&insStr[1]), insStr.Length(), pos, maxLength);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::Insert
//----------------------------------------------------------------------------------------

void CPascalStr_AC::Insert(const CPascalStr_AC& insStr, unsigned char pos)
{
	Insert(reinterpret_cast<const char*>(&insStr[1]), insStr.Length(), pos, kStr255Len);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::Pos
//----------------------------------------------------------------------------------------

unsigned char CPascalStr_AC::Pos(const char* subStr, unsigned char startPos) const
{
	char cStr[kStr255Len + 1];

	BlockMove_AC(&(*this)[1], cStr, Length());
	cStr[Length()] = 0;
	char* ptr = strstr(&cStr[startPos - 1], subStr);
	
	return ptr ? ptr - &cStr[0] + 1 : 0;
}


//----------------------------------------------------------------------------------------
// CPascalStr_AC::Pos(CPascalStr_AC):
//----------------------------------------------------------------------------------------

unsigned char CPascalStr_AC::Pos(const CPascalStr_AC& subStr, unsigned char startPos) const
{
	char cStr[kStr255Len + 1];

	BlockMove_AC(&subStr[1], cStr, subStr.Length());
	cStr[subStr.Length()] = 0;

	return Pos(cStr, startPos);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::Pos(CPascalStr_AC):
//----------------------------------------------------------------------------------------

unsigned char CPascalStr_AC::Pos(char c, unsigned char startPos) const
{
	char cStr[2];

	cStr[0] = c;
	cStr[1] = 0;

	return Pos(cStr, startPos);
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::Delete
//----------------------------------------------------------------------------------------
void CPascalStr_AC::Delete(unsigned char pos, unsigned char length)
{
	if ((pos > 0) && (length > 0) && (pos <= Length()))	// should also check that pos <= kMaxLength
	{
		if (pos + length > Length())
			Length() = pos - 1;
		else
		{
			BlockMoveOverlap_AC(&(*this)[static_cast<int>(pos) + static_cast<int>(length)],
								&(*this)[static_cast<int>(pos)], Length() - (pos + length) + kLengthByte);
			Length() -= length;
		}
	}
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::SetItl2Handle
//----------------------------------------------------------------------------------------

Handle CPascalStr_AC::SetItl2Handle(Handle itsItl2Handle)
{
	Handle returnVal = fgItl2Handle;
	fgItl2Handle = itsItl2Handle;
	
	return returnVal;
}

#if qMSWindows
// move these to somewhere in ACS, perhaps methods of CStr255_AC

//----------------------------------------------------------------------------------------
// CPascalStr_AC::AddLineFeeds
//----------------------------------------------------------------------------------------

void CPascalStr_AC::AddLineFeeds()
{
	unsigned char index = 1;
	while ((index = Pos("\r", index)) != 0)
	{
		index++;
		if (operator[](index) != '\n')
			Insert("\n", index);
	}
}

//----------------------------------------------------------------------------------------
// CPascalStr_AC::StripLineFeeds
//----------------------------------------------------------------------------------------

void CPascalStr_AC::StripLineFeeds()
{
	short index = 1;
	while ((index = Pos("\n", index)) != 0)
		Delete(index, 1);
}

#endif


//----------------------------------------------------------------------------------------
// End of CPascalString_AC.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/20/96	[1290382] (Strings) Str255_AC could have constructor for STR# id & index
		04/26/96	Made Pos a const method
		04/18/96	Added nil pointer protections to CCharStr_AC/CString_AC::CopyFrom/CopyTo
		----- R10 -----
		03/26/96	Change the name of CString_AC to CPascalStr_AC for clarity
		03/26/96	coerce CStrxxx_AC to const char* to get copies of the strings as c style strings
		 3/23/96	Added CopyTo
		 3/23/96	Change to CompareText in relational operators to avoid needless construction
		 					of temporaries.
		 3/21/96	Had conditional test (?) backwards for null pointer tests in operator+
		 3/15/96	CString_AC has no data members now. All subclasses have to have their
		 					own fStr data member. This allows the strings to look like Strxxx's in
		 					the debuggers and to simplify the operator functions.
		 					Also, all CString_AC subclasses can now be defined with nothing but inlines
		 					for simplicity.
		----- 3.3b1 -----
		 8/ 9/95	mrw		Cleanup in ::Copy funcs
		  7/5/95	Cosmetic. 
		 3/17/95	Reverting CString_AC::Pos for now. 
		 3/15/95	New versions of BlockMove_AC, BlockMoveOverlap_AC and
							CString_AC::Pos(char*). 
		  3/3/95	Remove casts to (size_t) from calls to BlockMove_AC. 
							BlockMove_AC and BlockMoveOverlap_AC now test if
							size_t < ulong at compile time. 
		 2/25/95	Include Limits, use USHRT_MAX instead of 65535. 
		 2/24/95	Change BlockMove_AC and BlockMoveOverlap_AC to regular
							functions for 68K. 
		10/26/94	Made Copy const. 
		  			JS		Use BlockMove_AC(), BlockMoveOverlap_AC, not BlockMove(), memcpy(), memmove(), strncpy().
							Changed default constructors to initialize to empty string.
							Changed number of temporary strings from 4 to 8
							Make operator[] and unsigned char*() inline
							Fix bugs in constructors out of const unsigned char* str
							Optimized constructors to only move required data
							General cleanup of code for readability
*/