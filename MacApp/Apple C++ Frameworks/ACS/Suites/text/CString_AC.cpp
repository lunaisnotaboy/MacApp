//----------------------------------------------------------------------------------------
// CString_AC.cpp
// Copyright � 2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		07/18/01	Added using std::strlen.
		06/05/01	Include CMultiLocal_AC.h.
		05/02/01	Trace string conversions. 
							Optimize kStartMarker and kEndMarker. 
		04/17/01	Correct tailLength comparison in DoSubstitution.
		04/18/01	Don't need to qualify types belonging to CString_AC. 
		04/07/01	[PB] Comparison between signed and unsigned. 
		01/24/01	Changed CString_AC ctor for STR to not throw if resource not found.
		01/22/01	Use ThrowIfNULLResource_AC in CString_AC STR ctor.
		01/19/01	Changed DoSubstitution so that if startPos is npos then
							no substition is done at all or if the original string
							is empty then it is always substituted.
		01/16/01	Pass string address in AsStr255 and AsStr63.
		01/11/01	Added GetSubstitutionMetrics, DoSubstitution.
		01/05/01	Resurrected.
*/

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

// ACS

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

// Usings

using std::strlen;

//========================================================================================
// Namespacing
//========================================================================================

using std::string;

//========================================================================================
// CString_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CString_AC ctor from STR#
//----------------------------------------------------------------------------------------

CString_AC::CString_AC(ResNumber strListID, short index)
// Construct a string from a STR# resource.
//
// strResourceID:	The resource number of the STR# containing the string to be
//					retrieved.
// index:			The index into the STR# by which the string is retrieved.
//
// Call?	As needed.
{
	Str255	aStr255;
	CMultiLocale_AC::GetIndString(aStr255, strListID, index);
#if qDebug
	char*		stringStart = reinterpret_cast<char*>(&aStr255[1]);
	size_type	stringLength = static_cast<unsigned long>(aStr255[0]);
	assign(stringStart, stringLength);
#else
	assign(reinterpret_cast<char*>(&aStr255[1]), static_cast<unsigned long>(aStr255[0]));
#endif
}

//----------------------------------------------------------------------------------------
// CString_AC ctor from STR
//----------------------------------------------------------------------------------------

CString_AC::CString_AC(ResNumber strResourceID)
// Construct a string from a STR resource.
//
// strResourceID:	The resource number of the STR to be retrieved.
//
// Call?	As needed.
{
	StringHandle toolboxStringH = CMultiLocale_AC::GetString(strResourceID);
	if (toolboxStringH)	
		assign(reinterpret_cast<char*>(*toolboxStringH),
			   ::GetHandleSize(reinterpret_cast<Handle>(toolboxStringH)));
}

//----------------------------------------------------------------------------------------
// AsStr255
//----------------------------------------------------------------------------------------

void CString_AC::AsStr255(Str255& toStr255) const
// AsStr255 converts a standard string into a Str255.  At most the first 255
// characters of our string are assigned to the destination Str255.
//
// toStr255:	A reference to a Str255 that is to receive the string.
//
// Call?	As needed.
{
	TraceString_AC(*this);
	size_type	strLength = Min_AC(sizeof(Str255) - 1, size());
	toStr255[0] = strLength;
	BlockMove_AC(reinterpret_cast<const void*>(c_str()),
				 reinterpret_cast<void*>(&toStr255[1]), strLength);
}

//----------------------------------------------------------------------------------------
// AsStr63
//----------------------------------------------------------------------------------------

void CString_AC::AsStr63(Str63& toStr63) const
// AsStr63 converts a standard string into a Str63.  At most the first 63
// characters of our string are assigned to the destination Str63.
//
// toStr63:	A reference to a Str63 that is to receive the string.
//
// Call?	As needed.
{
	TraceString_AC(*this);
	size_type	strLength = Min_AC(sizeof(Str63) - 1, size());
	toStr63[0] = strLength;
	BlockMove_AC(reinterpret_cast<const void*>(c_str()),
				 reinterpret_cast<void*>(&toStr63[1]), strLength);
}

//----------------------------------------------------------------------------------------
// GetSubstitutionMetrics
//----------------------------------------------------------------------------------------

bool CString_AC::GetSubstitutionMetrics(size_type&	startPos,
										size_type&	tailSize,
										short		inScript) const
// ParseTitleTemplate will scan our string (usually the title of a window or document)
// looking for substitutable title markers.  A true is returned if the appropriate markers
// were found or if the string is empty.  The marked postion of the template string is
// not removed.  It is possible to successfully find a start marker but no matching
// end marker.
//
// startPos		A reference to a string position that receives the position of the first
//				character of the starting substitution marker or npos if not found.  Note
//				that a 0 is returned if the string is empty.
// tailSize		A reference to a string length that receives the length of the constant
//				string that follows the trailing marker and which is to be retained
//				during any substitution.  If this is npos then do no substitution.  If
//				this is 0 then substitute up to the very end of the string.
// inScript		A short containing the script system we are to use when scanning.
//
// Call?	As needed.	
{
	#pragma unused (inScript)					// ��� Script should be taken into account.

	static const char*	kStartMarker = "<<<";	// ��� These should be resources.
	static const char*	kEndMarker = ">>>";

	if (empty())
	{
		startPos = 0;	// No template string at all so we will always substitute
		tailSize = 0;	// by specifying a start pos of 0 and a tail length of 0.
	}
	else
	{
		startPos = find(kStartMarker);
		if (startPos != npos)
		{
			// We've found the starting marker.  Search for the end marker.
			size_type	endPos = startPos + strlen(kStartMarker);
			size_type	postDocName = find(kEndMarker, endPos);
			if (postDocName != npos)
				tailSize = size() - (postDocName + strlen(kEndMarker));
			else
				tailSize = npos;
		}
	}

	return startPos != npos;
}

//----------------------------------------------------------------------------------------
// DoSubstitution
//----------------------------------------------------------------------------------------

CString_AC CString_AC::DoSubstitution(const CString_AC&	substitute,
									  size_type			startPos,
									  size_type			tailSize) const
// DoSubstitution replaces a marked substring with the substitute string
// provided and returns the modified string.  The marker string is started with the
// characters '<<<' and terminated with the characters '>>>' and includes everything
// in between.  If the original string is empty then it is replaced with the
// substitute string.  The original string is not changed.
//
// substitute:	A string containing the text that is to be inserted into the title.
// startPos:	A size_type giving the position at which the text is to be
//				inserted.  If this is npos then do no substitution.  If
//				this is 0 and tailSize is npos then we call GetSubstitutionMetrics
//				first to determine if there are any markers and to get the substitution
//				parameters.  This latter method of calling can be accomplished using
//				the default value for this parameter and is used when you just want to
//				do the substution once and will not need to do additional substitutions
//				in the future on this string.  If both startPos and tailSize are 0
//				then the entire string is substituted.
// tailSize:	A size_type giving the constant length of the text that follows the
//				substituted text and which is to be retained as part of the
//				title.  If this is npos then we substitute from the start marker
//				through the end of the string.  This parameter is ignored if the
//				startPos is either npos or 0.
//
// Call?	As needed.  Call with just the substitue string and no other parameters
//			if you just want to do the substution once and will not need to do additional
//			substitutions in the future, otherwise, call GetSubstitutionMetrics and save
//			the resulting parameters.
{
	size_type	startAt(startPos);
	size_type	tailLength(tailSize);
	CString_AC	newTitle(*this);

	if (newTitle.empty() || (startAt == 0 && tailSize == 0))
		newTitle = substitute;
	else
	{
		if (startAt == 0)
			// They want us to calculate the metrics and use them just this once.
			GetSubstitutionMetrics(startAt, tailLength);	// ��� Should consider script here.

		// Do no substitution if the startAt and tailLength are not npos.
		if (startAt != npos)
		{
			if (tailLength == npos)
				tailLength = 0;
			newTitle.replace(startAt, size() - tailLength - startAt, substitute);
		}
	}

	return	newTitle;
}

//----------------------------------------------------------------------------------------
// End of CString_AC.cpp
