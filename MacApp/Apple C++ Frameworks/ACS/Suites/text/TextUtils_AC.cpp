//----------------------------------------------------------------------------------------
// TextUtils_AC.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		03/24/99	Update copyright notice.
		11/09/98	[2279101] Created.
*/

#ifndef __TextUtils_AC__
#include "TextUtils_AC.h"
#endif

//========================================================================================
// CLASS CSuppressTESelection
//========================================================================================

//----------------------------------------------------------------------------------------
// CSuppressTESelection constructor
//----------------------------------------------------------------------------------------

CSuppressTESelection::CSuppressTESelection(TEHandle hTE, bool preserveSelection)
	:	fHTE(hTE),
		fPreserveSelection(preserveSelection)
{
	if (fHTE)
	{
		if (fPreserveSelection)
		{
			fSelStart = (*fHTE)->selStart;
			fSelEnd = (*fHTE)->selEnd;
		}
		fOutlineHilite = ::TEFeatureFlag(teFOutlineHilite, teBitClear, fHTE);
		fActive = (*fHTE)->active != 0;
		if (fActive)
			::TEDeactivate(fHTE);
	}
}

//----------------------------------------------------------------------------------------
// CSuppressTESelection destructor
//----------------------------------------------------------------------------------------

CSuppressTESelection::~CSuppressTESelection()
{
	if (fHTE)
	{
		if (fPreserveSelection)
			::TESetSelect(fSelStart, fSelEnd, fHTE);
		if (fActive)
			::TEActivate(fHTE);
		::TEFeatureFlag(teFOutlineHilite, fOutlineHilite, fHTE);
	}
}

//----------------------------------------------------------------------------------------
// End of TextUtils_AC.cpp
