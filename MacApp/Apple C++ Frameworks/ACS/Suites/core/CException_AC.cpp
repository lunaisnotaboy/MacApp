//----------------------------------------------------------------------------------------
// CException_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/09/01	[PP] Work with LException. 
		02/14/01	Include MacMemory instead of Memory_AC. 
		01/02/01	Update copyright.
		11/09/00	[PB] Change initialization order to match declaration. 
		11/01/00	[PB] Include MacErrors instead of Errors. 
		10/30/00	Split off CSourceLocation_AC, CTerminateHandler_AC and
					CMacException_AC from CException_AC. 
					Use OSStatus instead of CError_AC for errors. 
					Use a typedef for the terminate handler type. 
					Remove the fgDoThrowMessage and fgDoCatchMessage flags and
					the methods for setting them. They were not being used. 
					Remove backward compatible message and error fields. 
					Add ThrowIfBadAlloc_AC. Change ThrowIfNULL_AC to call
					ThrowIfBadAlloc_AC. Change ThrowIfOSErr_AC and 
					ThrowIfBadOSStatus_AC to call ThrowIfError_AC. 
					Rename DebugDoCatchISOMessage_AC to DoCatchISOMessage and
					DebugDoCatchForeignMessage_AC to DoCatchForeignMessage. 
					Remove DebugThrowBadCast_AC. 
					Add wrapper functions for throwing the standard C++
					exceptions from bad_alloc to underflow_error. 
		09/21/00	[W] Include typeinfo.h.
		05/15/00	CW Pro 6: namespacing. 
		04/03/00	Added ThrowIfBadOSStatus_AC and DebugThrowIfBadOSStatus_AC.
		03/31/00	[G] Use BadCast in ThrowIfBadCast_AC.
		03/23/00	Use bad_cast() for GNUC.
		12/07/99	Report fMessage instead of fError in DoCatchMessage.  Strip the path
					in DoCatchMessage, DebugDoCatchISOMessage_AC, DebugDoCatchForeignMessage_AC,
					SetThrownFrom, DebugThrowBadCast_AC
					Added * after castTo string output in DebugThrowBadCast_AC to accomodate
					change in DYNAMIC_CAST_OR_THROW_AC.  MrC's bad_cast is now okay.
					Added message output in ThrowIfNULL_AC.
		03/24/99	Update copyright notice.
		12/07/98	Fixed #warnings so they only come up for Carbon builds.
		11/16/98	[2284740] Cast lowWord in BuildMessage in case it’s negative.
		11/13/98	[2279264] Replaced a ProgramReport_AC with ProgramBreak_AC.
		11/12/98	[2279223] Include <typeinfo> instead of <typeinfo.h>.  Removed
					extra include of typeinfo.h.
		11/18/98	For Carbon, condition out calls to set_terminate because of dyld errors
		10/06/98	Clean up includes. 
*/

//----------------------------------------------------------------------------------------
// note on the terminate handler:
//
// The terminate handler gets called if an exception is thrown that is not 
// caught. The terminate_handler is not returned from and no informatation
// about the thrown exception is provided with the handler. Abort is immediately called after
// the terminate_handler. The best we can hope for is somesort of feedback saying sorry,
// we're about to terminate.
//
// The terminate_handler is called from terminate() and unexpected(), both of
// which can be user defined procs.
//
// Note also that MacApp wraps most places where an exception would be thrown
// with try/catch blocks that catch the exceptions so that appropriate
// action can be taken. Terminate will only be called in unusual circumstances,
// perhaps during application init time, for example.
//----------------------------------------------------------------------------------------

#if qMSWindows
#include <typeinfo.h>
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

// ANSI

#ifndef __cassert__
#include <cassert>
#endif

#if qDebugExceptions
	#ifndef __cstdio__
	#include <cstdio>
	#endif
#endif

#ifndef __cstring__
#include <cstring>
#endif

#ifndef __new__
#include <new>
#endif

#ifndef _STDEXCEPT
#include <stdexcept>
#endif

#ifndef __typeinfo__
#include <typeinfo>
#endif

#if qDebugExceptions
	#ifndef __stdio__
	#include <stdio.h>
	#endif
	
	#ifndef __string__
	#include <string.h>
	#endif
#endif

using std::strcmp;
using std::strncpy;

using std::bad_alloc;
using std::bad_cast;
using std::logic_error;
using std::domain_error;
using std::invalid_argument;
using std::length_error;
using std::out_of_range;
using std::runtime_error;
using std::overflow_error;
using std::range_error;
using std::underflow_error;

using std::set_terminate;
using std::terminate_handler;

//========================================================================================
// CSourceLocation_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// default ctor
//----------------------------------------------------------------------------------------

CSourceLocation_AC::CSourceLocation_AC()
	:	fLine(0)
{
	fFile[0] = 0;
}

//----------------------------------------------------------------------------------------
// ctor
//----------------------------------------------------------------------------------------

CSourceLocation_AC::CSourceLocation_AC(const char* inFile, short inLine)
	:	fLine(inLine)
{
	SetFile(inFile);
}

//----------------------------------------------------------------------------------------
// copy ctor
//----------------------------------------------------------------------------------------

CSourceLocation_AC::CSourceLocation_AC(const CSourceLocation_AC& inEx)
	:	fLine(inEx.fLine)
{ 
	SetFile(inEx.fFile);
}

//----------------------------------------------------------------------------------------
// CSourceLocation_AC::operator =
//----------------------------------------------------------------------------------------

CSourceLocation_AC& CSourceLocation_AC::operator = (const CSourceLocation_AC& inEx) 
{ 	
	SetFile(inEx.fFile);
	fLine = inEx.fLine;
	return *this; 
}

//----------------------------------------------------------------------------------------
// bool CSourceLocation_AC::operator ==
//----------------------------------------------------------------------------------------

bool CSourceLocation_AC::operator == (const CSourceLocation_AC& inEx) const
{
	return (fLine == inEx.fLine) && !strcmp(fFile, inEx.fFile);
}

//----------------------------------------------------------------------------------------
// CSourceLocation_AC::operator !=
//----------------------------------------------------------------------------------------

bool CSourceLocation_AC::operator != (const CSourceLocation_AC& inEx) const 
{
	return (fLine != inEx.fLine) || strcmp(fFile, inEx.fFile);
}

//----------------------------------------------------------------------------------------
// CSourceLocation_AC::SetLocation
//----------------------------------------------------------------------------------------

void CSourceLocation_AC::SetLocation(const char* inFile, short inLine)
{
	SetFile(inFile);
	fLine = inLine;
}

//----------------------------------------------------------------------------------------
// CSourceLocation_AC::SetFile
//----------------------------------------------------------------------------------------

void CSourceLocation_AC::SetFile(const char* inFile)
{
	if (inFile)
	{
		strncpy(fFile, LeafName_AC(inFile), sizeof(fFile) - 1);
		fFile[sizeof(fFile) - 1] = 0;
	}
	else
		fFile[0] = 0;
}


//========================================================================================
// CTerminateHandler_AC
//========================================================================================

CTerminateHandler_AC::terminate_handler_type CTerminateHandler_AC::fgPrevious;

#if qCarbonMach0
// •••  set_terminate is 'undefined symbol'
#warning "set_terminate is undefined"
#else
static CTerminateHandler_AC gSetDefault;
#endif

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CTerminateHandler_AC::CTerminateHandler_AC()
{
	fgPrevious = set_terminate(Default);
}

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------

CTerminateHandler_AC::CTerminateHandler_AC(terminate_handler inHandler)
{
	fgPrevious = set_terminate(inHandler);
}

//----------------------------------------------------------------------------------------
// CTerminateHandler_AC::Default
//----------------------------------------------------------------------------------------

void CTerminateHandler_AC::Default()
{
#if qDebugExceptions
	ProgramBreak_AC("CTerminateHandler_AC::Default: An unhandled and fatal exception of unknown type was encountered.");
#endif
	fgPrevious();
}


//========================================================================================
// CMacException_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// default ctor
//----------------------------------------------------------------------------------------

CMacException_AC::CMacException_AC()
#ifdef __PowerPlant__
	:	PP_PowerPlant::LException(0)
#else
	:	fError(0)
#endif
{
}

//----------------------------------------------------------------------------------------
// ctor
//----------------------------------------------------------------------------------------

CMacException_AC::CMacException_AC(OSStatus inError)
#ifdef __PowerPlant__
	:	PP_PowerPlant::LException(inError)
#else
	:	fError(inError)
#endif
{
}

//----------------------------------------------------------------------------------------
// copy ctor
//----------------------------------------------------------------------------------------

CMacException_AC::CMacException_AC(const CMacException_AC& inEx)
#ifdef __PowerPlant__
	:	PP_PowerPlant::LException(inEx)
#else
	:	fError(inEx.fError)
#endif
{
}

//----------------------------------------------------------------------------------------
// dtor
//----------------------------------------------------------------------------------------

CMacException_AC::~CMacException_AC() throw()
{
}

#ifndef __PowerPlant__
//----------------------------------------------------------------------------------------
// CMacException_AC::operator =
//----------------------------------------------------------------------------------------

CMacException_AC& CMacException_AC::operator = (const CMacException_AC& inEx) 
{
	fError = inEx.fError;

	return *this; 
}

//----------------------------------------------------------------------------------------
// bool CMacException_AC::operator ==
//----------------------------------------------------------------------------------------

bool CMacException_AC::operator == (const CMacException_AC& inEx) const
{
	return fError == inEx.fError;
}

//----------------------------------------------------------------------------------------
// CMacException_AC::operator !=
//----------------------------------------------------------------------------------------

bool CMacException_AC::operator != (const CMacException_AC& inEx) const 
{
	return fError != inEx.fError;
}
#endif // __PowerPlant__

//----------------------------------------------------------------------------------------
// CMacException_AC::SetError
//----------------------------------------------------------------------------------------

void CMacException_AC::SetError(OSStatus inError) 
{ 
#ifdef __PowerPlant__
	SetErrorCode(inError);
	SetErrorString(nil);
#else
	fError = inError; 
#endif
}

//----------------------------------------------------------------------------------------
// CMacException_AC::what
//----------------------------------------------------------------------------------------

const char* CMacException_AC::what() const throw() 
{ 	
	return "CMacException_AC"; 
}

#if qDebugExceptions
#if qDebugExceptions >= qDebugLevelTwo_AC
//----------------------------------------------------------------------------------------
// CMacException_AC::DoThrowMessage
//----------------------------------------------------------------------------------------

void CMacException_AC::DoThrowMessage()
{
	if (GetError() == memFullErr)
		::ProgramReport_AC("%s Thrown: type:memFullErr", what());
	else
		::ProgramReport_AC("%s Thrown: type:%ld", what(), GetError());
}

//----------------------------------------------------------------------------------------
// CMacException_AC::DoCatchMessage
//----------------------------------------------------------------------------------------

void CMacException_AC::DoCatchMessage(const char* fileName, short lineNum, bool breakInDebugger)
{
	fileName = LeafName_AC(fileName);
	if (GetError() == memFullErr)
		::ProgramReportOrBreak_AC(breakInDebugger, "%s Caught: type: memFullErr, Caught at:%s, Line:%d", what(), fileName, lineNum);
	else
		::ProgramReportOrBreak_AC(breakInDebugger, "%s Caught: type: %ld, Caught at:%s, Line:%d", what(), GetError(), fileName, lineNum);
}

//----------------------------------------------------------------------------------------
// DoCatchISOMessage
//----------------------------------------------------------------------------------------

void CMacException_AC::DoCatchISOMessage(const char* inFile, short inLine, exception& ex, bool breakInDebugger)
{
	inFile = LeafName_AC(inFile);
	::ProgramReportOrBreak_AC(breakInDebugger, "ISO standard exception %s caught at:%s, Line:%d", ex.what(), inFile, inLine);
}

//----------------------------------------------------------------------------------------
// DoCatchForeignMessage
//----------------------------------------------------------------------------------------

void CMacException_AC::DoCatchForeignMessage(const char* inFile, short inLine, bool breakInDebugger)
{
	inFile = LeafName_AC(inFile);
	::ProgramReportOrBreak_AC(breakInDebugger, "Unknown foreign exception: Caught at:%s, Line:%d", inFile, inLine);
}

#endif //	qDebugExceptions >= qDebugLevelTwo
#endif // qDebugExceptions


//========================================================================================
// CException_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// default ctor
//----------------------------------------------------------------------------------------

CException_AC::CException_AC() 
	:	CMacException_AC(0),
		fMessage(0)
{
}

//----------------------------------------------------------------------------------------
// ctor
//----------------------------------------------------------------------------------------

CException_AC::CException_AC(OSStatus inError, Message inMessage)
	:	CMacException_AC(inError),
		fMessage(inMessage)
{
}

#if qDebugExceptions
//----------------------------------------------------------------------------------------
// ctor
//----------------------------------------------------------------------------------------

CException_AC::CException_AC(OSStatus inError, const char* inFile, short inLine)
	:	CMacException_AC(inError),
		CSourceLocation_AC(inFile, inLine),
		fMessage(0)
{
}

//----------------------------------------------------------------------------------------
// ctor
//----------------------------------------------------------------------------------------

CException_AC::CException_AC(OSStatus inError, Message inMessage, const char* inFile, short inLine)
	:	CMacException_AC(inError),
		CSourceLocation_AC(inFile, inLine),
		fMessage(inMessage)
{
}

#endif

//----------------------------------------------------------------------------------------
// copy ctor
//----------------------------------------------------------------------------------------

CException_AC::CException_AC(const CException_AC& inEx) 
	:	CMacException_AC(inEx),
#if qDebugExceptions
		CSourceLocation_AC(inEx),
#endif
		fMessage(inEx.fMessage)
{ 
}

//----------------------------------------------------------------------------------------
// dtor
//----------------------------------------------------------------------------------------

CException_AC::~CException_AC() throw()
{
}

//----------------------------------------------------------------------------------------
// CException_AC::operator =
//----------------------------------------------------------------------------------------

CException_AC& CException_AC::operator = (const CException_AC& inEx) 
{ 	
	SetError(inEx.GetError());
	SetMessage(inEx.GetExceptionMessage());
	
#if qDebugExceptions
	SetLocation(inEx.fFile, inEx.fLine);
#endif

	return *this; 
}

//----------------------------------------------------------------------------------------
// CException_AC::what
//----------------------------------------------------------------------------------------

const char* CException_AC::what() const throw() 
{ 	
	return "CException_AC"; 
}

//----------------------------------------------------------------------------------------
// CException_AC::SetMessage
//----------------------------------------------------------------------------------------

void CException_AC::SetMessage(Message inMessage) 
{ 
	fMessage = inMessage; 
}

//----------------------------------------------------------------------------------------
// bool CException_AC::operator ==
//----------------------------------------------------------------------------------------

bool CException_AC::operator == (const CException_AC& inEx) const
{
	return (GetError() == inEx.GetError()) && (fMessage == inEx.fMessage);
}

//----------------------------------------------------------------------------------------
// CException_AC::operator !=
//----------------------------------------------------------------------------------------

bool CException_AC::operator != (const CException_AC& inEx) const 
{
	return (GetError() != inEx.GetError()) || (fMessage != inEx.fMessage);
}

//----------------------------------------------------------------------------------------
// CException_AC::BuildMessage
//----------------------------------------------------------------------------------------

long CException_AC::BuildMessage(short lowWord, short highWord) 
{ 
	return (static_cast<long>(highWord) << 16) | static_cast<unsigned short>(lowWord); 
}

//----------------------------------------------------------------------------------------
// CException_AC::SetMessage
//----------------------------------------------------------------------------------------

void CException_AC::SetMessage(short lowWord, short highWord)
{
	fMessage = BuildMessage(lowWord, highWord);
}


#if qDebugExceptions

#if qDebugExceptions >= qDebugLevelTwo_AC

//----------------------------------------------------------------------------------------
// CException_AC::DoThrowMessage
//----------------------------------------------------------------------------------------

void CException_AC::DoThrowMessage()
{
	if (GetError() == memFullErr)
		::ProgramReport_AC("%s Thrown: type:memFullErr, msg:%ld, Thrown at:%s, Line:%d", what(), fMessage, fFile, fLine);
	else
		::ProgramReport_AC("%s Thrown: type:%ld, msg:%ld, Thrown at:%s, Line:%d", what(), GetError(), fMessage, fFile, fLine);
}

//----------------------------------------------------------------------------------------
// CException_AC::DoCatchMessage
//----------------------------------------------------------------------------------------

void CException_AC::DoCatchMessage(const char* fileName, short lineNum, bool breakInDebugger)
{
	fileName = LeafName_AC(fileName);
	if (GetError() == memFullErr)
		::ProgramReportOrBreak_AC(breakInDebugger, "%s Caught: type: memFullErr, msg:%ld, Caught at:%s, Line:%d", what(), fMessage, fileName, lineNum);
	else
		::ProgramReportOrBreak_AC(breakInDebugger, "%s Caught: type: %ld, msg:%ld, Caught at:%s, Line:%d", what(), GetError(), fMessage, fileName, lineNum);
}

#endif //	qDebugExceptions >= qDebugLevelTwo_AC

//----------------------------------------------------------------------------------------
// DebugThrowException_AC
//----------------------------------------------------------------------------------------

void DebugThrowException_AC(OSStatus inErr, CException_AC::Message inMsg,  
							const char *inFileName, short inLineNum)
{
	CException_AC ex(inErr, inMsg, inFileName, inLineNum);
	DoThrowMessage_AC(ex);
	throw ex;
}

//----------------------------------------------------------------------------------------
// DebugThrowError_AC
//----------------------------------------------------------------------------------------

void DebugThrowError_AC(OSStatus inErr, const char* inFile, short inLine)
{
	CException_AC ex(inErr, inFile, inLine);
	DoThrowMessage_AC(ex);
	throw ex;
}

//----------------------------------------------------------------------------------------
// DebugThrowIfError_AC
//----------------------------------------------------------------------------------------

void DebugThrowIfError_AC(OSStatus inErr, const char* inFile, short inLine)
{
	if (inErr)
		DebugThrowError_AC(inErr, inFile, inLine);
}

//----------------------------------------------------------------------------------------
// DebugThrowIfMemError_AC
//----------------------------------------------------------------------------------------

void DebugThrowIfMemError_AC(const char* inFile, short inLine)
{
	OSErr e = MemError();

	if (e != noErr)
		::DebugThrowError_AC(e, inFile, inLine);
}

//----------------------------------------------------------------------------------------
// DebugThrowIfNULLResource_AC
//----------------------------------------------------------------------------------------

void DebugThrowIfNULLResource_AC(const void* r, const char* inFileName, short inLineNum)
{
	if (!r)
	{
		OSErr e = ResError();
		if (e == noErr)
			e = resNotFound;
		::DebugThrowError_AC(e, inFileName, inLineNum);
	}
}

//----------------------------------------------------------------------------------------
// DebugThrowIfNonObject_AC:
//----------------------------------------------------------------------------------------

void DebugThrowIfNonObject_AC(const void* obj, const char* inFileName, short inLineNum)
{
	if (!obj || ::Odd_AC(obj))
	{
#if qCoreDebug
		::ProgramBreak_AC("Object that failed discipline: %p", obj);
#endif
		::DebugThrowError_AC(minErr, inFileName, inLineNum);
//		ThrowLogicError_AC();
	}
}

//----------------------------------------------------------------------------------------
// DebugThrowIfResError_AC: 
//----------------------------------------------------------------------------------------

void DebugThrowIfResError_AC(const char* inFileName, short inLineNum)
{
	OSErr e = ::ResError();

	if (e != noErr)
		::DebugThrowError_AC(e, inFileName, inLineNum);
}

//----------------------------------------------------------------------------------------
// DebugThrowNewMessage_AC
//----------------------------------------------------------------------------------------

void DebugThrowNewMessage_AC(OSStatus inError, 
							 CException_AC::Message oldMessage, 
							 CException_AC::Message newMessage,
							 const char* inFileName, 
							 short inLineNum)
{
	CException_AC ex(inError, oldMessage ? oldMessage : newMessage, inFileName, inLineNum);
	DoThrowMessage_AC(ex);
	throw ex;
}

//----------------------------------------------------------------------------------------
// DebugThrowIfBadAlloc_AC
//----------------------------------------------------------------------------------------

void DebugThrowIfBadAlloc_AC(const void* inPtr, const char* inFile, short inLine)
{
	if (inPtr == NULL)
	{
		CException_AC ex(memFullErr, inFile, inLine);
		DoThrowMessage_AC(ex);
		throw ex;
	}
}

//----------------------------------------------------------------------------------------
// DebugThrowIfBadCast_AC
//----------------------------------------------------------------------------------------

void DebugThrowIfBadCast_AC(const void* inPtr, const char* inFile, short inLine)
{
	if (inPtr == NULL)
	{
		inFile = LeafName_AC(inFile);
		ProgramBreak_AC("Cast failed. File: %s, Line: %d", inFile, inLine);
		ThrowBadCast_AC();
	}
}

//=======================================================================================
// Non Debug Methods	
//=======================================================================================

#else // qDebugExceptions

//----------------------------------------------------------------------------------------
// ThrowIfMemError_AC
//----------------------------------------------------------------------------------------

void ThrowIfMemError_AC()
{
	OSErr e = ::MemError();

	if (e != noErr)
		::ThrowError_AC(e);
}

//----------------------------------------------------------------------------------------
// ThrowIfResError_AC
//----------------------------------------------------------------------------------------

void ThrowIfResError_AC()
{
	OSErr e = ::ResError();

	if (e != noErr)
		::ThrowError_AC(e);
}

//----------------------------------------------------------------------------------------
// ThrowIfNonObject_AC
//----------------------------------------------------------------------------------------

void ThrowIfNonObject_AC(const void* obj)
{
	if (!obj || ::Odd_AC(obj))
	{
		::ThrowError_AC(minErr);
	}
}

//----------------------------------------------------------------------------------------
// ThrowIfNULLResource_AC
//----------------------------------------------------------------------------------------

void ThrowIfNULLResource_AC(const void* r)
{
	if (!r)
	{
		OSErr e = ::ResError();
		if (e == noErr)
			e = resNotFound;
		::ThrowError_AC(e);
	}
}

//----------------------------------------------------------------------------------------
// ThrowIfBadAlloc_AC
//----------------------------------------------------------------------------------------

void ThrowIfBadAlloc_AC(const void* inPtr)
{
	if (inPtr == NULL)
	{
		CException_AC ex = memFullErr;
		throw ex;
	}
}

//----------------------------------------------------------------------------------------
// ThrowIfBadCast_AC
//----------------------------------------------------------------------------------------

void ThrowIfBadCast_AC(const void* inPtr)
{
	if (inPtr == NULL)
		ThrowBadCast_AC();
}

#endif // qDebugExceptions

//----------------------------------------------------------------------------------------
// ThrowBadAlloc_AC
//----------------------------------------------------------------------------------------

void ThrowBadAlloc_AC()
{
	throw bad_alloc();
}

//----------------------------------------------------------------------------------------
// ThrowBadCast_AC
//----------------------------------------------------------------------------------------

void ThrowBadCast_AC()
{
#if (defined(__MSL__) && __MSL__ >= 0x2405) || defined(__MRC__) || defined(__SC__) || defined(__GNUC__)
	throw bad_cast();
#else
	throw bad_cast("bad_cast");
#endif
}

//----------------------------------------------------------------------------------------
// ThrowLogicError_AC
//----------------------------------------------------------------------------------------

void ThrowLogicError_AC()
{
	ThrowLogicError_AC("logic_error");
}

void ThrowLogicError_AC(const char* what)
{
	throw logic_error(what);
}

//----------------------------------------------------------------------------------------
// ThrowDomainError_AC
//----------------------------------------------------------------------------------------

void ThrowDomainError_AC()
{
	ThrowDomainError_AC("domain_error");
}

void ThrowDomainError_AC(const char* what)
{
	throw domain_error(what);
}

//----------------------------------------------------------------------------------------
// ThrowInvalidArgument_AC
//----------------------------------------------------------------------------------------

void ThrowInvalidArgument_AC()
{
	ThrowInvalidArgument_AC("invalid_argument");
}

void ThrowInvalidArgument_AC(const char* what)
{
	throw invalid_argument(what);
}

//----------------------------------------------------------------------------------------
// ThrowLengthError_AC
//----------------------------------------------------------------------------------------

void ThrowLengthError_AC()
{
	ThrowLengthError_AC("length_error");
}

void ThrowLengthError_AC(const char* what)
{
	throw length_error(what);
}

//----------------------------------------------------------------------------------------
// ThrowOutOfRange_AC
//----------------------------------------------------------------------------------------

void ThrowOutOfRange_AC()
{
	ThrowOutOfRange_AC("out_of_range");
}

void ThrowOutOfRange_AC(const char* what)
{
	throw out_of_range(what);
}

//----------------------------------------------------------------------------------------
// ThrowRuntimeError_AC
//----------------------------------------------------------------------------------------

void ThrowRuntimeError_AC()
{
	ThrowRuntimeError_AC("runtime_error");
}

void ThrowRuntimeError_AC(const char* what)
{
	throw runtime_error(what);
}

//----------------------------------------------------------------------------------------
// ThrowOverflowError_AC
//----------------------------------------------------------------------------------------

void ThrowOverflowError_AC()
{
	ThrowOverflowError_AC("overflow_error");
}

void ThrowOverflowError_AC(const char* what)
{
	throw overflow_error(what);
}

//----------------------------------------------------------------------------------------
// ThrowRangeError_AC
//----------------------------------------------------------------------------------------

void ThrowRangeError_AC()
{
	ThrowRangeError_AC("range_error");
}

void ThrowRangeError_AC(const char* what)
{
	throw range_error(what);
}

//----------------------------------------------------------------------------------------
// ThrowUnderflowError_AC
//----------------------------------------------------------------------------------------

void ThrowUnderflowError_AC()
{
	ThrowUnderflowError_AC("underflow_error");
}

void ThrowUnderflowError_AC(const char* what)
{
	throw underflow_error(what);
}


//----------------------------------------------------------------------------------------
// End of CException_AC.cpp
