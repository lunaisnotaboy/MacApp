//----------------------------------------------------------------------------------------
// CAutoPtr_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/07/01	[PB] Make Test usable. 
		02/20/01	[PB] Add prototype for Test. 
		01/02/01	Update copyright.
		04/08/00	Initial version. 
*/

#ifndef __CAutoPtr_AC__
#include "CAutoPtr_AC.h"
#endif

// ACS

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

// Toolbox

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif

//========================================================================================
// Functions
//========================================================================================

void TestCAutoPtr_AC();

class CDummy
{
public:
	CDummy() : fDummy(0) {}
	CDummy(long dummy) : fDummy(dummy) {}
	CDummy(const CDummy& from) : fDummy(from.fDummy) {}
	virtual ~CDummy() {}

protected:
	long	fDummy;
};

void TestCAutoPtr_AC()
{
	CAutoPtr_AC<CDummy> p;
	CAutoPtr_AC<CDummy> p2(TH_new CDummy(2));

	p = TH_new CDummy(1);

	CDummy* d = p2;

	d = p.get();

	if (p)
		ProgramReport_AC("p\n");

	if (!p)
		ProgramReport_AC("!p\n");

	if (MemError() != noErr && p)
		ProgramReport_AC("MemError() != noErr && p\n");

	if (p && p2)
		ProgramReport_AC("p && p2\n");

	if (p || p2)
		ProgramReport_AC("p || p2\n");

	if (p == NULL)
		ProgramReport_AC("p == NULL\n");

	if (p != NULL)
		ProgramReport_AC("p != NULL\n");

	if (p == p2)
		ProgramReport_AC("p == p2\n");

	if (p != p2)
		ProgramReport_AC("p != p2\n");

	if (p < p2)
		ProgramReport_AC("p < p2\n");

	if (p <= p2)
		ProgramReport_AC("p <= p2\n");

	if (p >= p2)
		ProgramReport_AC("p >= p2\n");

	if (p > p2)
		ProgramReport_AC("p > p2\n");

	p.reset();

	p = p2.release();

	CAutoPtr_AC<CDummy> p3(p);
	
	p2 = p3;
}

//----------------------------------------------------------------------------------------
// End of CAutoPtr_AC.cpp
