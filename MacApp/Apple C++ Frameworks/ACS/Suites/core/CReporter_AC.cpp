//----------------------------------------------------------------------------------------
// CReporter_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/19/01	Added using std::vsprintf and std::strlen.  Descoped strlen.
		02/28/01	[W] Include Windows header. 
		02/08/01	Use vector instead of CLinkedList_AC. 
		01/05/01	Don’t include string.h.
		01/02/01	Update copyright.
		09/21/00	Added static_cast in SetIsCurrentInstance.
		07/31/00	[W] Don't stop after displaying message in OutputMessage.
		05/23/00	[2279264] Rename buffer-oriented calls to ProgramBreakText
					and ProgramReportText so as to eliminate all possible ambiguity. 
		05/15/00	CW Pro 6: ambiguous ProgramBreak and ProgramReport overloads. 
					Switch the order of the arguments for the buffer-oriented calls. 
					Rename ProgramReport(bool, const char*, ...) to ProgramReportOrBreak. 
		03/16/00	ProgramBreak_AC uses an unsigned int now.
		02/22/00	[W] Use MessageBox in OutputMessage.
		12/07/99	Removed developer identifying comment.  Call First instead of
					GetFirstElement in Instance and SetIsCurrentInstance.
		09/20/99	Split off string versions from CReporter_AC. 
		09/14/99	Added <string> version of ProgramBreak_AC and ProgramReport_AC.
		03/24/99	Update copyright notice.
		10/06/98	Clean up includes. 
*/

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// ACS

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __Debug_AC__
#include "Debug_AC.h"
#endif

#ifndef __dout_AC__
#include "dout_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

// Windows

#if qMSWindows
	#ifndef _WINDOWS_
	#include <Windows.h>
	#endif
#endif

// ANSI

#ifndef _ALGORITHM
#include <algorithm>
#endif

#ifndef _STDARG_H
#include <stdarg.h>
#endif

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STDLIB_H
#include <stdlib.h>
#endif

#ifndef _STRING_H
#include <string.h>
#endif

using std::find;
using std::vsprintf;
using std::strlen;

//========================================================================================
// Global Variables
//========================================================================================

#define kEndOfBufferCookie 0x012345678
#define kBufferSize BUFSIZ

static char gWorkBuffer[kBufferSize + sizeof(long)];
// this is okay because we're not allocating any memory.


//========================================================================================
// Local Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// PrepareBuffer
//----------------------------------------------------------------------------------------

inline void PrepareBuffer()
{
	long* endOData = reinterpret_cast<long*>(&gWorkBuffer[kBufferSize]);
	*endOData = kEndOfBufferCookie;
}

//----------------------------------------------------------------------------------------
// VerifyBuffer
//----------------------------------------------------------------------------------------

inline void VerifyBuffer()
{
	long* endOData = reinterpret_cast<long*>(&gWorkBuffer[kBufferSize]);
	Assertion_AC( *endOData == kEndOfBufferCookie, "ProgramBreak buffer overwritten!");
}

//========================================================================================
// class CReporter_AC
//========================================================================================

CReporter_AC::CList CReporter_AC::fgReporters;
CReporter_AC CReporter_AC::fgDefaultReporter = false;
bool CReporter_AC::fgDefaultReporterInitialized = false;

//----------------------------------------------------------------------------------------
// CReporter_AC::CReporter_AC
//----------------------------------------------------------------------------------------

CReporter_AC::CReporter_AC(bool becomeDefault)
{
	SetIsCurrentInstance(becomeDefault);
	if	(this == &fgDefaultReporter)
		fgDefaultReporterInitialized = true;
}

//----------------------------------------------------------------------------------------
// CReporter_AC::~CReporter_AC
//----------------------------------------------------------------------------------------

CReporter_AC::~CReporter_AC()
{
	if	(this == &fgDefaultReporter)
		fgDefaultReporterInitialized = false;
	SetIsCurrentInstance(false);
}

#if qCoreDebug

//----------------------------------------------------------------------------------------
// CReporter_AC::OutputMessage
//----------------------------------------------------------------------------------------

void CReporter_AC::OutputMessage(const char* inOutput, bool continueIfPossible)
{
#if qMSWindows
	::MessageBox(HWND_DESKTOP,inOutput,"DebugStr",MB_OK+MB_ICONINFORMATION);
#else
	static bool cantNest = false;
	
	if (!cantNest)
	{
		cantNest = true;

		if (dout.IsUsable())
		{
			dout << inOutput;
			
			if (continueIfPossible)
				dout << endl_AC;
			else
				dout << flush_AC;
			
		}
		else
		{
			DebugStr("\pCReporter_AC::OutputMessage: 'dout' has not been initialized -- cannot output messages.");
		}
		
		cantNest = false;
	}
	else
	{
		DebugStr("\pCReporter_AC::OutputMessage: Nested call to dout detected -- not allowed.");
	}
#endif
}
#else

//----------------------------------------------------------------------------------------
// CReporter_AC::OutputMessage
//----------------------------------------------------------------------------------------

void CReporter_AC::OutputMessage(const char* inOutput, bool continueIfPossible)
{
	#pragma unused (inOutput, continueIfPossible)
}
#endif


//----------------------------------------------------------------------------------------
// CReporter_AC::Instance
//----------------------------------------------------------------------------------------

CReporter_AC* CReporter_AC::Instance()
{
	return (fgReporters.size() > 0) ? fgReporters.back() : GetDefaultInstance();
}


//----------------------------------------------------------------------------------------
// CReporter_AC::SetIsCurrentInstance
//----------------------------------------------------------------------------------------

CReporter_AC* CReporter_AC::SetIsCurrentInstance(bool makeCurrent)
{	
	CReporter_AC* returnVal = NULL; 
	
	if ( makeCurrent )
	{
		CList::iterator position = find(fgReporters.begin(), fgReporters.end(), this);
		if (position == fgReporters.end())
		{
			if (fgReporters.size() > 0)
				returnVal = fgReporters.back();
		
			fgReporters.push_back(this);
		}
	}
	else
	{
		CList::iterator position = find(fgReporters.begin(), fgReporters.end(), this);
		if (position != fgReporters.end())
		{
			fgReporters.erase(position);
			
			returnVal = Instance();
		}
	}
	
	return returnVal;
}


//----------------------------------------------------------------------------------------
// CReporter_AC::GetDefaultInstance
//----------------------------------------------------------------------------------------

CReporter_AC* CReporter_AC::GetDefaultInstance()
{
	return fgDefaultReporterInitialized
			? &fgDefaultReporter
			: NULL;
}

//========================================================================================
// Global Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// ProgramBreak_AC
//----------------------------------------------------------------------------------------

void ProgramBreak_AC(const char* grievance, ...)
{
	/*static*/ va_list args;

	PrepareBuffer();

	va_start(args, grievance);
	vsprintf(gWorkBuffer, grievance, args);
	::Assertion_AC(strlen(gWorkBuffer) < sizeof(gWorkBuffer),
				   "ProgramReport_AC: Write beyond end of gWorkBuffer.");
	va_end(args);

	VerifyBuffer();

	if (strlen(gWorkBuffer))
		CReporter_AC::Instance()->OutputMessage(gWorkBuffer, false);
}
//----------------------------------------------------------------------------------------
// ProgramBreakText_AC
//----------------------------------------------------------------------------------------

void ProgramBreakText_AC(unsigned int msgLen, const void* debuggerMsg)
{
	if (msgLen > 0)
	{
		if (msgLen > kBufferSize)
			msgLen = kBufferSize;

		PrepareBuffer();

		BlockMove_AC(debuggerMsg, gWorkBuffer, msgLen);
		gWorkBuffer[msgLen] = 0;

		::Assertion_AC(strlen(gWorkBuffer) < sizeof(gWorkBuffer),
					   "ProgramReport_AC: Write beyond end of gWorkBuffer.");
		VerifyBuffer();

		CReporter_AC::Instance()->OutputMessage(gWorkBuffer, false);
	}
}

//----------------------------------------------------------------------------------------
// ProgramReport_AC
//----------------------------------------------------------------------------------------

void ProgramReport_AC(const char* grievance, ...)
{
	/*static*/ va_list args;

	PrepareBuffer();

	va_start(args, grievance);
	vsprintf(gWorkBuffer, grievance, args);
	::Assertion_AC(strlen(gWorkBuffer) < sizeof(gWorkBuffer),
				   "ProgramReport_AC: Write beyond end of gWorkBuffer.");
	va_end(args);

	VerifyBuffer();

	if (strlen(gWorkBuffer))
		CReporter_AC::Instance()->OutputMessage(gWorkBuffer, true);
}

//----------------------------------------------------------------------------------------
// ProgramReportText_AC
//----------------------------------------------------------------------------------------

void ProgramReportText_AC(unsigned int msgLen, const void* debuggerMsg)
{
	if (msgLen > 0)
	{
		if (msgLen > kBufferSize)
			msgLen = kBufferSize;

		PrepareBuffer();

		BlockMove_AC(debuggerMsg, gWorkBuffer, msgLen);
		gWorkBuffer[msgLen] = 0;

		::Assertion_AC(strlen(gWorkBuffer) < sizeof(gWorkBuffer),
					   "ProgramReport_AC: Write beyond end of gWorkBuffer.");
		VerifyBuffer();

		CReporter_AC::Instance()->OutputMessage(gWorkBuffer, true);
	}
}

//----------------------------------------------------------------------------------------
// ProgramReportOrBreak_AC
//----------------------------------------------------------------------------------------

void ProgramReportOrBreak_AC(bool stopInDebugger, const char* grievance, ...)
{
	va_list args;

	PrepareBuffer();

	va_start(args, grievance);
	vsprintf(gWorkBuffer, grievance, args);
	::Assertion_AC(strlen(gWorkBuffer) < sizeof(gWorkBuffer),
				   "ProgramReportOrBreak_AC: Write beyond end of gWorkBuffer.");
	va_end(args);

	VerifyBuffer();

	if (strlen(gWorkBuffer))
		CReporter_AC::Instance()->OutputMessage(gWorkBuffer, !stopInDebugger);
}

//----------------------------------------------------------------------------------------
// End of CReporter_AC.cpp