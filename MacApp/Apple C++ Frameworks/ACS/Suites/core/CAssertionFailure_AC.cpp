//----------------------------------------------------------------------------------------
// CAssertionFailure_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/19/01	Added using std::strncpy, std::strcpy and std::strlen.  Descoped each later.
		02/14/01	Don't depend directly on dout. 
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		09/21/00	Conditionalize include of typeinfo.
		05/10/00	Include typeinfo.  Change guards around stdio.h and string.h.
					Also cleaned up a bit.
		05/15/00	CW Pro 6: namespacing. 
		04/11/00	Change AssertNotNULL to throw minErr instead of memFullErr. 
		03/16/00	[G] Use bad_cast().
		12/07/99	Do not include typeinfo.  Strip the lengthy path in DebugWarning_AC
					and DebugAssertGoodCast_AC.
		03/24/99	Update copyright notice.
		11/13/98	[2279264] Replaced 2 ProgramReport_ACÕs with ProgramBreak_AC.
		11/12/98	[2279223] Include <typeinfo> instead of <typeinfo.h>.
		10/06/98	Clean up includes. 
*/

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

// ACS

#if qAssertions

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// ANSI

#ifndef RC_INVOKED
#include <typeinfo>
#endif

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifndef _STRING_H
#include <string.h>
#endif

using std::bad_cast;
using std::strncpy;
using std::strcpy;
using std::strlen;

//----------------------------------------------------------------------------------------
// DebugAssertNotNULL_AC
//----------------------------------------------------------------------------------------

void DebugAssertNotNULL_AC(const void* inPtr, const char* inFile, short inLine)
{ 	
	static bool alreadyFailed = false;

	if (inPtr == NULL)
	{
		try
		{
			if (alreadyFailed)
			{
				::ProgramReport_AC("Warning: Encountered Nested Failures of AssertNotNULL_AC\n");
			}			

			alreadyFailed = true;
			
			CAssertionFailure_AC ex = minErr;
			ex.SetThrownFrom(inFile, inLine);
			ex.SetAssertionMsg("AssertNotNULL Failed");
			
			if (!alreadyFailed)
			{
				::ProgramBreak_AC("DebugAssertNotNULL_AC: Assertion failed: [%s]", ex.GetAssertionMsg());
			}
			
			DoThrowMessage_AC(ex);
			throw ex;
		}
		catch (CException_AC& theException)
		{
			DoCatchMessage_AC(theException);
			alreadyFailed = false;
			throw;
		}
	}
}

//----------------------------------------------------------------------------------------
// CAssertionFailure_AC
//----------------------------------------------------------------------------------------

void CAssertionFailure_AC::SetAssertionMsg(const char* inString)
{	
	if(inString)
		strncpy(fMsgString, inString, sizeof(fMsgString)); 
	else
		strcpy(fMsgString, "Unknown");
	::Assertion_AC(::strlen(fMsgString) < sizeof(fMsgString),
				   "CAssertionFailure_AC::SetAssertionMsg: Write beyond end of fMsgString.");
}

//----------------------------------------------------------------------------------------
// DebugAssert_AC
//----------------------------------------------------------------------------------------

void DebugAssert_AC(bool condition, const char* msg, const char* inFile, short inLine  )
{
	if(!condition)
	{
		CAssertionFailure_AC ex;
		ex.SetThrownFrom(inFile, inLine);
		ex.SetAssertionMsg(msg);
		
		::ProgramBreak_AC("Assertion failed: [%s]", ex.GetAssertionMsg());

		DoThrowMessage_AC(ex);
		throw ex;
	}
}

//----------------------------------------------------------------------------------------
// DebugWarning_AC
//----------------------------------------------------------------------------------------

void DebugWarning_AC(bool condition, const char* optMsg, const char* inFile, short inLine)
{
	if(!condition)
	{
		// Strip the lengthy path under MPW builds (no-op under other environment) ref.
		inFile = LeafName_AC(inFile);
		const char* message = optMsg ? optMsg : "";
	
		::ProgramBreak_AC( 
				"DebugWarning_AC: Warning failed: [%s], File:%s, Line:%d",
				message,
				inFile,
				inLine);
	}
}

//----------------------------------------------------------------------------------------
// DebugAssertGoodCast_AC
//----------------------------------------------------------------------------------------

void DebugAssertGoodCast_AC(const void* inPtr, const char* inFile, short inLine)
{
	if(inPtr == NULL)
	{
		// Strip the lengthy path under MPW builds (no-op under other environment) ref.
		inFile = LeafName_AC(inFile);
		ProgramBreak_AC("Assertion Failed: BadCast. File: %s, Line: %d",  inFile, inLine);
#if (defined(__MSL__) && __MSL__ >= 0x2405) || defined(__MRC__) || defined(__SC__) || defined(__GNUC__)
		throw bad_cast();
#else
		throw bad_cast("bad_cast");
#endif
	}
}


#else	// qAssertions

	// inlined in header file

#endif	// qAssertions


//----------------------------------------------------------------------------------------
// End of CAssertionFailure_AC.cpp
