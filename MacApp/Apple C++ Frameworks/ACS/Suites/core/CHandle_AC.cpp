//----------------------------------------------------------------------------------------
// CHandle_AC.cpp
// Copyright � 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/26/01	Reorganize conditional code from previous change so it compiles
					outside of PB. 
		01/25/01	[PB] Odd address are okay in DisposeIfPtr_AC and IsHandle_AC.
		11/09/00	[PB] Suppress GCC warnings about unused return variables. 
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		02/22/00	[W] Do not define VerboseIsHandle_AC for Windows.
		07/22/99	[C] Do not include VerboseIsHandle_AC or IsFreeHandle_AC if Carbon.
		03/24/99	Update copyright notice.
		01/09/99	Add GetHandleSizeIfLocked. 
		11/13/98	[2279264] Replaced 6 ProgramReport_AC�s with ProgramBreak_AC.
		10/06/98	Clean up includes. 
*/

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

// ACS

#ifndef __CAutoPtr_AC__
#include "CAutoPtr_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// Toolbox

#ifndef __RESOURCES__
#include <Resources.h>
#endif


//----------------------------------------------------------------------------------------
// Static globals:
//----------------------------------------------------------------------------------------

static CPermHandleHandler_AC pDefaultPermHandleHandler;
static CAutoPtr_AC<CPermHandleHandler_AC> pPermHandleHandler;

//----------------------------------------------------------------------------------------
// CPermHandleHandler_AC constructor: 
//----------------------------------------------------------------------------------------

CPermHandleHandler_AC::CPermHandleHandler_AC()
{
}

//----------------------------------------------------------------------------------------
// CPermHandleHandler_AC destructor: 
//----------------------------------------------------------------------------------------

CPermHandleHandler_AC::~CPermHandleHandler_AC()
{
}

//----------------------------------------------------------------------------------------
// CPermHandleHandler_AC::DoNewHandle: 
//----------------------------------------------------------------------------------------
	
Handle CPermHandleHandler_AC::DoNewHandle(Size size)
{
	Handle returnHandle = ::NewHandle(size);
	::ThrowIfNULL_AC(returnHandle);
	return returnHandle;
}

//----------------------------------------------------------------------------------------
// CPermHandleHandler_AC::DoSetHandleSize: 
//----------------------------------------------------------------------------------------

void CPermHandleHandler_AC::DoSetHandleSize(Handle h, Size newSize)
{
	::SetHandleSize(h, newSize);
	::ThrowIfMemError_AC();
}

//----------------------------------------------------------------------------------------
// SetPermHandleHandler_AC
//----------------------------------------------------------------------------------------

EXPORT_AC void SetPermHandleHandler_AC(CPermHandleHandler_AC* newHandler)
{
	pPermHandleHandler = newHandler;
}

//----------------------------------------------------------------------------------------
// DisposeIfHandle_AC
//----------------------------------------------------------------------------------------

Handle DisposeIfHandle_AC(Handle aHandle)
{
	if (aHandle)
	{
#if !qCoreDebug
		::DisposeHandle(aHandle);
#else
		if (IsHandle_AC(aHandle))				// Test handlehood 
		{
			HGetState(aHandle);				// force subsequent MemError, if any
			if (IsHandlePurged_AC(aHandle))	// h might have been purged 
				DisposeHandle(aHandle);
			else if (MemError() != noErr)
			{
				::ProgramReport_AC("Handle was so bad I couldn't even get the handle bits!\nBad Handle: %p\n", aHandle);
			}
			else if (IsAResource_AC(aHandle))
			{
				::ProgramReport_AC("Trying to dispose a resource handle\nBad Handle: %p\n", aHandle);
			}
			else
			{
				// Set the handle contents to a real nice value for any dangling pointerciples 
				BlockSet_AC((*aHandle), GetHandleSize(aHandle), kDisposedInitVal_AC);
				DisposeHandle(aHandle);
			}
		}
		else
		{
			VerboseIsHandle_AC(aHandle);		// Get the diagnosis printed 
			::ProgramReport_AC("Trying to dispose an invalid handle\nBad Handle: %p\n", aHandle);
		}
#endif
	}

	return NULL;
}

//----------------------------------------------------------------------------------------
// DisposeIfPtr_AC 
//----------------------------------------------------------------------------------------

Ptr DisposeIfPtr_AC(Ptr aPtr)
{
	if (aPtr)
	{
#if !qCoreDebug
		::DisposePtr(aPtr);
#else
		// Test pointerhood
#if !qProjectBuilder
		if (odd_AC(aPtr))
		{
			::ProgramReport_AC("Trying to dispose an odd pointer: %p\n", aPtr);
		}
		else
#endif // !qProjectBuilder
		{
			BlockSet_AC(aPtr, GetPtrSize(aPtr), kDisposedInitVal_AC);
			DisposePtr(aPtr);
		}
#endif // !qCoreDebug
	}

	return NULL;
}

//----------------------------------------------------------------------------------------
// CopyHandle_AC
//----------------------------------------------------------------------------------------

OSErr CopyHandle_AC(const Handle inHandle, Handle& outHandle)
{
	outHandle = NULL;
	Handle temp = inHandle;

	OSErr returnVal = HandToHand(&temp);
	if (returnVal == noErr)
		outHandle = temp;
		
	return returnVal;
}

//----------------------------------------------------------------------------------------
// LockHandle_AC
//----------------------------------------------------------------------------------------

SignedByte LockHandle_AC(Handle h, EMoveHiState_AC high)
{
	enum {lockBit = 7};

	SignedByte savedState = 0;
	if (h)
	{
#if qCoreDebug
		if (!IsHandle_AC(h))
		{
			VerboseIsHandle_AC(h);					// Get the diagnosis printed 
			::ProgramReport_AC("In LockHandle: not handed a handle.");
		}
		else
#endif
		{
			savedState = HGetState(h);
			
			// skip if already locked
			if (!(savedState & (0x1 << lockBit)))
				if (high == eMoveHi)
					::HLockHi(h);
				else
					::HLock(h);
		}
	}

	return savedState;
}

//----------------------------------------------------------------------------------------
// IsFreeHandle_AC: Walk the free-list looking for the given handle
//----------------------------------------------------------------------------------------
#if (qCoreDebug && !qCarbon)

static bool IsFreeHandle_AC(const Handle aHandle)
{
	bool returnVal = false;

	THz inHeap = ApplicationZone();
	Handle currHandle = reinterpret_cast<Handle>(inHeap->hFstFree);

	while (currHandle)
	{
		if (currHandle == aHandle)
		{
			returnVal = true;
			break;
		}
		currHandle = reinterpret_cast<Handle>(*currHandle);
	}

	return returnVal;
}
#endif

//----------------------------------------------------------------------------------------
// IsAResource_AC: 
//----------------------------------------------------------------------------------------

bool IsAResource_AC(const Handle h)
{
	enum {kResNotFound = -1};

	return HomeResFile(h) != kResNotFound;
}

//----------------------------------------------------------------------------------------
// IsHandle_AC:	Returns true if handle appears valid. Must run on any processor since
//				it is called (indirectly) from MacAppAlert.
//----------------------------------------------------------------------------------------

bool IsHandle_AC(const Handle h)
{
	enum
	{
		kUnInitStorage1 = 0x72677267,		// Pascal provided uninited storage 
		kUnInitStorage2 = 0x67726772,		// odd byte boundary of above 
		kDebugHandleInit = 0xF3F3F3F3,		// Handles are inited to this in MacApp�
		kDebugPtrInit = 0xF5F5F5F5,			// Pointers are inited to this in MacApp�
		kDebugObjInit = 0xF1F1F1F1			// Objects are inited to this in MacApp�
	};

	// Handle can't be NULL
	// Handle must be in a known heap
	// Handle can't be odd (includes debug odd values)
	// If debugging, handle can't be uninitialized (debug even value)
	// Master pointer can be NULL
	// Non-null master pointer must be in a known heap
	// Non-null master pointer can't be odd

#if qMSWindows
	return (h != NULL);
#elif !qCarbon
	return  (h != NULL) && IsAddress_AC(h) && !odd_AC(h) &&
#if qCoreDebug
			(reinterpret_cast<long>(h) != kUnInitStorage2) &&	// uninitialized
#endif
			((*h == NULL) || (IsAddress_AC(*h) && !odd_AC(*h)));
#else	// qCarbon
	// ���  IsAddress_AC returns false for a handle allocated with TempNewHandle,
	// because it's not in the application zone.
	bool valid = false;
#if qProjectBuilder
	if (h != NULL)						// Pointers can be odd under Mach-O.
#else
	if ((h != NULL) && !odd_AC(h))
#endif
	{
		if (IsAddress_AC(h))
			valid = true;
		else
		{
			// may still be valid; try getting the handle bits
			SignedByte handleBits = ::HGetState(h);
#if qProjectBuilder
			(void) handleBits;
#endif
			if (MemError() == noErr)
				valid = true;
		}
	}
#if qCoreDebug
	if (valid)
		valid = (reinterpret_cast<long>(h) != kUnInitStorage2);	// uninitialized
#endif
#if !qProjectBuilder
	if (valid)
		valid = ((*h == NULL) || !odd_AC(*h));	// no way to check address (*h) for validity
#endif

	return valid;
#endif	// qCarbon
}

#if qCoreDebug && !qCarbon && !qMSWindows
//----------------------------------------------------------------------------------------
// VerboseIsHandle_AC
//----------------------------------------------------------------------------------------

bool VerboseIsHandle_AC(const Handle h)
{
	enum
	{
		kUnInitStorage1 = 0x72677267,		// Pascal provided uninited storage 
		kUnInitStorage2 = 0x67726772,		// odd byte boundary of above 
		kDebugHandleInit = 0xF3F3F3F3,		// Handles are inited to this in MacApp�
		kDebugPtrInit = 0xF5F5F5F5,			// Pointers are inited to this in MacApp�
		kDebugObjInit = 0xF1F1F1F1			// Objects are inited to this in MacApp�
	};

	bool valid = IsHandle_AC(h) && !IsFreeHandle_AC(h);
	if (!valid)
	{
		ProgramReport_AC("Handle %p is not valid:\n", h);
		if (!h)
		{
			ProgramReport_AC("  It is nil.\n");
		}
		else if (::odd_AC(h))
		{
			if (reinterpret_cast<long>(h) == kUnInitStorage1)
				ProgramReport_AC("  It appears to be from uninitialized storage.\n");
			else if (reinterpret_cast<long>(h) == kDebugHandleInit)
				ProgramReport_AC("  It appears to be from a handle initialized by debugging.\n");
			else if (reinterpret_cast<long>(h) == kDebugPtrInit)
				ProgramReport_AC("  It appears to be from a pointer initialized by debugging.\n");
			else if (reinterpret_cast<long>(h) == kDebugObjInit)
				ProgramReport_AC("  It appears to be an uninitialized instance variable.\n");
			else if (reinterpret_cast<long>(h) == *reinterpret_cast<long*>(0))
				ProgramReport_AC("  It appears to be a dereferenced NULL pointer.\n");
			else
				ProgramReport_AC("  It is odd.\n");
		}
		else if (reinterpret_cast<long>(h) == kUnInitStorage2)
		{
			ProgramReport_AC("  It appears to be from uninitialized storage.\n");
		}
		else if (!IsAddress_AC(h))
		{
			ProgramReport_AC("  It appears to not be in a valid heap.\n");
		}
		else
		{
			Ptr masterPointer = (*h);
			if (masterPointer == NULL)
			{
				// purged is okay
				valid = true;
			}
			else if (::odd_AC(masterPointer))
				ProgramReport_AC("  Its master pointer is odd.\n");
			else if (IsFreeHandle_AC(h))
				ProgramReport_AC("  It has been freed.\n");
			else if (VerboseIsAddress_AC(*h))
				ProgramReport_AC("  Its master pointer is not in a known heap.\n");
			else
				valid = true;
		}
	}

	return valid;
}
#endif // qCoreDebug && !qCarbon && !qMSWindows

//----------------------------------------------------------------------------------------
// IsHandleLocked_AC: Returns lockState of h.
//----------------------------------------------------------------------------------------

bool IsHandleLocked_AC(const Handle h)
{
	static const short lockBit = 7;

	SignedByte handleBits = ::HGetState(h);		// h might have been purged 

	return MemError() == noErr ? handleBits & (0x1 << lockBit) : false;
}

//----------------------------------------------------------------------------------------
// IsHandlePurged_AC: Returns purgeState of h.
//----------------------------------------------------------------------------------------
#if qCoreDebug

bool IsHandlePurged_AC(const Handle h)
{
	bool returnVal;

	if (!IsHandle_AC(h))
	{
		VerboseIsHandle_AC(h);						// Get the diagnosis printed 
		::ProgramReport_AC("IsHandlePurged was not handed a handle, pretty handy, eh?");

		returnVal = true;
	}
	else
		returnVal = *h == NULL;
	
	return returnVal;
}

#endif // qCoreDebug

//----------------------------------------------------------------------------------------
// GetHandleSizeIfLocked_AC
//----------------------------------------------------------------------------------------

Size GetHandleSizeIfLocked_AC(const Handle h, bool justLocked)
{
	Size itsSize = 0;
	if (h)
	{
		if (!justLocked || IsHandleLocked_AC(h))
			itsSize = GetHandleSize(h);

		// ��� Should we add kHeapOverhead ???
	}

	return itsSize;
}

//========================================================================================
// CLASS CTempHLock_AC
//========================================================================================
#undef Inherited

//----------------------------------------------------------------------------------------
// CTempHLock_AC constructor
//----------------------------------------------------------------------------------------

CTempHLock_AC::CTempHLock_AC(Handle inData) :
pointee(inData),
fHandleBits(0),
fRelease(eDontReleaseIt)
{
	if (pointee)
		fHandleBits = LockHandle_AC(pointee);
}

//----------------------------------------------------------------------------------------
// CTempHLock_AC constructor 
//----------------------------------------------------------------------------------------

CTempHLock_AC::CTempHLock_AC(Handle inData, EMoveHiState_AC high, EReleaseState_AC releaseIt, ELockState_AC lockIt) :
pointee(inData),
fHandleBits(0),
fRelease(releaseIt == eReleaseIt)
{
	if (pointee)
	{
		if (lockIt == eLockIt)
		{
			fHandleBits = ::LockHandle_AC(pointee, high);
		}
		else if (pointee && high == eMoveHi)
		{
			fHandleBits = HGetState(pointee);
			MoveHHi(pointee);
		}
	}
}

//----------------------------------------------------------------------------------------
// CTempHandleLock::RestoreState: 
//----------------------------------------------------------------------------------------

void CTempHLock_AC::RestoreState()
{
	if (pointee)
	{
		::HSetState(pointee, fHandleBits);
		if (fRelease)
			::ReleaseResource(pointee);
	}
}

//----------------------------------------------------------------------------------------
// NewPermHandle_AC
//----------------------------------------------------------------------------------------

Handle NewPermHandle_AC(Size size)
{
	if (!pPermHandleHandler.IsNULL())
		return pPermHandleHandler->DoNewHandle(size);
	else
		return pDefaultPermHandleHandler.DoNewHandle(size);
}

//----------------------------------------------------------------------------------------
// SetPermHandleSize
//----------------------------------------------------------------------------------------

void SetPermHandleSize_AC(Handle h, Size newSize)
{
	if (!pPermHandleHandler.IsNULL())
		pPermHandleHandler->DoSetHandleSize(h, newSize);
	else
		pDefaultPermHandleHandler.DoSetHandleSize(h, newSize);
}

//----------------------------------------------------------------------------------------
// End of CHandle_AC.cpp
