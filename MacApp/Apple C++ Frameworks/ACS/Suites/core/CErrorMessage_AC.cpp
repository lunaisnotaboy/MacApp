//----------------------------------------------------------------------------------------
// CErrorMessage_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		06/10/01	Need to include CMultiLocal_AC. 
		01/19/01	Use CString_AC in SearchErrTable.  Include CString_AC.h.
		01/02/01	Update copyright.
		12/28/00	Moved to ACS. 
		12/20/00	Include CStdReporter_AC.h.
		12/15/00	Use string in place of CStr255_AC.  Cosmetic and other cleanup.
		06/14/00	Eliminate unnecessary GetRegionCode calls.
		12/08/99	Fixed file name in banner.
		11/04/99	SearchErrTable: CopyFrom needs a length.
		10/25/99	PRAGMA_ALIGN_SUPPORTED now PRAGMA_STRUCT_ALIGN.
		03/24/99	Update copyright notice.
*/

#ifndef __CErrorMessage_AC__
#include "CErrorMessage_AC.h"
#endif

// ACS

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

// Toolbox

#ifndef __RESOURCES__
#include <Resources.h>
#endif

using std::string;

//----------------------------------------------------------------------------------------
// ErrRecord
//----------------------------------------------------------------------------------------

#if PRAGMA_STRUCT_ALIGN
#pragma options align=mac68k
#endif

struct ErrRecord
{
	short lowErr;
	short highErr;
	short index;
};

#if PRAGMA_STRUCT_ALIGN
#pragma options align=reset
#endif

typedef ErrRecord *ErrRecordPointer, **ErrRecordHandle;

//----------------------------------------------------------------------------------------
// SearchErrTable: Private function
//----------------------------------------------------------------------------------------

static bool SearchErrTable(short value, ResNumber resourceID, string& str)
{
	bool found = false;

	str.empty();
	ErrRecordHandle table = (ErrRecordHandle)CMultiLocale_AC::GetResource('errs', resourceID);
	if (table)
	{
		ResNumber strID = 0;
		CTempHandleLock_AC tempHandleLock((Handle)table);
		ErrRecordPointer pEntry = *table;

		short lenTab = static_cast<short>(GetHandleSize((Handle)table) / sizeof(ErrRecord));
		for (short i = 1; i <= lenTab; ++i, ++pEntry)
		{
			if (!pEntry->lowErr)
				strID = pEntry->index;
			else if ((pEntry->lowErr <= value) && (value <= pEntry->highErr))
			{
				if (pEntry->index > 0)
					str = CString_AC(strID, pEntry->index);
				found = true;
				break;
			}
		}
	}

	return found;
}

//========================================================================================
// GLOBAL Procedures
//========================================================================================

//----------------------------------------------------------------------------------------
// LookupErrString_AC: 
//----------------------------------------------------------------------------------------
bool LookupErrString_AC(short value, ResNumber resourceID, string& str)
{
	return SearchErrTable(value, errAppTable + resourceID, str) ||
		   SearchErrTable(value, resourceID, str);
}


//----------------------------------------------------------------------------------------
// End of CErrorMessage_AC.cpp



/*
	Historical Change Record:
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if(x) instead of if(x != 0).
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		----- R10 -----
		03/26/96	Cleanup references to gEmptyString and ""
		03/26/96	coerce CStrxxx_AC to const char* to get copies of the strings as c style strings
		 12/8/95	Split off from UErrorMgr. 
		----- 3.3 -----
		11/01/95	Use kMacAppTimeout in calls to InteractWithUser.
							MacAppAlert doesn't provide an event proc when calling
							InteractWithUser.
		10/19/95	[1285212] (Menus) Bug in TCmdTable::ErrorAlert.
		10/10/95	Call gApplication->InteractWithUser.
							Include "UApplication.h"
		----- 3.3b1 -----
		  7/6/95	Include UMemory to get gRsrcCheck. 
		 6/18/95	CheckRsrcUsage is not conditioned on #qDebug anymore. It is
		 					conditioned internally by gCheckRsrcUsage. 
		 6/12/95	Support TAppleEvent::fgIdleProc
		05/05/95	Remove support for pre-system 7
		 3/20/95	Move all Universal code required to Vet the hardware together
		02/13/95	More Remove unnecessary initialization of static variables. See ARM §8.4 
		02/13/95	Remove unnecessary initialization of static variables. See ARM §8.4 
		02/07/95	Create missing prototypes for static functions used internally. 
		 9/23/94	Modified to support relocation of
							gMacAppIdleEventProc to UScripting.
*/