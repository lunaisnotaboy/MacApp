//----------------------------------------------------------------------------------------
// Debug_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		02/14/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		12/07/99	Fix file name in banner.  Strip path in DebugSubClassResponsibility_AC.
		09/14/99	Include CReporter_AC.h.
		03/24/99	Update copyright notice.
*/

#ifndef __Debug_AC__
#include "Debug_AC.h"
#endif

// ACS

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#if qCoreDebug


//----------------------------------------------------------------------------------------
// CDebug_AC::TableLookup
//----------------------------------------------------------------------------------------

const char* CDebug_AC::TableLookup(const TLookupTable* inTable, long inKey)
{
	static const char* defaultMessage = "? (Lookup Error)";
	
	const char* outPtr = defaultMessage;
	
	long counter = 0;
	while( inTable[counter].fDescription )
	{
		if(inKey == inTable[counter].fKey )
		{
			outPtr = inTable[counter].fDescription;
			break;
		}
	
		++counter;
	}
	
	return outPtr;
}

//----------------------------------------------------------------------------------------
// CDebug_AC::TrimTypeName
//----------------------------------------------------------------------------------------

const char* CDebug_AC::TrimTypeName(const char* inName)
{
	enum { kSize = 512 };
	static char out[kSize];
	
	long count = 0;
	
	char* walker = const_cast<char*>(inName);
	char* outPtr = out;
	
	while( *walker != '\0' )
	{
		if(++count == kSize || *walker == '<')
			break;
		
		*outPtr++ = *walker++;
		
	}

	*outPtr = '\0';

	return out;
}

//----------------------------------------------------------------------------------------
// DebugSubClassResponsibility_AC
//----------------------------------------------------------------------------------------

void DebugSubClassResponsibility_AC(const char* fileName, short lineNum)
{
	fileName = LeafName_AC(fileName);
	::ProgramBreak_AC("Required Override not overridden: File %s, Line %d", fileName, lineNum);
}


#endif
