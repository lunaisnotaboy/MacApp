//----------------------------------------------------------------------------------------
// MTrackable_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		08/14/01	Scope stdio definitions because cstdio is getting included first. 
		03/01/01	Need to include CTidyHeapAction_AC. 
		02/15/01	Need to include CTidyHeap_AC. 
		02/12/01	Add CTidyHeap::CTempDisable. 
		02/08/01	Use vector instead of CLinkedList_AC. 
		01/02/01	Update copyright.
		05/15/00	CW Pro 6: namespacing. 
		03/24/99	Update copyright notice.
		11/12/98	[2279223] Include <typeinfo> instead of <typeinfo.h>.
*/

#ifndef __MTrackable_AC__
#include "MTrackable_AC.h"
#endif

#if qCoreDebug

// ACS

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qTidyHeap
	#ifndef __CTidyHeapAction_AC__
	#include "CTidyHeapAction_AC.h"
	#endif
#endif

#ifndef __dout_AC__
#include "dout_AC.h"
#endif

// ANSI

#ifndef _ALGORITHM
#include <algorithm>
#endif

#ifndef __typeinfo__
#include <typeinfo>
#endif

#ifndef _STDARG_H
#include <stdarg.h>
#endif

#ifndef _STDIO_H
#include <stdio.h>
#endif

using std::find;
using std::strlen;
using std::vsprintf;

#if qTidyHeap

//========================================================================================
// CFindUndeletedObjects_AC
//========================================================================================

class CFindUndeletedObjects_AC : public CTidyHeapAction_AC
{
public:
	virtual void DoAction(CTidyHeapBlock_AC* /*inBlock*/)
	{
		MTrackable_AC::FindUndeletedObjects();
	}
};
#endif

//========================================================================================
// MTrackable_AC
//========================================================================================

// Please note that fgObjectList is a simple pointer, rather than an auto pointer or
// a global object, so it will still be around for tidy heap to use at termination time. 
MTrackable_AC::CList* MTrackable_AC::fgObjectList;

long MTrackable_AC::fgTrackedObjectNum;
bool MTrackable_AC::fgBreak;

//----------------------------------------------------------------------------------------
// MTrackable_AC
//----------------------------------------------------------------------------------------

MTrackable_AC::MTrackable_AC()
	:	fObjectSerialNumber(0),
		fUserValue(0)
{	
	static bool firstTime = true;
	static long counter = 0;	

	if (firstTime)
	{
		firstTime = false;
		
		fgBreak = true;
		
		long breakValue = GetTrackedObjectNum();
			// get for later restoration
		
		if (!SetTrackedObjectNum(0))			// returns true if first time
			SetTrackedObjectNum(breakValue);	// restore value if it's not the first time.
		
		fgObjectList = TH_new CList;

#if qTidyHeap
		CTidyHeap_AC::ExemptBlockFromLeakCheck(fgObjectList);
		CTidyHeap_AC::Instance()->AquireTerminationAction(new CFindUndeletedObjects_AC);
#endif
	}
	
	fObjectSerialNumber = ++counter;
	
	if (fgObjectList)
	{
		CList::iterator position = find(fgObjectList->begin(), fgObjectList->end(), this);
		if (position == fgObjectList->end())
		{
#if qTidyHeap
			CTidyHeap_AC::CTempDisable exemptBlocks;
#endif
			fgObjectList->push_back(this);
		}
	}
	
	BreakIfTrackedObject(this, "TrackedObject Constructor");
}

//----------------------------------------------------------------------------------------
// ~MTrackable_AC
//----------------------------------------------------------------------------------------

MTrackable_AC::~MTrackable_AC()
{
	BreakIfTrackedObject(this, "TrackedObject Destructor");

	if (fgObjectList && fgObjectList->size() > 0)
	{
		CList::iterator position = find(fgObjectList->begin(), fgObjectList->end(), this);
		if (position != fgObjectList->end())
			fgObjectList->erase(position);
	}
}

//----------------------------------------------------------------------------------------
// FindUndeletedObjects
//----------------------------------------------------------------------------------------

void MTrackable_AC::FindUndeletedObjects()
{
	if (fgObjectList && fgObjectList->size() > 0)
	{
#if qTidyHeap
		CTidyHeap_AC::Instance()->Logf("%ld outstanding MTrackable_AC objects.", fgObjectList->size());
#else
		dout << fgObjectList->size() << " outstanding MTrackable_AC objects." << endl_AC;
#endif		
		for (CList::iterator walker = fgObjectList->begin();
			 walker != fgObjectList->end();
			 ++walker)
		{

#if qTidyHeap
			CTidyHeap_AC::Instance()->Logf("Outstanding object: %s (#%ld)", 
					typeid(**walker).name(), (*walker)->fObjectSerialNumber);
#else
			dout 	<< "Outstanding object: " 
					<< typeid(**walker).name() 
					<< " (" 
					<< (*walker)->fObjectSerialNumber 
					<< ")" 
					<< endl_AC;
#endif		
		}
	}
}

//----------------------------------------------------------------------------------------
// SetTrackedObjectNum
//----------------------------------------------------------------------------------------

bool MTrackable_AC::SetTrackedObjectNum(long inNumber)
{
	static bool firstTime = true;
	
	bool out = firstTime;
	
	if(firstTime)
		firstTime = false;

	fgTrackedObjectNum = inNumber;

	return out;
}

//----------------------------------------------------------------------------------------
// BreakIfTrackedObject
//----------------------------------------------------------------------------------------

void MTrackable_AC::BreakIfTrackedObject(MTrackable_AC* inObject, const char* inStr, ...)
{
	if(inObject->IsTrackedObject() && inObject->PerformConditionalTest())
	{
	
		static va_list args;
		static char str[256];
		
		va_start(args, inStr);
		vsprintf(str, inStr, args);
		::Assertion_AC(::strlen(str) < sizeof(str),
					   "MTrackable_AC::BreakIfTrackedObject: Write beyond end of str.");
		va_end(args);
	
		dout 	<< "Target Object: " 
				<< typeid(*inObject).name() 
				<< " (" 
				<< inObject->GetObjectSerialNum() 
				<< ") " 
				<< str		
				<< (fgBreak ? flush_AC : endl_AC );
	}
}


#endif // qCoreDebug

//----------------------------------------------------------------------------------------
// End of MTrackable_AC.cpp
