//----------------------------------------------------------------------------------------
// MemoryUtils_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/22/01	BlockZero is not available for 68K so changed BlockZero_AC.  Cosmetic.
		03/19/01	Add BlockZero_AC and modify BlocKSet_AC to check for 0 so
					that the system ::BlockZero can be called and used.
		02/14/01	Include MacMemory instead of Memory_AC. 
		01/02/01	Update copyright.
		11/09/00	[PB] GCC was warning about a signed vs. unsigned comparison
					in BlockSet_AC. The values involved were the constants 4 and 8,
					so I changed them to enums. 
		09/01/00	StripLong_AC implementation no longer needed here.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		05/15/00	CW Pro 6: namespacing. 
		07/22/99	[C] Do not include IsAddress_AC or VerboseIsAddress_AC.
		03/24/99	Update copyright notice.
		12/26/98	[W] Accomodate missing routines for Windows in IsAddress_AC.
		10/23/98	Carbonize
		10/06/98	Clean up includes. 
*/

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

// ACS

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// Toolbox

#if q68K || (UINT_MAX <= ULONG_MAX)
	#ifndef __MACMEMORY__
	#include <MacMemory.h>
	#endif
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

using std::memcmp;

//========================================================================================
// GLOBAL Functions
//========================================================================================

#if qCoreDebug && !qCarbon

//----------------------------------------------------------------------------------------
// IsAddress_AC
//----------------------------------------------------------------------------------------

bool IsAddress_AC(const void* inAddress)
{
	bool valid = false;

	if (inAddress)
	{
		if (IsAddress_AC(inAddress, ApplicationZone()))
			valid = true;
#if !qCarbon && !qMSWindows
			// SystemZone, LMGetRAMBase, etc are all gone in Carbon
		else if (IsAddress_AC(inAddress, SystemZone()))
			valid = true;
		else if (inAddress >= ::LMGetRAMBase())
		{
			if (inAddress < ::LMGetBufPtr())
				valid = true;
			else if (GetMMUMode())
			{
				// 32-bit
				if (inAddress < ::LMGetROMBase() + 0x10000000)
					valid = true;
			}
			else
			{
				// 24-bit
				if (inAddress < ::LMGetROMBase() + 0x00100000)
					valid = true;
			}
		}
#endif	// non-Carbon code
	}

	return valid;
}

//----------------------------------------------------------------------------------------
// VerboseIsAddress_AC
//----------------------------------------------------------------------------------------

bool VerboseIsAddress_AC(const void* inAddress)
{
	enum
	{
		kUnInitStorage1 = 0x72677267,		// Pascal provided uninited storage 
		kUnInitStorage2 = 0x67726772,		// odd byte boundary of above 
		kDebugHandleInit = 0xF3F3F3F3,		// Handles are inited to this in MacApp¨
		kDebugPtrInit = 0xF5F5F5F5,			// Pointers are inited to this in MacApp¨
		kDebugObjInit = 0xF1F1F1F1			// Objects are inited to this in MacApp¨
	};

	bool valid = IsAddress_AC(inAddress);
	if (!valid)
	{
		ProgramReport_AC("Address %p is not valid:\n", inAddress);
		if (!inAddress)
			ProgramReport_AC("  It is nil.\n");
		else if (reinterpret_cast<long>(inAddress) == kUnInitStorage1)
			ProgramReport_AC("  It appears to be from uninitialized storage.\n");
		else if (reinterpret_cast<long>(inAddress) == kUnInitStorage2)
			ProgramReport_AC("  It appears to be from uninitialized storage.\n");
		else if (reinterpret_cast<long>(inAddress) == kDebugHandleInit)
			ProgramReport_AC("  It appears to be from a handle initialized by debugging.\n");
		else if (reinterpret_cast<long>(inAddress) == kDebugPtrInit)
			ProgramReport_AC("  It appears to be from a pointer initialized by debugging.\n");
		else if (reinterpret_cast<long>(inAddress) == kDebugObjInit)
			ProgramReport_AC("  It appears to be an uninitialized instance variable.\n");
		else if (reinterpret_cast<long>(inAddress) == *reinterpret_cast<long*>(0))
			ProgramReport_AC("  It appears to be a dereferenced NULL pointer.\n");
		else
			ProgramReport_AC("  It is not in a known heap.\n");
	}

	return valid;
}

#endif // qCoreDebug && !qCarbon

#if (UINT_MAX < ULONG_MAX)

//----------------------------------------------------------------------------------------
// BlockMove_AC:
//----------------------------------------------------------------------------------------

void BlockMove_AC(const void* srcPtr, void* destPtr, long byteCount)
{
	// We think size_t is at least a long, so we don't need a cast.
	// If we get a compiler warning, we're in trouble. 
	if (byteCount < UINT_MAX) // size_t could be an unsigned 16 bit value
		::memcpy(destPtr, srcPtr, byteCount);
	else
		BlockMoveData(srcPtr, destPtr, byteCount);
}

#endif		// (UINT_MAX < ULONG_MAX)

#if (UINT_MAX < ULONG_MAX)

//----------------------------------------------------------------------------------------
// BlockMoveOverlap_AC:
//----------------------------------------------------------------------------------------

void BlockMoveOverlap_AC(const void* srcPtr, void* destPtr, long byteCount)
{
	// We think size_t is at least a long, so we don't need a cast.
	// If we get a compiler warning, we're in trouble. 
	if (byteCount < UINT_MAX) // size_t could be an unsigned 16 bit value
		::memmove(destPtr, srcPtr, byteCount);
	else
		BlockMoveData(srcPtr, destPtr, byteCount);
}

#endif		// (UINT_MAX < ULONG_MAX)

#if !(qProjectBuilder || qNeedsCarbonEvents || qNeedsSystem8_5)


void BlockZero_AC(void* destPtr, long byteCount)
// BlockZero_AC will set a block of memory to zero.  This function has been optimized for
// cases where Altivec is available.  This implementation is provided for ; the only reason not to use it
// would be if its not available (pre-8.5).  If we know at compile time that we're using
// it, make it an inline.
{
#if qPowerPC
	if ((Ptr)BlockZero != (Ptr)kUnresolvedCFragSymbolAddress)	// in 8.5 and later
		::BlockZero(destPtr, byteCount);
	else	// Do a modified version of BlocKSet_AC, that only handles 0
#endif
	{
	#if qPowerPC
		enum { kBytesPerPunch = 8 };
		typedef double Punch, *PunchPtr;
			// select type double for best performance
	#else
		enum { kBytesPerPunch = 4 };
		typedef unsigned long Punch, *PunchPtr;
			// select type long for best performance
	#endif

		char* begPtr = reinterpret_cast<char*>(StripLong_AC(destPtr));
		char* endPtr = begPtr + byteCount;

		// this looks like the right cutoff, since for the optimization 
		// O(n) = kBPP + kBPP/2 + n/kBPP + kBPP/2 = 2*kBPP + n/kBPP
		// a simple linear fill has O(n) = n
		// n > 2*kBPP + n/kBPP if n > 2*kBPP, since 1/kBPP Å 0.
		
		if (byteCount >= (4 * kBytesPerPunch))
		{
			// progress to nearest 4 byte boundary. O(n) = kBytesPerPunch/2
			while (reinterpret_cast<long>(begPtr) & (kBytesPerPunch - 1))
				*begPtr++ = 0;

			// lets get a kBytesPerPunch byte 'punch'. O(n) = kBytesPerPunch
			register PunchPtr punchSetValPtr = (PunchPtr)begPtr;	// save pointer to the first value

			// truncate to nearest kBytesPerPunch bytes
			PunchPtr punchEndPtr = (PunchPtr)(reinterpret_cast<long>(endPtr) & (0xFFFFFFFF - (kBytesPerPunch - 1)));
		
			// assign in kBytesPerPunch byte chunks what we can. O(n) = n/kBytesPerPunch
			while (punchSetValPtr < punchEndPtr)
				*punchSetValPtr++ = 0;
				
			begPtr = (char*)punchSetValPtr;
		}
		
		// now finish assigning odd bytes. O(n) = kBytesPerPunch/2 if optimization chosen.
		while (begPtr < endPtr)
			*begPtr++ = 0;

	}
}

#endif		// !(qProjectBuilder || qNeedsCarbonEvents || qNeedsSystem8_5)

//----------------------------------------------------------------------------------------
// BlockSet: Much thanks for this improved version to Scott D. Schmitz
//----------------------------------------------------------------------------------------

void BlockSet_AC(void* destPtr, long byteCount, unsigned char setVal)
{
#if qPowerPC
	// Don't try for this optimization, if not on a PPC
	if (setVal == 0 
#if !(qProjectBuilder || qNeedsCarbonEvents || qNeedsSystem8_5)
		// if know that BlockZero is available, don't bother with the check
		&& (Ptr)BlockZero != (Ptr)kUnresolvedCFragSymbolAddress
#endif
				 )
	{
		::BlockZero(destPtr, byteCount);
		return;
	}
#endif
	// here are the results of using chars (1), longs (4) or doubles (8) on 68K and PowerPC
	// 				68K				601
	//---------------------------------------
	// char			261	(100)		237 (100)
	// long			156	(60)		68 	(29)
	// double		933	(357)		46	(19)
	//---------------------------------------
	// the poor result for 68K/double is to be expected. Jeroen Schalk, DTS.
	
#if qPowerPC
	enum { kBytesPerPunch = 8 };
	typedef double Punch, *PunchPtr;
		// select type double for best performance
#else
	enum { kBytesPerPunch = 4 };
	typedef unsigned long Punch, *PunchPtr;
		// select type long for best performance
#endif

	char* begPtr = reinterpret_cast<char*>(StripLong_AC(destPtr));
	char* endPtr = begPtr + byteCount;

	// this looks like the right cutoff, since for the optimization 
	// O(n) = kBPP + kBPP/2 + n/kBPP + kBPP/2 = 2*kBPP + n/kBPP
	// a simple linear fill has O(n) = n
	// n > 2*kBPP + n/kBPP if n > 2*kBPP, since 1/kBPP Å 0.
	
	if (byteCount >= (4 * kBytesPerPunch))
	{
		// progress to nearest 4 byte boundary. O(n) = kBytesPerPunch/2
		while (reinterpret_cast<long>(begPtr) & (kBytesPerPunch - 1))
			*begPtr++ = setVal;

		// lets get a kBytesPerPunch byte 'punch'. O(n) = kBytesPerPunch
		register PunchPtr punchSetValPtr = (PunchPtr)begPtr;	// save pointer to the first value
#if qPowerPC
		*begPtr++ = setVal;										// fill it in
		*begPtr++ = setVal;
		*begPtr++ = setVal;
		*begPtr++ = setVal;
#endif
		*begPtr++ = setVal;
		*begPtr++ = setVal;
		*begPtr++ = setVal;
		*begPtr++ = setVal;
		register Punch punchSetVal = *punchSetValPtr++;			// pick it up

		// truncate to nearest kBytesPerPunch bytes
		PunchPtr punchEndPtr = (PunchPtr)(reinterpret_cast<long>(endPtr) & (0xFFFFFFFF - (kBytesPerPunch - 1)));
	
		// assign in kBytesPerPunch byte chunks what we can. O(n) = n/kBytesPerPunch
		while (punchSetValPtr < punchEndPtr)
			*punchSetValPtr++ = punchSetVal;
			
		begPtr = (char*)punchSetValPtr;
	}
	
	// now finish assigning odd bytes. O(n) = kBytesPerPunch/2 if optimization chosen.
	while (begPtr < endPtr)
		*begPtr++ = setVal;
}

//----------------------------------------------------------------------------------------
// EqualBlocks_AC: 
//----------------------------------------------------------------------------------------

bool EqualBlocks_AC(const void* first, const void* second, size_t theSize)
{
	return !memcmp(first, second, theSize);
}

//----------------------------------------------------------------------------------------
// End of MemoryUtils_AC.cpp

