//----------------------------------------------------------------------------------------
// CAppleGuide_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		10/21/99	Carbon: compile out all code and headers, as not supported in Carbon.
		03/24/99	Update copyright notice.
		11/06/98	Changed first parm of ContextReplyProc from ContextCheckDataPtr_AC to Ptr.
		11/06/98	CarbonSeed110398: API of ContextReplyProc changed
		10/06/98	Clean up includes. 
		----- R13u4 -----
		05/02/98	Change qDebug to qDebugMsg where msg output is conditioned
		----- R13u3 -----
		11/18/97	CW Pro2 fixes. Added missing include for Gestalt.h
		09/03/97	Fixed up non-precompiled includes.
		08/24/97	Created.
*/
#if !qCarbon
#ifndef __CAppleGuide_AC__
#include "CAppleGuide_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __Configuration_AC__
#include "Configuration_AC.h"
#endif

#ifndef __CRect_AC__
#include "CRect_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// ToolBox

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

//----------------------------------------------------------------------------------------

static pascal OSErr CoachReplyProc(Rect *pRect, Ptr name, long refCon)
{
	OSErr returnErr = noErr;
	try 
	{
		CRect_AC replyRect;
		CAppleGuide_AC* guide = reinterpret_cast<CAppleGuide_AC*> (refCon);
		guide->DoCoachReply(replyRect, name);
		*pRect = replyRect;
	}
	catch (CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		returnErr = theException.GetError();
	}
	catch (...)
	{
#if qDebugMsg
		ProgramReport_AC("CoachReplyProc: An unhandled exception was almost passed to the Toolbox.");
#endif		
	}
	
	return returnErr;
}

//----------------------------------------------------------------------------------------
// •••  First parm was ContextCheckDataPtr_AC. 
static pascal OSErr ContextReplyProc(Ptr pInputData, Size inputDataSize, Ptr *ppOutputData, Size *pOutputDataSize, AGAppInfoHdl hAppInfo)
{
	OSErr returnErr = noErr;
	try 
	{
		CAppleGuide_AC* guide = reinterpret_cast<CAppleGuide_AC*> ((*hAppInfo)->refCon);
#if !qCarbon
		guide->DoContextReply(reinterpret_cast<ContextCheckDataPtr_AC>(pInputData), inputDataSize, ppOutputData, *pOutputDataSize, hAppInfo);
#else
		// •••  is this cast legit?
		guide->DoContextReply(reinterpret_cast<ContextCheckDataPtr_AC>(pInputData), inputDataSize, ppOutputData, *pOutputDataSize, hAppInfo);
#endif
	}
	catch (CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
		returnErr = theException.GetError();
	}
	catch (...)
	{
#if qDebugMsg
		ProgramReport_AC("ContextReplyProc: An unhandled exception was almost passed to the Toolbox.");
#endif		
	}
	return returnErr;
}

//----------------------------------------------------------------------------------------

CAppleGuide_AC::CAppleGuide_AC() :
	fCoachRefNum(0),
	fContextRefNum(0)
{
	// By default, this does nothing.
	// Subclass constructors may install one or both handlers by calling:
	//
	//	SetCoachMarkHandler();
	//	SetContextCheckHandler();
}

//----------------------------------------------------------------------------------------

CAppleGuide_AC::~CAppleGuide_AC()
{
	RemoveCoachMarkHandler();
	RemoveContextCheckHandler();
}

//----------------------------------------------------------------------------------------


void CAppleGuide_AC::SetCoachMarkHandler()
{
	if (HasAppleGuide_AC())
	{
		fCoachReplyUPP = NewCoachReplyProc(CoachReplyProc);
		::ThrowIfNULL_AC(fCoachReplyUPP);
		::ThrowIfOSErr_AC(::AGInstallCoachHandler(fCoachReplyUPP, (long) this, &fCoachRefNum));
	}
}

//----------------------------------------------------------------------------------------
	
void CAppleGuide_AC::SetContextCheckHandler(OSType contextType)
{
	if (HasAppleGuide_AC())
	{
		fContextReplyUPP = NewContextReplyProc(ContextReplyProc);
		::ThrowIfNULL_AC(fContextReplyUPP);
		::ThrowIfOSErr_AC(::AGInstallContextHandler(fContextReplyUPP, contextType, (long) this, &fContextRefNum));
	}
}

//----------------------------------------------------------------------------------------
	
void CAppleGuide_AC::RemoveCoachMarkHandler()
{
	if (HasAppleGuide_AC() && fCoachReplyUPP.get() != NULL)
	{
		AGRemoveCoachHandler(&fCoachRefNum);
		fCoachReplyUPP.reset();
	}
}

//----------------------------------------------------------------------------------------
	
void CAppleGuide_AC::RemoveContextCheckHandler()
{
	if (HasAppleGuide_AC() && fContextReplyUPP.get() != NULL)
	{
		AGRemoveContextHandler(&fContextRefNum);
		fContextReplyUPP.reset();
	}
}

//----------------------------------------------------------------------------------------

void CAppleGuide_AC::DoCoachReply(CRect_AC& replyRect, Ptr /*name*/)
{
#if qDebugMsg
	ProgramBreak_AC("AppleGuide coach reply proc installed, but no implementation.");
#endif
	replyRect = CRect_AC::kZeroRect;
}
	
//----------------------------------------------------------------------------------------

void CAppleGuide_AC::DoContextReply(ContextCheckDataPtr_AC /*pInputData*/, Size /*inputDataSize*/, Ptr* ppOutputData, Size& pOutputDataSize, AGAppInfoHdl /*hAppInfo*/)
{
#if qDebugMsg
	ProgramBreak_AC("AppleGuide context reply proc installed, but no implementation.");
#endif
	*ppOutputData = NULL;
	pOutputDataSize = 0;
}


//----------------------------------------------------------------------------------------

bool HasAppleGuide_AC() 
{
	static bool defined;
	static bool hasAppleGuide;
	if (!defined)
	{
		defined = true;
		hasAppleGuide = GestaltAttribute_AC(gestaltHelpMgrAttr, gestaltAppleGuidePresent);
	}
	return hasAppleGuide;

}

#endif	// of if !qCarbon
//----------------------------------------------------------------------------------------
// End of CAppleGuide_AC.cpp
