//----------------------------------------------------------------------------------------
// CCFString_AC.cpp
// Copyright © 1999-2001 by Apple Computer, Inc., all rights reserved.
//----------------------------------------------------------------------------------------

// Contains:	C++ wrappers for CoreFoundation strings

/*
	Change History:
		05/03/01	Consolidate inlines. 
		02/27/01	Redesign so CF references point to CF objects. 
		01/02/01	Update copyright.
		10/31/00	Move to ACS. 
		08/08/00	Default encoding for strings in the application is Mac Roman,
							not the system encoding. 
		07/31/00	ThrowIfBadAlloc_AC. 
							Use OSStatus for error codes. 
		07/29/00	Build standalone without ACS. 
		07/24/00	Range checking. 
		07/20/00	Add signed char equivalents for APIs that take only unsigned 
							chars, so the cast can be hidden from the caller. 
		07/12/00	Simplify constructors. 
		07/10/00	Allocators. 
		06/30/00	Allow defaulting encoding to system encoding. 
		06/29/00	Error handling. 
		06/11/00	Split off string encoding into its own class. 
		06/09/00	Initial version. 
*/

#ifndef __CCFString_AC__
#include "CCFString_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

//========================================================================================
// CCFStringEncoding_AC
//========================================================================================


//========================================================================================
// __CFString
//========================================================================================

/*static*/ CFStringRef __CFString::CreateWithPascalString(CFAllocatorRef alloc, ConstStringPtr pStr)
{
	return CreateWithPascalString(alloc, pStr, kCFStringEncodingMacRoman);
}

/*static*/ CFStringRef __CFString::CreateWithPascalString(CFAllocatorRef alloc, ConstStringPtr pStr, CFStringEncoding encoding)
{
	CFStringRef result = CFStringCreateWithPascalString(alloc, pStr, encoding);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithCString(CFAllocatorRef alloc, const char* cStr)
{
	return CreateWithCString(alloc, cStr, kCFStringEncodingMacRoman);
}

/*static*/ CFStringRef __CFString::CreateWithCString(CFAllocatorRef alloc, const char* cStr, CFStringEncoding encoding)
{
	CFStringRef result = CFStringCreateWithCString(alloc, cStr, encoding);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithCharacters(CFAllocatorRef alloc, const UniChar* chars, CFIndex numChars)
{
	CFStringRef result = CFStringCreateWithCharacters(alloc, chars, numChars);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithPascalStringNoCopy(CFAllocatorRef alloc, 
																  ConstStringPtr pStr, 
																  CFAllocatorRef contentsDeallocator)
{
	return CreateWithPascalStringNoCopy(alloc, pStr, kCFStringEncodingMacRoman, contentsDeallocator);
}

/*static*/ CFStringRef __CFString::CreateWithPascalStringNoCopy(CFAllocatorRef alloc, 
																  ConstStringPtr pStr, 
																  CFStringEncoding encoding, 
																  CFAllocatorRef contentsDeallocator)
{
	CFStringRef result = CFStringCreateWithPascalStringNoCopy(alloc, pStr, encoding, contentsDeallocator);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithCStringNoCopy(CFAllocatorRef alloc, 
															 const char* cStr, 
															 CFAllocatorRef contentsDeallocator)
{
	return CreateWithCStringNoCopy(alloc, cStr, kCFStringEncodingMacRoman, contentsDeallocator);
}

/*static*/ CFStringRef __CFString::CreateWithCStringNoCopy(CFAllocatorRef alloc, 
															 const char* cStr, 
															 CFStringEncoding encoding, 
															 CFAllocatorRef contentsDeallocator)
{
	CFStringRef result = CFStringCreateWithCStringNoCopy(alloc, cStr, encoding, contentsDeallocator);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithCharactersNoCopy(CFAllocatorRef alloc, 
																const UniChar* chars, 
																CFIndex numChars, 
																CFAllocatorRef contentsDeallocator)
{
	CFStringRef result = CFStringCreateWithCharactersNoCopy(alloc, chars, numChars, contentsDeallocator);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithSubstring(CFAllocatorRef alloc, CFStringRef str, CFRange range)
{
#if qRangeCheck
	str->RangeCheck(range);
#endif
	CFStringRef result = CFStringCreateWithSubstring(alloc, str, range);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateCopy(CFAllocatorRef alloc, CFStringRef theString)
{
	CFStringRef result = CFStringCreateCopy(alloc, theString);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithFormat(CFAllocatorRef alloc, CFDictionaryRef formatOptions, CFStringRef format, ...)
{
	va_list arguments;
	va_start(arguments, format);
	CFStringRef result = CreateWithFormatAndArguments(alloc, formatOptions, format, arguments);
	va_end(arguments);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithFormatAndArguments(CFAllocatorRef alloc, CFDictionaryRef formatOptions, CFStringRef format, va_list arguments)
{
	CFStringRef result = CFStringCreateWithFormatAndArguments(alloc, formatOptions, format, arguments);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateWithBytes(CFAllocatorRef alloc, 
													 const UInt8* bytes, 
													 CFIndex numBytes, 
													 bool isExternalRepresentation)
{
	return CreateWithBytes(alloc, bytes, numBytes, kCFStringEncodingMacRoman, isExternalRepresentation);
}

/*static*/ CFStringRef __CFString::CreateWithBytes(CFAllocatorRef alloc, 
													 const UInt8* bytes, 
													 CFIndex numBytes, 
													 CFStringEncoding encoding, 
													 bool isExternalRepresentation)
{
	CFStringRef result = CFStringCreateWithBytes(alloc, bytes, numBytes, encoding, isExternalRepresentation);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateFromExternalRepresentation(CFAllocatorRef alloc, 
																	  CFDataRef data)
{
	return CreateFromExternalRepresentation(alloc, data, CFStringGetSystemEncoding());
}

/*static*/ CFStringRef __CFString::CreateFromExternalRepresentation(CFAllocatorRef alloc, 
																	  CFDataRef data, 
																	  CFStringEncoding encoding)
{
	CFStringRef result = CFStringCreateFromExternalRepresentation(alloc, data, encoding);
	ThrowIfBadAlloc_AC(result);
	return result;
}

CFDataRef __CFString::CreateExternalRepresentation(CFAllocatorRef alloc, UInt8 lossByte) const
{
	return CreateExternalRepresentation(alloc, CFStringGetSystemEncoding(), lossByte);
}

CFDataRef __CFString::CreateExternalRepresentation(CFAllocatorRef alloc, CFStringEncoding encoding, UInt8 lossByte) const
{
	CFDataRef result = CFStringCreateExternalRepresentation(alloc, getref(), encoding, lossByte);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFStringRef __CFString::CreateByCombiningStrings(CFAllocatorRef alloc, 
															  CFArrayRef theArray, 
															  CFStringRef separatorString)
{
	CFStringRef result = CFStringCreateByCombiningStrings(alloc, theArray, separatorString);
	ThrowIfBadAlloc_AC(result);
	return result;
}

CFArrayRef __CFString::CreateArrayBySeparatingStrings(CFAllocatorRef alloc, 
														CFStringRef separatorString) const
{
	CFArrayRef result = CFStringCreateArrayBySeparatingStrings(alloc, getref(), separatorString);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFMutableStringRef __CFString::CreateMutable(CFAllocatorRef alloc, 
														CFIndex maxLength)
{
	CFMutableStringRef result = CFStringCreateMutable(alloc, maxLength);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFMutableStringRef __CFString::CreateMutableCopy(CFAllocatorRef alloc, 
															CFIndex maxLength, 
															CFStringRef theString)
{
	CFMutableStringRef result = CFStringCreateMutableCopy(alloc, maxLength, theString);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFMutableStringRef __CFString::CreateMutableWithExternalCharactersNoCopy(CFAllocatorRef alloc, 
																					UniChar* chars, 
																					CFIndex numChars, 
																					CFIndex capacity, 
																					CFAllocatorRef externalCharactersAllocator)
{
	CFMutableStringRef result = CFStringCreateMutableWithExternalCharactersNoCopy(alloc, chars, numChars, capacity, externalCharactersAllocator);
	ThrowIfBadAlloc_AC(result);
	return result;
}

/*static*/ CFMutableStringRef __CFString::CreateMutableWithPascalString(ConstStringPtr pStr, CFIndex maxLength)
{
	CAutoCFString_AC tempCFString(pStr);
	return CreateMutableCopy(NULL, maxLength, tempCFString);
}

/*static*/ CFMutableStringRef __CFString::CreateMutableWithCString(const char* cStr, CFIndex maxLength)
{
	CAutoCFString_AC tempCFString(cStr);
	return CreateMutableCopy(NULL, maxLength, tempCFString);
}

/*static*/ CFMutableStringRef __CFString::CreateMutableWithBytes(const char* bytes, CFIndex numBytes, 
																 bool isExternalRepresentation, 
																 CFIndex maxLength)
{
	CAutoCFString_AC tempCFString(bytes, numBytes, isExternalRepresentation);
	return CreateMutableCopy(NULL, maxLength, tempCFString);
}

/*static*/ CFMutableStringRef __CFString::CreateMutableWithBytes(const UInt8* bytes, CFIndex numBytes, 
																 bool isExternalRepresentation, 
																 CFIndex maxLength)
{
	CAutoCFString_AC tempCFString(bytes, numBytes, isExternalRepresentation);
	return CreateMutableCopy(NULL, maxLength, tempCFString);
}

void __CFString::AppendFormat(CFDictionaryRef formatOptions, CFStringRef format, ...)
{
	va_list arguments;
	va_start(arguments, format);
	AppendFormatAndArguments(formatOptions, format, arguments);
	va_end(arguments);
}

//----------------------------------------------------------------------------------------
// Range Checking
//----------------------------------------------------------------------------------------

#if qRangeCheck

//----------------------------------------------------------------------------------------
// getref
//----------------------------------------------------------------------------------------

CFStringRef __CFString::getref() const
{
	ThrowIfNonObject_AC(this);
	return this;
}

CFMutableStringRef __CFString::getref()
{
	ThrowIfNonObject_AC(this);
	return this;
}

//----------------------------------------------------------------------------------------
// RangeCheck
//----------------------------------------------------------------------------------------

bool __CFString::RangeCheck(CFIndex index, const char* debugString) const
{
	bool error = (index < 0) || (index > GetLength() - 1);
	if (error)
	{
#if qDebugMsg
		ProgramReport_AC("String range check: length == %1d  index == %1d\n", GetLength(), index);
#endif
		if (debugString)
			ProgramBreak_AC(debugString);
	}

	return error;
}

//----------------------------------------------------------------------------------------
// RangeCheck
//----------------------------------------------------------------------------------------

bool __CFString::RangeCheck(CFRange range, const char* debugString) const
{
	CFIndex mySize = GetLength();
	bool error = (range.location < 0) || (range.location > mySize - 1) ||
				  (range.length <= 0) || (range.location + range.length > mySize);
	if (error)
	{
#if qDebugMsg
		ProgramReport_AC("String range check: length == %1d  location,length == %1d,%1d\n", mySize, range.location, range.length);
#endif
		if (debugString)
			ProgramBreak_AC(debugString);
	}

	return error;
}

//----------------------------------------------------------------------------------------
// RangeCheckInsert
//----------------------------------------------------------------------------------------

bool __CFString::RangeCheckInsert(CFIndex index, const char* debugString) const
{
	bool error = (index < 0) || (index > GetLength());
	if (error)
	{
#if qDebugMsg
		ProgramReport_AC("String range check: length == %1d  index == %1d\n", GetLength(), index);
#endif
		if (debugString)
			ProgramBreak_AC(debugString);
	}

	return error;
}

//----------------------------------------------------------------------------------------
// ThrowIfRangeCheck
//----------------------------------------------------------------------------------------

void __CFString::ThrowIfRangeCheck(CFIndex index, const char* debugString) const
{
	if (RangeCheck(index, debugString))
		ThrowOutOfRange_AC();
}

//----------------------------------------------------------------------------------------
// ThrowIfRangeCheck
//----------------------------------------------------------------------------------------

void __CFString::ThrowIfRangeCheck(CFRange range, const char* debugString) const
{
	if (RangeCheck(range, debugString))
		ThrowOutOfRange_AC();
}

//----------------------------------------------------------------------------------------
// ThrowIfRangeCheckInsert
//----------------------------------------------------------------------------------------

void __CFString::ThrowIfRangeCheckInsert(CFIndex index, const char* debugString) const
{
	if (RangeCheckInsert(index, debugString))
		ThrowOutOfRange_AC();
}

#endif // qRangeCheck


//----------------------------------------------------------------------------------------
// End of CCFString_AC.cpp
