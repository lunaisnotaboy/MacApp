//------------------------------------------------------------------------------
// MemDebg.cpp
// Copyright © 1993-2001 by Apple Computer, Inc., all rights reserved.
//------------------------------------------------------------------------------

// Contains:	Memory management debug routine implementations

/*
	Change History
		01/02/01	Update copyright.
		09/20/00	DonÕt start file with C-style quotes -- VC++ complains.
		09/01/00	Stripped dead code.
		03/24/99	Update copyright notice.
*/

#ifndef _MEMCNFIG_
#include "MemCnfig.h"
#endif

#ifndef _MEMDEBG_
#include "MemDebg.h"
#endif


#if MM_DEBUG


#ifndef _MEMMGRPV_
#include "MemMgrPv.h"
#endif

#ifndef _MEMORYHE_
#include "MemoryHe.h"
#endif

//	#ifndef _MEMHOOKS_
//	#include "MemHooks.h"
//	#endif

#include <string.h>

#ifndef __Crawl_AC__
#include "Crawl.h"
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif


//==============================================================================
// Global variable definitions
//==============================================================================

char gValidate = 0;
char gHeapChecking = 0;


//==============================================================================
// Function definitions
//==============================================================================
MMBoolean
MMFindBlockContaining( const void *start, const void *end,
					   const void* *blockStart, const void* *blockEnd );

MMBoolean
MMValidateMemoryRange( const void *start, const void *end );

//------------------------------------------------------------------------------
// DoesHeapExist
//------------------------------------------------------------------------------

MMBoolean MMDoesHeapExist( MemoryHeap *heap )
{
	if( heap->GetLocation() == kMMSysMemory )
		return kMMTrue;		// A system heap might have been allocated by another process.
		
	for( MemoryHeap *h = MemoryHeap::GetFirstHeap(); h; h = h->GetNextHeap() )
		if( h == heap )
			return kMMTrue;
	return kMMFalse;
}

//------------------------------------------------------------------------------
// MMBeginMemValidation
//------------------------------------------------------------------------------

void
MMBeginMemValidation( )
{
	MMValidateAllHeaps();
	if( gValidate==0 )
		for( MemoryHeap *h = MemoryHeap::GetFirstHeap(); h; h = h->GetNextHeap() ) {
			h->SetZapOnAllocate(kMMTrue);
			h->SetZapOnFree(kMMTrue);
			h->SetAutoValidation(kMMTrue);
		}
	gValidate++;
}

//------------------------------------------------------------------------------
// MMEndMemValidation
//------------------------------------------------------------------------------

void
MMEndMemValidation( )
{
	if( gValidate<=0 ) {
		MM_WARN("Improper nesting of memory-validation calls");
		return;
	}
	
	MMValidateAllHeaps();
	gValidate--;
	if (gValidate==0)
		for( MemoryHeap *h = MemoryHeap::GetFirstHeap(); h; h = h->GetNextHeap() ) {
			h->SetZapOnAllocate(kMMFalse);
			h->SetZapOnFree(kMMFalse);
			h->SetAutoValidation(kMMFalse);
		}
}

//------------------------------------------------------------------------------
// MMBeginHeapChecking
//------------------------------------------------------------------------------

void
MMBeginHeapChecking( )
{
	gHeapChecking++;
	MMBeginMemValidation();
}

//------------------------------------------------------------------------------
// MMEndHeapChecking
//------------------------------------------------------------------------------

void
MMEndHeapChecking( )
{
	if( gHeapChecking<=0 ) {
		MM_WARN("Improper nesting of heap-checking calls");
		return;
	}
	
	gHeapChecking--;
	MMEndMemValidation();
}

//------------------------------------------------------------------------------
// MMValidateHeap
//------------------------------------------------------------------------------

static bool
HeapCheckProc( const void *blk, unsigned long /*size*/, bool isObject, void *refCon )
{
	if( isObject ) {
		(*(MMULong*)refCon) ++;							// Increment object count
		MMValidateObject((SOMObject*)blk);
	}
	return true;
}


MMBoolean
MMValidateHeap( MemoryHeap *heapID, const void* /*ptr*/ )
{
	if (!heapID )
		heapID = MMGetDefaultHeap();

	MM_ASSERT(heapID);
	
	MMULong objects = 0;
	heapID->Check(&HeapCheckProc, &objects);
	
	return kMMTrue;
}


//------------------------------------------------------------------------------
// MMValidateAllHeaps
//------------------------------------------------------------------------------

MMBoolean
MMValidateAllHeaps( )
{
	MMBoolean result = kMMTrue;
	for( MemoryHeap *h = MemoryHeap::GetFirstHeap(); h; h = h->GetNextHeap() )
		if( !MMValidateHeap(h) )
			result = kMMFalse;
	return result;
}


//------------------------------------------------------------------------------
// MMValidatePtr
//------------------------------------------------------------------------------

MMBoolean
MMValidatePtr( const void* p, MMBoolean validateHeap, const char *operation )
{
	// If we could be sure that p were in the app zone, we could be more
	// stringent. But it might be in the System heap or in temp-mem.
	
	const char *err = BasicValidatePtr(p);
	if( !err ) {
		MemoryHeap *heap = gDefaultHeap->GetBlockHeap(p);
		
		if( !heap->IsValidBlock(p) ) {
			err = "is invalid";
		} else if( validateHeap && !MMValidateHeap(heap,p) )
			return kMMFalse;	// ODValidateHeap already warns the user
		else
			return kMMTrue;
	}
	
	if( operation )
		MM_WARN("%s(%p): ptr %s!",operation,p,err);
	else
		MM_WARN("Pointer %p %s!",p,err);
	return kMMFalse;
}


//------------------------------------------------------------------------------
// MMValidateObject
//------------------------------------------------------------------------------

static MMBoolean
BasicIsObject( const void *block )
{
	// This is like MMIsObject but does not do any heap checking, which would
	// be fatal if MMValidateObject were already being called during a heap-check!
	
	MemoryHeap *heap = gDefaultHeap->GetBlockHeap(block);
	return heap ?heap->BlockIsObject(block) :kMMFalse;
}

MMBoolean
MMValidateObject( const SOMObject *o )
{
	// I mustn't check the heap, since I am called during heap checking!!
	if( !MMValidatePtr(o,kMMFalse,"MMValidateObject") )
		return kMMFalse;
	
	const char *err;
	if( !BasicIsObject(o) )
		err = "is not marked as an object in the heap";
	else
		return kMMTrue;
	
	MM_WARN("Object %p %s!", o, err);
	return kMMFalse;
}

//------------------------------------------------------------------------------
// MMGetHeapInfo
//------------------------------------------------------------------------------

void
MMGetHeapInfo( MemoryHeap *heapID,
				const char* *name, size_t *allocated, size_t *free,
				size_t *nBlocks, size_t *nObjects )
{
	MemoryHeap *heap = heapID ? heapID : MMGetDefaultHeap();
	
	if( name )		*name = heap->GetDescription();
	if( allocated )	*allocated = heap->BytesAllocated();
	if( free )		*free = heap->BytesFree();
	if( nBlocks )	*nBlocks = heap->NumberAllocatedBlocks();
	
	if( nObjects ) {
		*nObjects = 0;
		heap->Check(&HeapCheckProc,&*nObjects);
	}
}


//------------------------------------------------------------------------------
// MMWalkHeap
//------------------------------------------------------------------------------

struct HeapWalkData {
	MMBlockInfoProc proc;
	void *refCon;
};

static bool CallHeapWalkProc( const void *blk, unsigned long size, bool isObject,
								 void *refCon )
{
	if( isObject )
		MMValidateObject((SOMObject*)blk);
	else
		MMValidatePtr(blk,false);
		
	HeapWalkData *data = (HeapWalkData*) refCon;
	return (data->proc) (blk, size, isObject, data->refCon);
}



void
MMWalkHeap( MemoryHeap *heapID, MMBlockInfoProc proc, void *refCon )
{
	MemoryHeap *heap = heapID ? heapID : MMGetDefaultHeap();
	
	HeapWalkData data;
	data.proc = proc;
	data.refCon = refCon;
	heap->Check(/*(HeapWalkProc)*/CallHeapWalkProc,&data);
}

MMBoolean
MMFindBlockContaining( const void *start, const void *end,
					   const void* *blockStart, const void* *blockEnd )
{
	const void *foo, *bar;
	if( !blockStart ) blockStart=&foo;
	if( !blockEnd   ) blockEnd=&bar;
		
	if( end<start ) {
		const void *temp = end;
		end = start;
		start = temp;
	}

	MemoryHeap *heap = MMGetDefaultHeap();
	return heap->FindBlockContaining(start,end,*blockStart,*blockEnd);
}


MMBoolean
MMValidateMemoryRange( const void *start, const void *end )
{
	// Warn if memory range is in default heap but not entirely within a valid block:
	if( end<start ) {
		const void *temp = end;
		end = start;
		start = temp;
	}
	const void *blockStart, *blockEnd;
	MemoryHeap *heap = MMGetDefaultHeap();
	if( heap->FindBlockContaining(start,end, blockStart,blockEnd) )
		if( blockStart==NULL ) {
			MM_WARN("Mem range %p--%p is in heap but not in any block", start,end);
			return kMMFalse;
		} else if( start<blockStart || end>blockEnd ) {
			MM_WARN("Mem range %p--%p violates block %p--%p",
					start,end, blockStart,blockEnd);
			return kMMFalse;
		}
	return kMMTrue;
}

//========================================================================================
// Non-Debug Stubs
//========================================================================================

#else /* MM_DEBUG */


void		MMBeginMemValidation( ) { }
void		MMEndMemValidation( ) { }
void		MMBeginHeapChecking( ) { }
void		MMEndHeapChecking( ) { }

MMBoolean	MMValidatePtr( ConstMMBlock, MMBoolean /*validateHeap*/, const char * /*operation*/ )	{return 1;}
MMBoolean	MMValidateObject( const SOMObject * /*o*/ ) {return 1;}
MMBoolean	MMValidateHandle( MMHandle ) {return 1;}

MMBoolean	MMDoesHeapExist( MemoryHeap * /*heap*/ ) {return 1;}
MMBoolean	MMValidateHeap( MemoryHeap * /*heapID*/, const void* /*ptr*/ ) {return 1;}
MMBoolean	MMValidateAllHeaps( ) {return 1;}

void		MMGetHeapInfo( MemoryHeap * /*heapID*/,
							const char* * /*name*/, size_t * /*allocated*/, size_t * /*free*/,
							size_t * /*nBlocks*/, size_t * /*nObjects*/ ) { }

void		MMWalkHeap( MemoryHeap * /*heapID*/, MMBlockInfoProc, void * /*StackCrawl*/ )  { }

MMBoolean	MMFindBlockContaining( const void *, const void*,
									const void* *blockStart, const void* * /*blockEnd*/ )
{
	if( blockStart ) *blockStart=NULL;
	return 0;
}
MMBoolean	MMValidateMemoryRange( const void * /*start*/, const void * /*end*/ )	{return 1;}

#endif /*MMDebug*/
