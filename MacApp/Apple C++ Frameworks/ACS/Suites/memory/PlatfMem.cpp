//----------------------------------------------------------------------------------------
// PlatfMem.cpp
// Copyright © 1993-2001 by Apple Computer, Inc. All rights reserved.
//
// Contains: Platform layer implementation
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		02/22/00	[W] Do not StripAddress in PlatformAllocateBlock.
		12/27/99	Stripped out unused code.
		12/07/99	Strip path in MM_ASSERT_FAILED.
		07/23/99	[C] Call PurgeSpace instead of MMSystemFreeSpace.
		03/24/99	Update copyright notice.
		11/13/98	Don't use StripAddress for Carbon
		10/06/98	Clean up includes. 
*/

#ifndef _PLATFMEM_
#include "PlatfMem.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef _MEMMGRPV_
#include "MemMgrPv.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// ANSI

#include <string.h>
#include <stdio.h>
#include <stdarg.h>

//========================================================================================
// External
//========================================================================================

/* Adkins -- removed const from first param to somPrintf -- it was never const */
extern "C" int somPrintf (const char * fmt, ...);		// From <somapi.h>

//========================================================================================
// Global function definitions
//========================================================================================

//----------------------------------------------------------------------------------------
// PlatformZapMem
//----------------------------------------------------------------------------------------

void PlatformZapMem( void *start, size_t size, MMULong value )
{
	MM_ASSERT(((size_t)start&3)==0);				// Must start on a 4byte boundary
	long *blk = (long *) start;
	for (long i = size>>2; i>0; i--) 					// (i must be signed!)
		*blk++ = value;
	if( size&3 )
		PlatformCopyMemory(&value,blk, size&3);		// Fill remaining 1-3 bytes
}

//----------------------------------------------------------------------------------------
// PlatformAllocateBlock
//----------------------------------------------------------------------------------------

void *PlatformAllocateBlock(size_t size, MMHeapLocation src )
{
	// Check total free space before trying anything; must leave some amount free.
	size_t free;
	#if !qCarbon
	MMSystemFreeSpace(src,&free,kMMNULL);
	#else
	PurgeSpace((long *)&free,(long *)kMMNULL);
	#endif
	if( free-size < kPlatformMinFreeSpace )
		return kMMNULL;
		
	Handle handle = (Handle) MMAllocateHandleIn(size,src);
			
	if ( handle ) {
		if( src==kMMAppMemory )
			::MoveHHi(handle);	// Jeff Crawford sez we don't need MoveHHi for temp/sys heap
		::HLock(handle);
		OSErr err = MemError();
		
		if (err == noErr)
#if !qCarbon && !qMSWindows
			return StripAddress(*handle);
#else
			// Carbon spec says not to use StripAddress
			return *handle;
#endif
		else
			DisposeHandle(handle);
	}
	
	return kMMNULL;
}

//----------------------------------------------------------------------------------------
// PlatformFreeBlock
//----------------------------------------------------------------------------------------

void PlatformFreeBlock(void *ptr)
{
	Handle handle = ::RecoverHandle((Ptr) ptr);

#if MM_DEBUG
	OSErr err = MemError();
	if( err )
		MM_WARN("PlatformFreeBlock got err %hd on ptr %p",err,ptr);
#endif

	if( handle == NULL )
		return;
	
#if MM_DEBUG
	// Zap the block as we dispose it:
	if( gValidate > 0 )
		PlatformZapMem(ptr,::GetHandleSize(handle),0xDEADBEEF);
#endif

	::DisposeHandle(handle);
	
#if MM_DEBUG
	err = MemError();
	if( err && err != memFullErr )
		MM_WARN("PlatformFreeBlock got err %hd on hdl %p",err,handle);
#endif
}

//----------------------------------------------------------------------------------------
// BREAK
//----------------------------------------------------------------------------------------

static void
BREAK( const char msg[] )
{
	// Now convert to Pascal string and call DebugStr:
	Str255 pstr;
	long len = strlen(msg);
	pstr[0] = (len>255) ?255 :len;
	for( int i=pstr[0]; i>0; i-- ) {
		char c = msg[i-1];
		if( c==';' ) c=':';		// ";" is bad in DebugStrs
		pstr[i] = c;
	}

	DebugStr(pstr);
}


//----------------------------------------------------------------------------------------
// MM_ASSERT_FAILED
//----------------------------------------------------------------------------------------

void MM_ASSERT_FAILED(const char *cond, const char *fil)
{
	fil = LeafName_AC(fil);
	char dbg[256];
	sprintf(dbg,"MM: %s ...NOT! In %s", cond,fil); 
	::Assertion_AC(::strlen(dbg) < sizeof(dbg),
				   "MM_SHOW_WARNING: Write beyond end of dbg.");
	BREAK(dbg);
}

//----------------------------------------------------------------------------------------
// MM_SHOW_WARNING
//----------------------------------------------------------------------------------------

void MM_SHOW_WARNING(const char *msg, ...)
{
	char buf[512];
	strcpy(buf, "MMWarning: ");
	va_list args;
	va_start(args,msg);
	vsprintf(buf+strlen(buf),msg,args);
	::Assertion_AC(::strlen(buf) < sizeof(buf),
				   "MM_SHOW_WARNING: Write beyond end of buf.");
	va_end(args);
	
	BREAK(buf);
}

//----------------------------------------------------------------------------------------
// MMPrintf
//----------------------------------------------------------------------------------------

int MMPrintf(const char *fmt, ...)
{
	int n;
	char buf[512];
	va_list args;
	va_start(args, fmt);
	vsprintf(buf, fmt, args);
	::Assertion_AC(::strlen(buf) < sizeof(buf),
				   "MMPrintf: Write beyond end of buf.");
	va_end(args);
	n = 0;
#if qDebugMsg
	ProgramReport_AC(buf);
#endif
	return n;
}


//----------------------------------------------------------------------------------------
// End of PlatfMem.cpp
