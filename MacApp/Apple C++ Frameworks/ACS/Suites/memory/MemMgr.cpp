//------------------------------------------------------------------------------
// MemMgr.cpp
// Copyright © 1994-2001 by Apple Computer, Inc., all rights reserved.
//------------------------------------------------------------------------------

// Contains:	Procedural API for memory heaps

/*
	Change History
		01/02/01	Update copyright.
		09/20/00	Don’t start file with C-style quotes -- VC++ complains.
		08/22/00	CW Pro 6: remove unnecessary casts in MMNewHeap. 
		05/03/00	[C] Call PurgeSpace in MMGetFreeSpace.
		07/23/99	[C] Do not do warning check in MMMove.
		03/24/99	Update copyright notice.
*/


#ifndef _MEMMGR_
#include "MemMgr.h"
#endif

#ifndef _MEMMGRPV_
#include "MemMgrPv.h"
#endif

#ifndef _MEMDEBG_
#include "MemDebg.h"
#endif

#ifndef _MEMORYHE_
#include "MemoryHe.h"
#endif


#undef SURVEY_SIZES

// Added the following prototype, it was missing from MemDebg.h. Future versions of that file should include it!!
extern MMBoolean
MMValidateMemoryRange( const void *start, const void *end );


//==============================================================================
// GLOBAL VARIABLES
//==============================================================================


MemoryHeap	*gDefaultHeap;


#ifdef SURVEY_SIZES
	const int kNSizeBins = 100;
	unsigned long gSizeBin[kNSizeBins];
	unsigned long gNAllocations;
#endif


//========================================================================================
// HEAP MANAGEMENT
//========================================================================================

long MMConfiguration( )
{
	return MM_DEBUG ?kMMDebugConfigMask :0;
}


//------------------------------------------------------------------------------
// MMNewHeap
//------------------------------------------------------------------------------

MemoryHeap* MMNewHeap( MMHeapLocation loc, size_t initialSize, size_t growAmount,
#if MM_DEBUG
					const char* name
#else
					const char* /*name*/
#endif
				  )
{
	MemoryHeap *heap = new(loc) MemoryHeap(initialSize, growAmount, 0, loc);
	if( heap ) {
		heap->IMemoryHeap();
#if MM_DEBUG
		if( name )
			heap->SetDescription(name);
		if( gValidate>0 ) {
			heap->SetZapOnAllocate(kMMTrue);
			heap->SetZapOnFree(kMMTrue);
			heap->SetAutoValidation(kMMTrue);
		}
#endif
	}
	return heap;
}


//------------------------------------------------------------------------------
// MMDisposeHeap
//------------------------------------------------------------------------------

void MMDisposeHeap( MemoryHeap *heap )
{
	delete heap;
}


//------------------------------------------------------------------------------
// MMGetDefaultHeap
//------------------------------------------------------------------------------

MemoryHeap* MMGetDefaultHeap( )
{
	return gDefaultHeap;
}


//------------------------------------------------------------------------------
// MMSetDefaultHeap
//------------------------------------------------------------------------------

MemoryHeap* MMSetDefaultHeap( MemoryHeap *heap )
{
	MM_ASSERT(heap!=kMMNULL);
	MemoryHeap *oldDefault = gDefaultHeap;
	gDefaultHeap = heap;
	return oldDefault;
}


//========================================================================================
// FREE SPACE MANAGEMENT
//========================================================================================


//----------------------------------------------------------------------------------------
// MMGetFreeSpace
//----------------------------------------------------------------------------------------

void MMGetFreeSpace( MemoryHeap *heapID, size_t *total, size_t *contig )
{
	MemoryHeap *heap = heapID ? heapID : MMGetDefaultHeap();
	
	size_t sysTotal, sysContig, heapTotal, heapContig;
	
#if qCarbon
	PurgeSpace((long*)&sysTotal,(long*)&sysContig);
#else
	MMSystemFreeSpace(heap->GetLocation(),&sysTotal,&sysContig);
#endif
	heapTotal = heap->BytesFree();
	size_t incr = heap->GetSizeIncrement();
	
	if( sysContig < incr || sysTotal < incr+kPlatformMinFreeSpace ) {
		// Not enough memory to grow heap, so we're limited to space in heap.
		heapTotal = sysTotal;
		heapContig = heap->LargestFreeBlock();
	} else {
		heapTotal += sysTotal;
		heapContig = sysContig;
	}
	
	if( total ) *total = heapTotal;
	if( contig) *contig= heapContig;
}


MMBoolean MMAllocateSlushFund( MemoryHeap *heapID, size_t size, size_t allocSizeLimit )
{
	MemoryHeap *heap = heapID ? heapID : gDefaultHeap;
	return heap->AllocateSlushFund(size,allocSizeLimit);
}


size_t MMSlushFundSize( MemoryHeap *heapID )
{
	MemoryHeap *heap = heapID ? heapID : gDefaultHeap;
	return heap->GetSlushFundSize();
}


size_t MMFreeSlushFund( MemoryHeap *heapID )
{
	MemoryHeap *heap = heapID ? heapID : gDefaultHeap;
	return heap->FreeSlushFund();
}



//========================================================================================
// OPERATIONS ON BLOCKS
//========================================================================================


#ifdef SURVEY_SIZES
static void SurveySize( size_t size )
{
	size_t index = (size+3)>>2;
	if( index >= kNSizeBins )
		index = kNSizeBins-1;
	gSizeBin[index]++;
	gNAllocations++;
}
#endif


//------------------------------------------------------------------------------
// MMAllocate
//------------------------------------------------------------------------------

void* MMAllocate( size_t size )
{
#if MM_DEBUG
	if( (MMULong)size > MemoryHeap::kMaxBlockSize )
	{
		MM_WARN("Bogus size 0x%08lx for MMAllocate",size);
		return kMMNULL;
	}
	
	if( gHeapChecking>0 )
		MMValidateHeap(gDefaultHeap);
#endif

#ifdef SURVEY_SIZES
	SurveySize(size);
#endif

	return gDefaultHeap->Allocate(size);
}


//------------------------------------------------------------------------------
// MMAllocateIn
//------------------------------------------------------------------------------

void* MMAllocateIn( size_t size, MemoryHeap *heap )
{
#if MM_DEBUG
	if( (MMULong)size > MemoryHeap::kMaxBlockSize )
	{
		MM_WARN("Bogus size 0x%08lx for MMAllocate",size);
		return kMMNULL;
	}
	
	if( gHeapChecking>0 )
		MMValidateHeap(heap);
#endif

#ifdef SURVEY_SIZES
	SurveySize(size);
#endif

	return heap->Allocate(size);
}


//------------------------------------------------------------------------------
// MMAllocateClear
//------------------------------------------------------------------------------

void* MMAllocateClear( size_t size )
{
	return MMAllocateClearIn(size, gDefaultHeap);
}


//------------------------------------------------------------------------------
// MMAllocateClearIn
//------------------------------------------------------------------------------

void* MMAllocateClearIn( size_t size, MemoryHeap *heap )
{
	void *block = MMAllocateIn(size,heap);
	if( block )
		PlatformZapMem(block,size,0);
	return block;
}


//------------------------------------------------------------------------------
// MMReallocate
//------------------------------------------------------------------------------

void* MMReallocate( void *block, size_t size )
{
#ifdef SURVEY_SIZES
	SurveySize(size);
#endif

	if( block==kMMNULL )
		return gDefaultHeap->Allocate(size);
	else {
		MemoryHeap *heap = MMGetHeap(block);
		if( heap )
			return heap->Reallocate(block,size);
		else
			return kMMNULL;
	}
}


//------------------------------------------------------------------------------
// MMSplice
//------------------------------------------------------------------------------

void* MMSplice( void *block, size_t offset, long delta )
{
	// If delta>0, insert bytes at offset. If delta<0, delete bytes at offset.
	
	if( delta==0 ) return block;
	size_t oldSize = block ?MMBlockSize(block) :0;
	MM_ASSERT(offset<=oldSize);
	if( MM_DEBUG && delta<0 )
		MM_ASSERT(offset-delta<=oldSize);
		
	size_t newSize = oldSize + delta;
	void *newBlock;
	if( newSize==0 )
		newBlock = kMMNULL;
	else {
		MemoryHeap *heap = MMGetHeap(block);
		if( heap )
			newBlock = heap->Allocate(newSize);
		else {
			MM_WARN("Couldn't get block's heap in MMSplice");
			return kMMNULL;
		}
		if( newBlock ) {
			PlatformCopyMemory(block,newBlock,offset);
			if( delta>0 )
				PlatformCopyMemory((char*)block+offset,(char*)newBlock+offset+delta, oldSize-offset);
			else
				PlatformCopyMemory((char*)block+offset-delta,(char*)newBlock+offset, oldSize-offset+delta);
		}
	}
	MMFree(block);
	return newBlock;
}


//------------------------------------------------------------------------------
// GetHeap [static]
//------------------------------------------------------------------------------


MemoryHeap* GetHeap( const void* block, const char *op )
{
	if (block == kMMNULL)
	{
		MM_WARN("%s(NULL) is bogus, dude",op);
		return kMMNULL;
	}
	
#if MM_DEBUG		
	if( gValidate>0 )
		if( !MMValidatePtr(block,gHeapChecking>0,op) )
			return kMMNULL;
#endif
	
	return gDefaultHeap->GetBlockHeap(block);	// Should be static but isn't
}



//------------------------------------------------------------------------------
// MMFree
//------------------------------------------------------------------------------

void MMFree( void *block )
{
	if( block ) {
		MemoryHeap *heap = GetHeap(block,"MMFree");
		if( heap ) {
			#if MM_DEBUG
				// The isObject flag should have been cleared by ODObject::SOMUninit!
				if( heap->BlockIsObject(block) )
					MM_WARN("Object %p unexpectedly disposed!",block);
			#endif
					
			heap->Free(block);
		}
	}
}


//------------------------------------------------------------------------------
// MMBlockSize
//------------------------------------------------------------------------------

size_t MMBlockSize( const void *block )
{
	MemoryHeap *heap = GetHeap(block,"MMBlockSize");
	if( heap )
		return heap->BlockSize(block);
	else
		return 0;
}


//------------------------------------------------------------------------------
// MMGetHeap
//------------------------------------------------------------------------------

MemoryHeap* MMGetHeap( const void* block )
{
	return GetHeap(block,"MMGetHeap");
}


//------------------------------------------------------------------------------
// MMSetIsObject
//------------------------------------------------------------------------------

void MMSetIsObject(MMBlock block, MMBoolean isObject )
{
	MemoryHeap *heap = GetHeap(block,"MMSetIsObject");
	if( heap )
		heap->SetBlockIsObject(block,isObject);
}


//------------------------------------------------------------------------------
// MMIsObject
//------------------------------------------------------------------------------

MMBoolean MMIsObject(ConstMMBlock block)
{
	MemoryHeap *heap = GetHeap(block,"MMIsObject");
	if( heap )
		return heap->BlockIsObject(block);
	else
		return kMMFalse;
}


//------------------------------------------------------------------------------
// MMMove
//------------------------------------------------------------------------------

void MMMove( void *dst, const void *src, size_t size )
{
	if( size!=0 && src!=dst ) {
#if MM_DEBUG && !qCarbon
		static void *worldStart = LOWEST_POSSIBLE_ADDRESS();
		static void *worldEnd   = HIGHEST_POSSIBLE_ADDRESS();
		const void *srcEnd = (char*)src+size;
		const void *dstEnd = (char*)dst+size;
		if( srcEnd<worldStart || src>worldEnd || dstEnd<worldStart || dst>worldEnd
					|| (size&~0x0FFFFFFF) )
			MM_WARN("MMMove(%p,%p,%ld) looks weird", dst,src,size);
		if( gValidate>0 ) {
			MMValidateMemoryRange(src,srcEnd);
			MMValidateMemoryRange(dst,(char*)dst+size);
		}
#endif
		PlatformCopyMemory((void*)src,dst,size);
	}
}
