//------------------------------------------------------------------------------
// MemDebgM.cpp
// Copyright © 1993-2001 by Apple Computer, Inc., all rights reserved.
//------------------------------------------------------------------------------

// Contains:	Mac-specific memory management debug routines

/*
	Change History
		03/01/01	Don't include Memory_AC. 
		01/02/01	Update copyright.
		09/20/00	DonÕt start file with C-style quotes -- VC++ complains.
		09/01/00	Stripped dead code.
		02/22/00	[W] Do not StripAddress in BasicValidatePtr.
		03/24/99	Update copyright notice.
		10/28/98	Carbonized
*/


#ifndef _MEMCNFIG_
#include "MemCnfig.h"
#endif


#if MM_DEBUG


#ifndef _MEMDEBG_
#include "MemDebg.h"
#endif

#ifndef _MEMMGRPV_
#include "MemMgrPv.h"
#endif

//	#ifndef _MEMHOOKS_
//	#include "MemHooks.h"
//	#endif

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif


const size_t kMaxHandleBlockSize = 0x7FFFFFFF;


//------------------------------------------------------------------------------
// PtrInHeap
//------------------------------------------------------------------------------

inline static MMBoolean
PtrInHeap( const void *p, THz heap )
{
	return (p >= &heap->heapData) && (p < heap->bkLim);
}


//------------------------------------------------------------------------------
// BasicValidatePtr
//------------------------------------------------------------------------------

const char*
BasicValidatePtr( const void *p, MMBoolean /*mustBeInHeap*/ )
{
	// If we could be sure that p were in the app zone, we could be more
	// stringent. But it might be in the System heap or in temp-mem.

#if !qCarbon && !qMSWindows
	// Carbon spec says not to use StripAddress
	p = StripAddress((void*)p);
#endif
	
	if( p == kMMNULL )
		return "is NULL";
//	else if( (MMULong)p & 1 )
//		return "is odd";
	else if( (MMULong)p & 2 )
		return "isn't 4-byte-aligned";
#if !qCarbon
	else if( /*!mustBeInHeap &&*/ (p<LOWEST_POSSIBLE_ADDRESS() || p>HIGHEST_POSSIBLE_ADDRESS()) )
		return "is outside the known universe";
#endif
	else
		return kMMNULL;
}


//------------------------------------------------------------------------------
// MMValidateHandle
//------------------------------------------------------------------------------

MMBoolean
MMValidateHandle( MMHandle MMHandle )
{
	Handle h = (Handle) MMHandle;
	
	// Check handle itself as a pointer:
	const char *err = BasicValidatePtr(h);
	
	if( err == kMMNULL && *h == kMMNULL )
		err = "is purged";
	
	if( err ) {
		MM_WARN("Handle %p %s!",h,err);
		return kMMFalse;
	}
	
	// Check master pointer for validity:
	err = BasicValidatePtr(*h);
	if( err ) {
		MM_WARN("Handle %p's master %p %s!",h,*h,err);
		return kMMFalse;
	}
	
	// Check handle's size:
	size_t size = GetHandleSize(h);
	if( size > kMaxHandleBlockSize )
		MM_WARN("Handle %p has bogus size %08lx!",h,size);
	else if( MemError() != noErr )
		MM_WARN("Handle %p caused err %d on GetHandleSize",h,MemError());
	else
		return kMMTrue;
	return kMMFalse;
}

//----------------------------------------------------------------------------------------
// MMGetTotalMemory:
//----------------------------------------------------------------------------------------

size_t MMGetTotalMemory()
{
	static bool defined;
	static size_t totalMemory;
	if (!defined)
	{
		defined = true;

		if( Gestalt(gestaltLogicalRAMSize, (long*)&totalMemory) != noErr )
			totalMemory = 0x80000000;	// bogus default value

		long result;
		if( Gestalt(gestaltVMAttr,&result) == noErr && (result&1) )
			totalMemory <<= 1;			// Use double logical RAM size if VM on
										// since code fragments get loaded above it
	}
	return totalMemory;
}

#endif /*MM_DEBUG*/
