//----------------------------------------------------------------------------------------
// MDependable_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/16/01	GetDependencySpace is now const.
		01/02/01	Update copyright.
		09/01/00	Added embedded documentation.
		08/31/00	Really fixed file name in banner.
		12/07/99	Corrected file name in banner.
		09/09/99	Minor cosmetic work.
		03/24/99	Update copyright notice.
*/

#ifndef __MDependable_AC__
#include "MDependable_AC.h"
#endif

// ACS

#ifndef __CDependencies_AC__
#include "CDependencies_AC.h"
#endif

//========================================================================================
// CLASS MDependable_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// MDependable_AC destructor
//----------------------------------------------------------------------------------------

MDependable_AC::~MDependable_AC()
{
	RemoveAllDependencies();
}

//----------------------------------------------------------------------------------------
// MDependable_AC::Changed: 
//----------------------------------------------------------------------------------------

void MDependable_AC::Changed(ChangeID_AC theChange, void* changeData)
{
	CDependencySpace_AC* itsDependencySpace = GetDependencySpace();

	if (itsDependencySpace)
		itsDependencySpace->NotifierChanged(this, theChange, changeData);
}

//----------------------------------------------------------------------------------------
// MDependable_AC::DoUpdate: 
//----------------------------------------------------------------------------------------

void MDependable_AC::DoUpdate(	ChangeID_AC				theChange,
								MDependable_AC*			changedObject,
								void*					changeData,
								CDependencySpace_AC*	dependencySpace)
{
	#pragma unused (theChange, changedObject, changeData, dependencySpace)
}

//----------------------------------------------------------------------------------------
// MDependable_AC::GetDependencySpace: 
//----------------------------------------------------------------------------------------

CDependencySpace_AC* MDependable_AC::GetDependencySpace() const
{
	return CDependencySpace_AC::fgDefaultDependencySpace;
}

//----------------------------------------------------------------------------------------
// MDependable_AC::AddDependent: 
//----------------------------------------------------------------------------------------

void MDependable_AC::AddDependent(MDependable_AC* dependent)
// AddDependent is intended to register the specified object as a dependent 
// of this object, so that the specified object will be notified of any changes
// to this object. AddDependent stores the dependency relationship in the
// gMacAppDependencies dependency space.
// For example, MacApp calls AddDependent to register a subscriber to an edition 
// as a dependent of an edition document.
//
// dependent:	Specifies the object to be registered as a dependent of this 
// object.
//
// Call?		As needed.
// Override?	NEVER. It is not virtual.
{
	CDependencySpace_AC* itsDependencySpace = GetDependencySpace();
	if (itsDependencySpace)
		itsDependencySpace->AddDependency(this, dependent, kNoLabel_AC);
}

//----------------------------------------------------------------------------------------
// MDependable_AC::RemoveDependent: 
//----------------------------------------------------------------------------------------

void MDependable_AC::RemoveDependent(MDependable_AC* dependent)
{
	CDependencySpace_AC* itsDependencySpace = GetDependencySpace();
	if (itsDependencySpace)
		itsDependencySpace->RemoveDependency(this, dependent, kNoLabel_AC);
}

//----------------------------------------------------------------------------------------
// MDependable_AC::RemoveAllDependencies: 
//----------------------------------------------------------------------------------------

void MDependable_AC::RemoveAllDependencies()
{
	CDependencySpace_AC* itsDependencySpace = GetDependencySpace();
	if (itsDependencySpace)
		itsDependencySpace->RemoveDependencies(this);// Call the routine in UDependencies 
}

//----------------------------------------------------------------------------------------
// MDependable_AC::IsMarked: 
//----------------------------------------------------------------------------------------

bool MDependable_AC::IsMarked()
{
	return false;
}

//----------------------------------------------------------------------------------------
// MDependable_AC::SetMark: 
//----------------------------------------------------------------------------------------

void MDependable_AC::SetMark(bool state)
{
	#pragma unused (state)
}

//----------------------------------------------------------------------------------------
// End of UDependable.cp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		04/15/96	Removed MDependable_AC::RemoveDependenciesOnFree since we will soon
							stop mixing MDependent in at TObject and it will be unnecessary
		 4/15/96	Tax Day, split this file off separate from UObject
		----- R10 -----
*/