//----------------------------------------------------------------------------------------
// CDependencies_AC.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		04/07/01	[PB] Taking address of temporary. 
		01/02/01	Update copyright.
		11/10/00	Cosmetic.
		11/01/00	[PB] DonÕt include Packages.h. 
		08/31/00	Added embedded documentation.
		03/23/00	Cast to SDependency_AC* not const SDependency_AC* in TestDependency.
		09/09/99	Minor cosmetic work.
		03/24/99	Update copyright notice.
		10/06/98	Clean up includes. 
*/

#ifndef __CDependencies_AC__
#include "CDependencies_AC.h"
#endif

// ACS

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#ifndef __Debug_AC__
#include "Debug_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

//========================================================================================
// SDependency_AC::Compare
//========================================================================================

CompareResult_AC SDependency_AC::Compare(const SDependency_AC& criteria) const
{
	CompareResult_AC returnVal = kItemEqualCriteria_AC;

	if (fPrimaryObject > criteria.fPrimaryObject)
		returnVal = kItemGreaterThanCriteria_AC;
	else if (fPrimaryObject < criteria.fPrimaryObject)
		returnVal = kItemLessThanCriteria_AC;
	else
	{
		if (!fSecondaryObject || !criteria.fSecondaryObject || (fSecondaryObject == criteria.fSecondaryObject))
			returnVal = kItemEqualCriteria_AC;
		else if (fSecondaryObject < criteria.fSecondaryObject)
			returnVal = kItemLessThanCriteria_AC;
		else
			returnVal = kItemGreaterThanCriteria_AC;
	}

	return returnVal;
}

//========================================================================================
// GLOBAL Variables
//========================================================================================

#if !qMSWindows
	CAutoPtr_AC<CDependencySpace_AC> CDependencySpace_AC::fgDefaultDependencySpace;
#else
	CDependencySpace_AC* CDependencySpace_AC::fgDefaultDependencySpace;
#endif

//========================================================================================
// CLASS CNotificationQueue_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CNotificationQueue_AC destructor
//----------------------------------------------------------------------------------------

CNotificationQueue_AC::~CNotificationQueue_AC()
{
}

//----------------------------------------------------------------------------------------
// CNotificationQueue_AC::Dequeue: 
//----------------------------------------------------------------------------------------

bool CNotificationQueue_AC::Dequeue(SNotification_AC& item)
{
	bool available = (fSize > 0);
	if (available)
	{
		GetElementsAt(1, &item, 1);
		DeleteElementsAt(1, 1);
	}

	return available;
}

//========================================================================================
// CLASS CDependencies_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CDependencies_AC destructor
//----------------------------------------------------------------------------------------

CDependencies_AC::~CDependencies_AC()
{
}

//----------------------------------------------------------------------------------------
// CDependencies_AC::AddDependency: 
//----------------------------------------------------------------------------------------


void CDependencies_AC::AddDependency(MDependable_AC*		notifier,
									 MDependable_AC*		dependent,
									 DependencyLabels_AC	dependencyLabel)
{
	ArrayIndex_AC index;

	if (!FindDependency(notifier, dependent, dependencyLabel, index))
		InsertDependencyBefore(index, notifier, dependent, dependencyLabel);
}

//----------------------------------------------------------------------------------------
// CDependencies_AC::InsertDependencyBefore: 
//----------------------------------------------------------------------------------------

void CDependencies_AC::InsertDependencyBefore(ArrayIndex_AC			index,
											  MDependable_AC*		notifier,
											  MDependable_AC*		dependent,
											  DependencyLabels_AC	dependencyLabel)
{
	SDependency_AC record(notifier, dependent, dependencyLabel);
	InsertElementsBefore(index, &record, 1);
}


//----------------------------------------------------------------------------------------
// CDependencies_AC::FindDependency: 
//----------------------------------------------------------------------------------------

bool CDependencies_AC::FindDependency(MDependable_AC*		notifier,
									  MDependable_AC*		dependent,
									  DependencyLabels_AC	dependencyLabel,
									  ArrayIndex_AC&		index) const
{
	SDependency_AC record(notifier, dependent, dependencyLabel);
	return DoSearch(TestDependency, &record, index) != NULL;
}

//----------------------------------------------------------------------------------------
// CDependencies_AC::FindPrimaryObject: 
//----------------------------------------------------------------------------------------

bool CDependencies_AC::FindPrimaryObject(const MDependable_AC*	notifier,
										 ArrayIndex_AC&			index) const
{
	SDependency_AC record(notifier, NULL, kNoLabel_AC);
	return DoSearch(TestDependency, &record, index) != NULL;
}

//----------------------------------------------------------------------------------------
// CDependencies_AC::RemoveDependency: 
//----------------------------------------------------------------------------------------

void CDependencies_AC::RemoveDependency(MDependable_AC*		notifier,
										MDependable_AC*		dependent,
										DependencyLabels_AC	dependencyLabel)
{
	ArrayIndex_AC index;

	if (FindDependency(notifier, dependent, dependencyLabel, index))
		DeleteElementsAt(index, 1);
}

//----------------------------------------------------------------------------------------
// CDependencies_AC::Compare: 
//----------------------------------------------------------------------------------------

CompareResult_AC CDependencies_AC::Compare(const SDependency_AC& record1,
										   const SDependency_AC& record2) const

{
	return record2.Compare(record1);
}

//----------------------------------------------------------------------------------------
// CompareDependency_AC: 
//----------------------------------------------------------------------------------------

CompareResult_AC CDependencies_AC::TestDependency(const SDependency_AC&	anRecord,
												  void*					yourDataPtr)
{
	return anRecord.Compare(*static_cast<SDependency_AC*>(yourDataPtr));
}


//========================================================================================
// CLASS CDependencySpace_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CDependencySpace_AC destructor
//----------------------------------------------------------------------------------------

CDependencySpace_AC::~CDependencySpace_AC()
{
}

//----------------------------------------------------------------------------------------
// CDependencySpace_AC::AddDependency: 
//----------------------------------------------------------------------------------------

void CDependencySpace_AC::AddDependency(MDependable_AC*		notifier,
										MDependable_AC*		dependent,
										DependencyLabels_AC	dependencyLabel)
// AddDependency is intended to register an object as a dependent of another 
// object with the specified dependency label. CDependencySpace_AC::AddDependency must be 
// overridden to perform those functions.
//
// notifier:	Specifies a notifier object.
// dependent:	Specifies a dependent object.
// dependencyLabel:	Specifies the status of the relationship during the
//				notification process.
//
// Call?		As needed. However, you usually use MDependable::AddDependent 
//				to register the dependency.
// Override?	ALWAYS, if you are creating a subclass of TDependencySpace. 
//				Note that MacApp provides a TSimpleDependencySpace class that overrides this method.
{
	#pragma unused (notifier, dependent, dependencyLabel)
	SubClassResponsibility_AC();
}

//----------------------------------------------------------------------------------------
// CDependencySpace_AC::RemoveDependency: 
//----------------------------------------------------------------------------------------

void CDependencySpace_AC::RemoveDependency(	MDependable_AC*		notifier,
											MDependable_AC*		dependent,
											DependencyLabels_AC	dependencyLabel)
{
	#pragma unused (notifier, dependent, dependencyLabel)
	SubClassResponsibility_AC();
}

//----------------------------------------------------------------------------------------
// CDependencySpace_AC::NotifierChanged: 
//----------------------------------------------------------------------------------------

void CDependencySpace_AC::NotifierChanged(	MDependable_AC*	notifier,
											ChangeID_AC		theChange,
											void*			changeData)
{
	#pragma unused (notifier, theChange, changeData)
	SubClassResponsibility_AC();
}

//----------------------------------------------------------------------------------------
// CDependencySpace_AC::RemoveDependencies: 
//----------------------------------------------------------------------------------------

void CDependencySpace_AC::RemoveDependencies(MDependable_AC* anObject)
{
	#pragma unused (anObject)
	SubClassResponsibility_AC();
}


//========================================================================================
// CLASS CSimpleDependencySpace_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CSimpleDependencySpace_AC destructor: 
//----------------------------------------------------------------------------------------

CSimpleDependencySpace_AC::~CSimpleDependencySpace_AC()
{
}

//----------------------------------------------------------------------------------------
// CSimpleDependencySpace_AC::AddDependency: 
//----------------------------------------------------------------------------------------

void CSimpleDependencySpace_AC::AddDependency(MDependable_AC*		notifier,
											  MDependable_AC*		dependent,
											  DependencyLabels_AC	dependencyLabel)
{
	fDependents.AddDependency(notifier, dependent, dependencyLabel);
	fNotifiers.AddDependency(dependent, notifier, dependencyLabel);
}

//----------------------------------------------------------------------------------------
// CSimpleDependencySpace_AC::RemoveDependency: 
//----------------------------------------------------------------------------------------

void CSimpleDependencySpace_AC::RemoveDependency(MDependable_AC*		notifier,
												 MDependable_AC*		dependent,
												 DependencyLabels_AC	dependencyLabel)
{
	fDependents.RemoveDependency(notifier, dependent, dependencyLabel);
	fNotifiers.RemoveDependency(dependent, notifier, dependencyLabel);
}

//----------------------------------------------------------------------------------------
// CSimpleDependencySpace_AC::NotifierChanged: 
//----------------------------------------------------------------------------------------

void CSimpleDependencySpace_AC::NotifierChanged(MDependable_AC*	notifier,
												ChangeID_AC		theChange,
												void*			changeData)
{
	for (CDependentIterator iter(notifier, this); iter; ++iter)
		iter->DoUpdate(theChange, notifier, changeData, this);
}

//----------------------------------------------------------------------------------------
// CSimpleDependencySpace_AC::RemoveDependencies: 
//----------------------------------------------------------------------------------------

void CSimpleDependencySpace_AC::RemoveDependencies(MDependable_AC* anObject)
{
	{
		for (CDependentIterator iter(anObject, this); iter; ++iter)
		{
			fDependents.DeleteElementsAt(iter.CurrentIndex(), 1);
			fNotifiers.RemoveDependency(iter, anObject, kNoLabel_AC);
		}
	}
	{
		for (CNotifierIterator_AC iter(anObject, this); iter; ++iter)
		{
			fNotifiers.DeleteElementsAt(iter.CurrentIndex(), 1);
			fDependents.RemoveDependency(iter, anObject, kNoLabel_AC);
		}
	}
}

//========================================================================================
// CLASS CStandardDependencySpace_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC constructor
//----------------------------------------------------------------------------------------

CStandardDependencySpace_AC::CStandardDependencySpace_AC()
	:	fUpdating(false)
{
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC destructor
//----------------------------------------------------------------------------------------

CStandardDependencySpace_AC::~CStandardDependencySpace_AC()
{
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC::NotifierChanged: 
//----------------------------------------------------------------------------------------

void CStandardDependencySpace_AC::NotifierChanged(MDependable_AC*	notifier,
												  ChangeID_AC		theChange,
												  void*				changeData)
{
	if (fUpdating)
		fNestedUpdates.Queue(SNotification_AC(notifier, theChange, changeData));
	else
	{
		NotifyDependents(notifier, theChange, changeData);

		while (fNestedUpdates.GetSize() > 0)
		{
			SNotification_AC n;
			if (fNestedUpdates.Dequeue(n))
				NotifyDependents(n.fNotifier, n.fChange, n.fChangeData);
		}
	}
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC::NotifyDependents: 
//----------------------------------------------------------------------------------------

void CStandardDependencySpace_AC::NotifyDependents(MDependable_AC*	notifier,
												   ChangeID_AC		theChange,
												   void*			changeData)
{
	if (notifier && (theChange != kNoChange_AC))
	{
		fUpdating = true;
		MarkAllDependents(notifier, true);
		UpdateMarkedObjects(theChange, notifier, changeData);
		fUpdating = false;
	}
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC::MarkObject: 
//----------------------------------------------------------------------------------------

void CStandardDependencySpace_AC::MarkObject(MDependable_AC* anObject, bool state)
{
	if (anObject)
	{
		ArrayIndex_AC index;
		if (fNotifiers.FindPrimaryObject(anObject, index))
		{
			SDependency_AC& p = fNotifiers.At(index);
			if (state != (p.fLabel < 0))
				p.fLabel = -(p.fLabel);
		}
	}
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC::IsObjectMarked: 
//----------------------------------------------------------------------------------------

bool CStandardDependencySpace_AC::IsObjectMarked(MDependable_AC* anObject)
{
	bool returnVal = false;

	ArrayIndex_AC index;
	if (anObject && fNotifiers.FindPrimaryObject(anObject, index))
		returnVal = fNotifiers.At(index).fLabel < 0;

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC::MarkAllDependents: 
//----------------------------------------------------------------------------------------

void CStandardDependencySpace_AC::MarkAllDependents(MDependable_AC* notifier, bool state)
{
	if (notifier)
		for (CDependentIterator iter(notifier, this); iter; ++iter)
			if (state != IsObjectMarked(iter))
			{
				MarkObject(iter, state);
				MarkAllDependents(iter, state);
			}
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC::UpdateMarkedObjects: 
//----------------------------------------------------------------------------------------

void CStandardDependencySpace_AC::UpdateMarkedObjects(ChangeID_AC		theChange,
													  MDependable_AC*	changedObject,
													  void*				changeData)
{
	for (CDependencies_AC::Iterator iter(&fNotifiers); iter; ++iter)
		if ((*iter).fLabel < 0)
			HandleUpdate(const_cast<MDependable_AC*>((*iter).fPrimaryObject), theChange, changedObject, changeData);
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC::HandleUpdate: 
//----------------------------------------------------------------------------------------

void CStandardDependencySpace_AC::HandleUpdate(MDependable_AC*	anObject,
											   ChangeID_AC		theChange,
											   MDependable_AC*	changedObject,
											   void*			changeData)
{
	if (IsObjectMarked(anObject))
	{
		MarkObject(anObject, false);

		// ¥¥¥ This should be changed to iterate rather than recurse
		UpdateNotifiers(anObject, theChange, changedObject, changeData);

		anObject->DoUpdate(theChange, changedObject, changeData, this);
	}
}

//----------------------------------------------------------------------------------------
// CStandardDependencySpace_AC::UpdateNotifiers: 
//----------------------------------------------------------------------------------------

void CStandardDependencySpace_AC::UpdateNotifiers(MDependable_AC*	anObject,
												  ChangeID_AC		theChange,
												  MDependable_AC*	changedObject,
												  void*				changeData)
{
	for (CNotifierIterator_AC iter(anObject, this); iter; ++iter)
		HandleUpdate(iter, theChange, changedObject, changeData);
}

//========================================================================================
// CLASS CDependencyIterator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CDependencyIterator_AC::CDependencyIterator_AC: CDependentIterator
//----------------------------------------------------------------------------------------

CDependencyIterator_AC::CDependencyIterator_AC(const CDependencies_AC*	theArray,
											   const MDependable_AC*	theObject)
	:	CArrayIterator_AC(theArray, kIterateForward_AC),
		fObject(theObject)
// CDependencyIterator_AC is a constructor that initializes an instance for iteration 
// over dependencies.
//
// theArray:	specifies the instance of the depencency array over whose elements 
// 				you want to iterate.
// theObject:	specifies the notifier or dependent over which to iterate within 
// 				the array. This is the primary object, which also specifies the sort
//				order of the array. If the array specifies notifierÐdependent relationships,
// 				the primary object is a notifier. If the array specifies dependentÐnotifier
// 				relationships, the primary object is a dependent.
//
// TBehavior* operator++(int);
//
// Call?		Seldom. MacApp calls this method for you when it 
//				creates a CDependencyIterator_AC instance. If you subclass CDependencyIterator_AC,
// 				however, you must invoke this constructor from the subclass constructor.
// Override?	NEVER. It is a constructor.
{
	First();
}

//----------------------------------------------------------------------------------------
// CDependencyIterator_AC::First: 
//----------------------------------------------------------------------------------------

MDependable_AC* CDependencyIterator_AC::First()
{
	const CDependencies_AC* dependencies = dynamic_cast_or_throw_AC(const CDependencies_AC*,fDynamicArray);
	if (dependencies)
	{
		ArrayIndex_AC foundIndex;

		// Although the lists are ordered the search is a binary search and can return
		// a random entry from the set of matching entries.  First back up the the _real_
		// first matching entry and then we will march forward applying the DoToDependency

		if (dependencies->FindPrimaryObject(fObject, foundIndex))
		{
			{									// extra block to ensure iterators are destroyed in fifo order
				for (CArrayIterator_AC iter(dependencies, 1, foundIndex, kIterateBackward_AC); iter.Current(); ++iter)
				{
					if (dependencies->PrimaryObjectAt(iter.Current()) == fObject)
						foundIndex = iter.Current();
					else
						break;
				}
				fLowBound = foundIndex;
			}
		}
		else
			fLowBound = kEmptyIndex_AC;
	}

	return fCurrent = CArrayIterator_AC::First() ? dependencies->SecondaryObjectAt(CurrentIndex()) : NULL;
}

//----------------------------------------------------------------------------------------
// CDependencyIterator_AC::Next: 
//----------------------------------------------------------------------------------------

MDependable_AC* CDependencyIterator_AC::Next()
{
	const CDependencies_AC* dependencies = dynamic_cast_or_throw_AC(const CDependencies_AC*,fDynamicArray);
	return fCurrent = CArrayIterator_AC::Next() && (dependencies->PrimaryObjectAt(CurrentIndex()) == fObject) ? 
		dependencies->SecondaryObjectAt(CurrentIndex()) : NULL;
}

//========================================================================================
// CLASS CDependentIterator
//========================================================================================

//----------------------------------------------------------------------------------------
// CDependentIterator::CDependentIterator: 
//----------------------------------------------------------------------------------------

CDependentIterator::CDependentIterator(const MDependable_AC*		theObject,
									   CSimpleDependencySpace_AC*	dependencySpace)
	:	CDependencyIterator_AC(dependencySpace ? &dependencySpace->fDependents : NULL, theObject)
// CDependentIterator is a constructor that initializes an instance for iteration 
// over dependents.
//
// theObject:			specifies the object whose dependents should be iterated over.
// dependencySpace: 	specifies:	the dependency space over which to iterate to look  
// 						for dependents of theObject.
// 
// MDependable* operator++(int);
//
// Call?		Seldom. MacApp calls this method for you when it 
//				creates a CDependentIterator instance. If you subclass CDependentIterator,
// 				however, you must invoke this constructor from the subclass constructor.
// Override?	NEVER. It is a constructor.
{
}

//========================================================================================
// CLASS CNotifierIterator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CNotifierIterator_AC::CNotifierIterator_AC: 
//----------------------------------------------------------------------------------------

CNotifierIterator_AC::CNotifierIterator_AC(const MDependable_AC*		theObject,
										   CSimpleDependencySpace_AC*	dependencySpace)
	:	CDependencyIterator_AC(dependencySpace ? &dependencySpace->fNotifiers : NULL, theObject)
{
}

//----------------------------------------------------------------------------------------
// End of CDependencies_AC.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression portion of while loops
							so we just changed them all to for loops
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Update iterators to be OD stylish.
		04/18/96	More Use post-increment with iterators in while loops
		04/18/96	Use post-increment with iterators in while loops
		04/15/96	Use "while" style iteration
		04/15/96	Split MDependable_AC off from TObject 
		----- R10 -----
		03/27/96	Made several functions non-virtual inlines. 
		10/12/95	Add nested updates for standard dependency space. 
		----- 3.3b1 -----
		04/12/95	Use #if instead of if qDebug. 
	    04/12/95	Base class constructors called from mem initializers don't
		 					rely on default arguments.
		03/13/95	Change Free methods to destructors. 
		02/13/95	fgDefaultDependencySpace was declared extern in this file.
		02/13/95	Remove unnecessary initialization of static variables. See ARM ¤8.4 
		02/08/95	replace usage of staticLink with yourDataPtr. 
		02/07/95	Create missing prototypes for static functions used internally. 
*/