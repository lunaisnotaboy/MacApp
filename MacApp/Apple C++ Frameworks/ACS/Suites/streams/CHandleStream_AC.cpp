//----------------------------------------------------------------------------------------
// CHandleStream_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
// Originally written by Larry S. Rosenstein. Used by permission
//----------------------------------------------------------------------------------------

/*
	Change History
		02/09/01	Need to include tidy heap. 
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		03/24/99	Update copyright notice.
		10/26/98	Use LoadResource_AC and include ResourceUtils_AC.h.
*/

#ifndef __CHandleStream_AC__
#include "CHandleStream_AC.h"
#endif

// ACS

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#ifndef __ResourceUtils_AC__
#include "ResourceUtils_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

//========================================================================================
// CLASS CHandleStreamRep_AC
//========================================================================================

class CHandleStreamRep_AC : public CRandomAccessStreamRep_AC
{
public:
	CHandleStreamRep_AC(Handle itsHandle,  long growth);
	
	virtual ~CHandleStreamRep_AC();

	//------------------------------------------------------------------------------------
	// Subclass implementations 
	//------------------------------------------------------------------------------------
	virtual long GetPosition() const;

	virtual void SetPosition(long newPosition);

	virtual long GetSize() const;

	virtual void SetSize(long newSize);

	virtual void ReadBytes(void* p, long count); 

	virtual void WriteBytes(const void* p, long count); 

	Handle GetHandle() const
	{	return fHandle; }
	
	void SetHandle(Handle itsHandle)
	{	fHandle = itsHandle; }

	//------------------------------------------------------------------------------------
	// Growing 
	//------------------------------------------------------------------------------------
	virtual long GrowthSize(long needed);
		// Returns amount to grow by, given that we need 'needed' bytes.Default is to grow
        // by Max(fGrowth, needed). 

	//------------------------------------------------------------------------------------
	// data members
	//------------------------------------------------------------------------------------
public:
	Handle	fHandle;		// The handle associated with this stream.
	long	fPosition;		// Current position in the stream.
	long	fSize;			// The size of the stream. Note that this value may be smaller
							// than the size of the handle itself. 
	long	fGrowthSize;	// Default growth increment for the handle.
	char	fSavedState;	// The flags of the master pointer associated with this handle.
};



//========================================================================================
// CLASS CHandleStreamRep_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::CHandleStreamRep_AC: 
//----------------------------------------------------------------------------------------

CHandleStreamRep_AC::CHandleStreamRep_AC(Handle itsHandle,
								  long growth) :
	fHandle(itsHandle),
	fPosition(0),
	fSize(0),
	fGrowthSize(growth),
	fSavedState(0)
{
	if (itsHandle)
	{
		if (IsAResource_AC(itsHandle))
		{
			::LoadResource_AC(itsHandle);		// ensure it's loaded in memory
			::ThrowIfResError_AC();

		}
		fSize = ::GetHandleSize(itsHandle);
		fSavedState = ::HGetState(itsHandle);
		::HNoPurge(itsHandle);					// ensure it's not purgeable
		fHandle = itsHandle;
	}
}

//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::Free: 
//----------------------------------------------------------------------------------------

CHandleStreamRep_AC::~CHandleStreamRep_AC()
{
	if (fHandle)
	{
		SetSize(GetPosition());					// Trim the handle to its current position. 
		::HSetState(fHandle, fSavedState);
	}
}

//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::GetPosition: 
//----------------------------------------------------------------------------------------

long CHandleStreamRep_AC::GetPosition() const				// override 
{
	return fPosition;
}

//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::GetSize: 
//----------------------------------------------------------------------------------------

long CHandleStreamRep_AC::GetSize() const					// override 
{
	return fSize;
}

//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::GrowthSize: 
//----------------------------------------------------------------------------------------

long CHandleStreamRep_AC::GrowthSize(long needed)
{
	return Max_AC(fGrowthSize, needed);
}


//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::SetPosition: 
//----------------------------------------------------------------------------------------

void CHandleStreamRep_AC::SetPosition(long newPosition )// override 
{
	OSErr err = noErr;

	if (newPosition < 0)						// Same error returned by File Manager. 
		::ThrowIfOSErr_AC(posErr);
	else if (newPosition > fSize)				// Hit the end of the stream. 
	{
		newPosition = fSize;					// We still want to position to end of the stream.
		err = eofErr;
	}

	fPosition = newPosition;
	::ThrowIfOSErr_AC(err);
}

//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::SetSize: 
//----------------------------------------------------------------------------------------

void CHandleStreamRep_AC::SetSize(long newSize)		// override 
{
	SetPermHandleSize_AC(fHandle, newSize);

	if (newSize < fPosition)					// If we shrunk the size, then adjust position and size
		fPosition = newSize;

	fSize = newSize;
}

//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::ReadBytes: 
//----------------------------------------------------------------------------------------

void CHandleStreamRep_AC::ReadBytes(void* p,
							  long count)		// override 
{
	OSErr err = noErr;

	register long available = fSize - fPosition;// Bytes available in the stream. 

	if (available < count)						// About to read past end of stream. 
	{
		count = available;
		err = eofErr;
	}

	if (count > 0)								// Move the bytes. 
	{
		BlockMove_AC(*fHandle + fPosition, p, count);
		fPosition += count;
	}
	else if (count < 0)
		err = paramErr;							// Negative request count. 

	::ThrowIfOSErr_AC(err);
}

//----------------------------------------------------------------------------------------
// CHandleStreamRep_AC::WriteBytes: 
//----------------------------------------------------------------------------------------

void CHandleStreamRep_AC::WriteBytes(const void* p,
							   long count)		// override 
{
	if (count < 0)
		::ThrowIfOSErr_AC(paramErr);					// Negtive request count. 

	long available = fSize - fPosition;			// Bytes available in the stream. 

	if (available < count)						// Grow the handle to accommodate request. 
	{
		// code as 2 statements to avoid interference of memory move in call to GrowthSize
		long itsGrowthSize = GrowthSize(count - available);
		SetSize(fSize + itsGrowthSize);
	}

	BlockMove_AC(p, *fHandle + fPosition, count);// Move the bytes. 

	fPosition += count;							// Advance the position. 

	if (fPosition > fSize)						// Adjust the size if necessary. 
		fSize = fPosition;
}

//========================================================================================
// CLASS CHandletream_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CHandleStream_AC::CHandleStream_AC
//----------------------------------------------------------------------------------------

CHandleStream_AC::CHandleStream_AC(Handle itsHandle,  long growth)
	: CRandomAccessStream_AC(TH_new CHandleStreamRep_AC(itsHandle, growth))
{
}

//----------------------------------------------------------------------------------------
// CHandleStream_AC::~CHandleStream_AC
//----------------------------------------------------------------------------------------

CHandleStream_AC::~CHandleStream_AC()
{
}

//----------------------------------------------------------------------------------------
// CHandleStream_AC::SetHandle
//----------------------------------------------------------------------------------------

void CHandleStream_AC::SetHandle(Handle itsHandle)
{
	dynamic_cast_or_throw_AC(CHandleStreamRep_AC*,GetStreamRep())->SetHandle(itsHandle);
}

//----------------------------------------------------------------------------------------
// CHandleStream_AC::GetHandle
//----------------------------------------------------------------------------------------

Handle CHandleStream_AC::GetHandle()
{
	return dynamic_cast_or_throw_AC(CHandleStreamRep_AC*,GetStreamRep())->GetHandle();
}

//----------------------------------------------------------------------------------------
// CHandleStream_AC::GrowthSize
//----------------------------------------------------------------------------------------

long CHandleStream_AC::GrowthSize(long needed)
{
	return dynamic_cast_or_throw_AC(CHandleStreamRep_AC*,GetStreamRep())->GrowthSize(needed);
}


//----------------------------------------------------------------------------------------
// End of CHandleStream_AC.cpp

/*
	Historical Change Record:
		----- R13 -----
		07/16/97	Tidied up.
		07/09/97	Use SetPermHandleSize_AC, it now works.
		06/09/97	Use dynamic_cast_AC where appropriate.
		05/19/97	Add CStreamRep_AC to streams abstraction.
		04/19/97	Even if we don't have setpermhandlesize avail here yet,
							we still need to set the handle size.
		04/18/97	Changes to streaming.
		04/14/97	Update for real xxx_cast operators.
		03/37/97	Broke out from CStream_AC
*/