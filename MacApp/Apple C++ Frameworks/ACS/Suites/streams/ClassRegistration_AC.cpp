//----------------------------------------------------------------------------------------
// ClassRegistration_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/19/01	Do not throw exception in NewByClassID, NewByClassName or
					NewBySignature.  Take address of signature in GetClassDescFromSignature
					for printing a trouble message.
		05/19/01	RegisterSignature wasn't replacing old signatures. 
		05/11/01	Added a debug check in GetClassDescFromClassName and
					GetClassDescFromSignature.  RegisterClass_AC now also registers
					the compiler's version (typeid) of the class' name (so its
					interface has changed).  Added pRegisteredNamesCrossRef to hold
					this cross reference.  NewByClassDesc has now been reenabled for
					other compilers.  Added GetClassNameFromTypeID and GetClassDescFromTypeID.
		02/15/01	Need to include CAssertionFailure_AC. 
		02/08/00	Use standard C++ library containers. 
		01/02/01	Update copyright.
		11/27/00	Add a way to reserve array space for the registered classes
					and signatures. Add a debug usage count and a utility for
					reporting unused classes. 
		11/09/00	[PB] Suppress unused variable warning. 
		11/09/00	[PB] Don’t test class name in NewByClassDesc.
		09/20/00	[W] Don’t test class name in NewByClassDesc for VC++.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		03/23/00	Use EXPORT_CLASS_AC instead of EXPORT_AC.
		03/15/00	[2444988] CClassRegistration is now reentrant. 
		12/07/99	Removed specialization for compiler in NewByClassDesc.
		11/04/99	Fix up RegisterClass_AC method by having it call the correct module.
		03/24/99	Update copyright notice.
		03/19/99	Rename RegisterClass to RegisterClass_AC since it conflicted
					with a define in Windows.
		10/15/98	[2279094] Use kNoIdentifier_AC instead of NULL in GetSignatureFromClassName.
		10/06/98	Clean up includes. 
*/

#ifndef __ClassRegistration_AC__
#include "ClassRegistration_AC.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __MStreamable_AC__
#include "MStreamable_AC.h"
#endif

#ifndef __Types_AC__
#include "Types_AC.h"
#endif

// ANSI

#ifndef _CTYPE_H
#include <ctype.h>
#endif

#ifndef _MAP
#include <map>
#endif

#ifndef _STRING_H
#include <string.h>
#endif

#ifndef _VECTOR
#include <vector>
#endif

using std::map;
using std::pair;
using std::toupper;
using std::vector;
using std::strcmp;

//========================================================================================
// CCaseInsensitiveStringCompare_AC
//========================================================================================

struct CCaseInsensitiveStringCompare_AC : std::binary_function<const char*, const char*, bool>
{
	result_type operator()(const first_argument_type& x, const second_argument_type& y) const
	{
		return relstrcmp(x, y) < 0;
	}

	static int relstrcmp(const char* s1, const char* s2);
};

//----------------------------------------------------------------------------------------
// relstrcmp
//----------------------------------------------------------------------------------------

int CCaseInsensitiveStringCompare_AC::relstrcmp(const char* s1, const char* s2)
{
	int d;
	while (!(d = toupper(*s1) - toupper(*s2)) && *s1 && *s2)
	{
		++s1;
		++s2;
	}
	return d;
}

//========================================================================================
// CRegisteredClasses_AC
//========================================================================================

template class vector<CClassRegistration_AC>;
typedef vector<CClassRegistration_AC>	CRegisteredClasses_AC;

//========================================================================================
// CRegisteredNames_AC
//========================================================================================

template class map<const char*, ClassID_AC, CCaseInsensitiveStringCompare_AC>;
typedef map<const char*, ClassID_AC, CCaseInsensitiveStringCompare_AC>	CRegisteredNames_AC;

//========================================================================================
// CRegisteredSignatures_AC
//========================================================================================

template class map<IDType, ClassID_AC>;
typedef map<IDType, ClassID_AC>	CRegisteredSignatures_AC;

//========================================================================================
// CRegisteredNamesCrossRef_AC
//========================================================================================

template class map<const char*, const char*, CCaseInsensitiveStringCompare_AC>;
typedef map<const char*, const char*, CCaseInsensitiveStringCompare_AC>	CRegisteredNamesCrossRef_AC;

// The CRegisteredNamesCrossRef_AC has been added because various compilers can return different
// names for each class--it may not necessarily be the literal class name.  For example, you
// may register TAdorner and then expect a call to 'typeid(TAdorner).name()' to return a
// 'TAdorner'.  Beware, though, because this call in VC++ returns 'class TAdorner' and gcc
// returns the class name prepended with a number such as '41TAdorner'.  This table will
// provide the runtime matching between the compiler's version of the class name and what
// the framework thinks it ought to be.

//========================================================================================
// GLOBALS
//========================================================================================

CRegisteredClasses_AC		pRegisteredClasses;
CRegisteredNames_AC			pRegisteredNames;
CRegisteredSignatures_AC	pRegisteredSignatures;
CRegisteredNamesCrossRef_AC	pRegisteredNamesCrossRef;

//----------------------------------------------------------------------------------------
// NewObjectBySignature: 
//----------------------------------------------------------------------------------------

MStreamable_AC* NewObjectBySignature_AC(IDType signature,
										const char* className)
{
	return *className
			 ? CClassRegistration_AC::NewByClassName(className)
			 : CClassRegistration_AC::NewBySignature(signature);
}

//========================================================================================
// CClassRegistration_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// GetClassDescFromClassID:
//----------------------------------------------------------------------------------------

CClassRegistration_AC* CClassRegistration_AC::GetClassDescFromClassID(const ClassID_AC classID)
{
	return &pRegisteredClasses[classID - 1];
}

//----------------------------------------------------------------------------------------
// GetClassDescFromClassName:
//----------------------------------------------------------------------------------------

CClassRegistration_AC* CClassRegistration_AC::GetClassDescFromClassName(const char* className)
{
	CClassRegistration_AC* classDesc = NULL;
	CRegisteredNames_AC::const_iterator iter = pRegisteredNames.find(className);
	if (iter != pRegisteredNames.end())
		classDesc = GetClassDescFromClassID(iter->second);
#if qDebug
	else
		::ProgramBreak_AC("CClassRegistration_AC::GetClassDescFromClassName: "
						  "Class '%s' not found.\n", (char*)className);
#endif

	return classDesc;
}

//----------------------------------------------------------------------------------------
// GetClassDescFromTypeID:
//----------------------------------------------------------------------------------------

CClassRegistration_AC* CClassRegistration_AC::GetClassDescFromTypeID(const MStreamable_AC& inClass)
// GetClassDescFromCompilerName will determine the 'real' class name and then retrieve the
// class registration information record for that class.
//
// className:	A const char* pointing to the compiler's version of the class name.
//
// Call?		As needed.
{
	CClassRegistration_AC*	classDesc = NULL;
	const char*				className = GetClassNameFromTypeID(inClass);
	if (className != NULL)
		classDesc = GetClassDescFromClassName(className);

	return classDesc;
}

//----------------------------------------------------------------------------------------
// GetClassDescFromSignature:
//----------------------------------------------------------------------------------------

CClassRegistration_AC* CClassRegistration_AC::GetClassDescFromSignature(IDType signature)
{
	CClassRegistration_AC* classDesc = NULL;
	CRegisteredSignatures_AC::const_iterator iter = pRegisteredSignatures.find(signature);
	if (iter != pRegisteredSignatures.end())
		classDesc = GetClassDescFromClassID(iter->second);
#if qDebug
	else
		::ProgramBreak_AC("CClassRegistration_AC::GetClassDescFromSignature: "
						  "Signature '%4s' not found.\n", (char*)&signature);
#endif

	return classDesc;
}

//----------------------------------------------------------------------------------------
// GetSignatureFromClassName:
//----------------------------------------------------------------------------------------

IDType CClassRegistration_AC::GetSignatureFromClassName(const char* className)
{
	IDType returnVal = kNoIdentifier_AC;

	// Look up the name in the map because it's faster
	const CClassRegistration_AC* classDesc = GetClassDescFromClassName(className);
	if (classDesc)
	{
		// Now we just have to find a signature record with the same class ID
		ClassID_AC classID = classDesc->GetClassID();

		for (CRegisteredSignatures_AC::const_iterator iter = pRegisteredSignatures.begin();
			 iter != pRegisteredSignatures.end();
			 ++iter)
		{
			if (iter->second == classID)
			{
				returnVal = iter->first;
				break;
			}
		}
	}
	
	return returnVal;
}

//----------------------------------------------------------------------------------------
// GetClassNameFromTypeID:
//----------------------------------------------------------------------------------------

const char* CClassRegistration_AC::GetClassNameFromTypeID(const MStreamable_AC& inData)
// GetClassNameFromTypeID will look up the compiler's name for the given class and
// return a pointer to the real class name, if found.
{
	const char*		typeIDName = typeid(inData).name();
	const char*		realName = NULL;
	if (pRegisteredNamesCrossRef.find(typeIDName) != pRegisteredNamesCrossRef.end())
		realName = pRegisteredNamesCrossRef[typeIDName];

	return realName;
}

//----------------------------------------------------------------------------------------
// NewByClassDesc
//----------------------------------------------------------------------------------------

#if qDebug
MStreamable_AC* CClassRegistration_AC::NewByClassDesc(CClassRegistration_AC* inClassDesc)
{	
	// Find the name before creating the object. The object's constructor could
	// register more classes, moving the data under the classdesc pointer. 
	const char* typeName = inClassDesc->GetName();

	MStreamable_AC* obj = inClassDesc->Call_DefaultConstructor();
	if (obj)
	{
		const char*		className = GetClassNameFromTypeID(*obj);
		
		if (className == NULL || strcmp(className, typeName) != 0)
			ProgramBreak_AC("CClassRegistration_AC::NewByClassDesc: Object created not of class expected.\n"
							"Expected ‘%s’ but got ‘%s’.\n", typeName, className);
	}
	return(obj);
}
#endif

//----------------------------------------------------------------------------------------
// NewByClassID:
//----------------------------------------------------------------------------------------

MStreamable_AC* CClassRegistration_AC::NewByClassID(const ClassID_AC classID)
{
	MStreamable_AC* returnVal = NULL;

	CClassRegistration_AC* classDesc = CClassRegistration_AC::GetClassDescFromClassID(classID);

	if (classDesc)
		returnVal = NewByClassDesc(classDesc);
	else
	{
#if qDebugMsg
#if defined(__SC__)  || defined(__MRC__)
		::ProgramBreak_AC("The application doesn't contain the class with class ID " + CStr255_AC(static_cast<unsigned long>(classID)) + ".");
#else
		::ProgramBreak_AC(CChar255_AC("The application doesn't contain the class with class ID " + CStr255_AC(static_cast<unsigned long>(classID)) + "."));
#endif
#endif
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// NewByClassName:
//----------------------------------------------------------------------------------------

MStreamable_AC* CClassRegistration_AC::NewByClassName(const char* className)
{
	MStreamable_AC* returnVal = NULL;

	CClassRegistration_AC* classDesc = CClassRegistration_AC::GetClassDescFromClassName(className);

	if (classDesc)
		returnVal = NewByClassDesc(classDesc);
	else
	{
#if qDebugMsg
#if defined(__SC__)  || defined(__MRC__)
		::ProgramBreak_AC("The application doesn't contain the class " + CStr255_AC(className) + ".");
#else
		::ProgramBreak_AC(CChar255_AC("The application doesn't contain the class " + CStr255_AC(className) + "."));
#endif
#endif
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// NewBySignature:
//----------------------------------------------------------------------------------------

MStreamable_AC* CClassRegistration_AC::NewBySignature(IDType signature)
{
	MStreamable_AC* returnVal = NULL;

	CClassRegistration_AC* classDesc = CClassRegistration_AC::GetClassDescFromSignature(signature);

	if (classDesc)
		returnVal = NewByClassDesc(classDesc);
	else
	{
#if qDebugMsg
		ProgramReport_AC("signature='%4s'\n", &signature);
		::ProgramBreak_AC("Unable to find class for the given signature");
#endif
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CClassRegistration_AC:
//----------------------------------------------------------------------------------------

CClassRegistration_AC::CClassRegistration_AC(const char* inTypeName,
											 ConstructorProcPtr_AC constructor,
											 ClassID_AC inClassID)
	:	fTypeName(inTypeName),
		fDefaultConstructor(constructor),
		fClassID(inClassID)
#if qDebug
		, fUsed(0)
#endif
{
}

#if qDebug

//----------------------------------------------------------------------------------------
// Call_DefaultConstructor:
//----------------------------------------------------------------------------------------

MStreamable_AC* CClassRegistration_AC::Call_DefaultConstructor()
{
	++fUsed;
	return fDefaultConstructor();
}
#endif

//----------------------------------------------------------------------------------------
// CompareName:
//----------------------------------------------------------------------------------------

CompareResult_AC CClassRegistration_AC::CompareName(const CClassRegistration_AC& criteria) const
{
//	// Classnames are not international strings!
//	return ::RelString(CStr255_AC(criteria.GetName()), CStr255_AC(GetName()), false, true);
	int c = CCaseInsensitiveStringCompare_AC::relstrcmp(criteria.fTypeName, fTypeName);
	CompareResult_AC result;
	if (c == 0)
		result = 0; // kItemEqualCriteria_AC;
	else if (c < 0)
		result = -1; // kItemGreaterThanCriteria_AC
	else
		result = 1; // kItemLessThanCriteria_AC;

	return result;
}

//----------------------------------------------------------------------------------------
// RegisterClass_AC:
//----------------------------------------------------------------------------------------

void CClassRegistration_AC::RegisterClass_AC(const char* inTypeName,
											 ConstructorProcPtr_AC constructor,
											 const char* inTypeIDName)
// RegisterClass_AC will create an class registration entry and add it to the class
// registration table, if it has not already been registered.
//
// inTypeName:		A const char* pointing to the 'real' class name from the framework's
//					point-of-view.  In other words, TAdorner will come out as 'TAdorner'.
// constructor:		A function pointer to the default constructor for the class being
//					registered.
// inTypeIDName:	A const char* pointing to the class name from the compiler's 
//					point-of-view.  This can be different for each compiler and is
//					determined at run-time in the call to this function.  The recommended
//					argument for this parameter is 'typeid(argument).name()'.
//
// Call?		Never.  Instead, use the REGISTER_CLASS_AC or REGISTER_SIGNATURE_AC macros
//				since they will do the right thing.
{
	if (pRegisteredNames.find(inTypeName) == pRegisteredNames.end())
	{
		// Add a CClassRegistration_AC for this class to the class registration table.
		ClassID_AC classID = pRegisteredClasses.size() + 1;
		CClassRegistration_AC record(inTypeName, constructor, classID);
		pRegisteredClasses.push_back(record);
		pRegisteredNames.insert(CRegisteredNames_AC::value_type(inTypeName, classID));
		
		// Add a cross-reference entry for this class into the compiler's class name registry.
		if (pRegisteredNamesCrossRef.find(inTypeIDName) == pRegisteredNamesCrossRef.end())
			pRegisteredNamesCrossRef[inTypeIDName] = inTypeName;
#if qDebug
		else
			ProgramReport_AC("CClassRegistration_AC::RegisterClass_AC: Class typeid.name ‘%s’ has already been registered\n",
							 inTypeIDName);
#endif
	}
#if 0 // qDebugMsg
	// •••  This would be nice to include but gIntenseDebugging is defined in MacApp, not ACS.
	else if (gIntenseDebugging)
		ProgramReport_AC("CClassRegistration_AC::RegisterClass_AC: Class ‘%s’ has already been registered\n",
						 inTypeName);
#endif
}

//----------------------------------------------------------------------------------------
// RegisterSignature:
//----------------------------------------------------------------------------------------

void CClassRegistration_AC::RegisterSignature(const char* inTypeName, IDType signature)
// Replace or add signature as necessary. 
{
#if 0 // qDebugMsg
	// •••  This would be nice to include but gIntenseDebugging is defined in MacApp, not ACS.
	if (gIntenseDebugging)
	{
		if (pRegisteredSignatures.find(signature) != pRegisteredSignatures.end())
		{
			ProgramReport_AC("CClassRegistration_AC::RegisterSignature: Signature ‘%s’ has already been registered\n",
							 (char*)&signature);
		}
	}
#endif

	const CClassRegistration_AC* classDesc = GetClassDescFromClassName(inTypeName);
	Assertion_AC(classDesc, ""); // class should already be registered
	pRegisteredSignatures[signature] = classDesc->GetClassID();
}

//----------------------------------------------------------------------------------------
// ReserveClassSpace:
//----------------------------------------------------------------------------------------

void CClassRegistration_AC::ReserveClassSpace(unsigned long classes)
// Reserve space for the specified number of classes to be registered. This is for
// performance optimization. It is okay if the number is not exactly right, because
// the array will allocate more space as needed. To determine the number of classes, 
// examine pRegisteredClasses.fSize at the end of your application's main function. 
// Subtract classes that are used only for debugging.  Then add a call at the 
// beginning of your main function, to reserve that much space. 
{
	pRegisteredClasses.resize(classes);
}

//----------------------------------------------------------------------------------------
// ReserveSignatureSpace:
//----------------------------------------------------------------------------------------

void CClassRegistration_AC::ReserveSignatureSpace(unsigned long signatures)
// Reserve space for the specified number of signatures to be registered. This is for
// performance optimization. It is okay if the number is not exactly right, because
// the array will allocate more space as needed. To determine the number of signatures, 
// examine pRegisteredSignatures.fSize at the end of your application's main function. 
// Subtract classes that are used only for debugging. Then add a call at the beginning 
// of your main function, to reserve that much space. 
{
//	pRegisteredSignatures.SetArraySize(signatures);
//	pRegisteredSignatures.resize(signatures);
#pragma unused (signatures)
	// Now that we're using map, there's no way to preallocate space in the tree. 
}

#if qDebug
//----------------------------------------------------------------------------------------
// ReportUnusedClasses:
//----------------------------------------------------------------------------------------

void CClassRegistration_AC::ReportUnusedClasses()
// Prints a list of registered classes that have not been used. Call this from the end
// of your application's main function. The call should be conditionalized by qDebug. 
// This function cannot determine if a class will never be used in your application, 
// only that it hasn't been used in the current run. Before removing any classes, it's a
// good idea to DeView your application resources and check if the class is needed by
// a view that hasn't been exercised. 
{
	for (CRegisteredClasses_AC::const_iterator iter = pRegisteredClasses.begin();
		 iter != pRegisteredClasses.end();
		 ++iter)
	{
		if ((*iter).fUsed == 0)
			::ProgramReport_AC("registration not used for class %s\n", (*iter).GetName());
	}
}
#endif

//----------------------------------------------------------------------------------------
// End of ClassRegistration_AC.cpp

/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/19/96	SCpp and MrCpp can't handle declarations in the expression 
							portion of while loops so we just changed them all to for loops
		06/09/96	Removed UStreamable to a separate file from UObject
		04/25/96	More use of CTempxxx classes instead of Failure handling where poss.
		04/24/96	Use PRE-Increment/Decrement operators whenever possible for eff.
		04/18/96	More Use post-increment with iterators in while loops
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/31/96	Don't use ordered insertion to build the byName and byID dynamicArrays.
		 					Use unordered insertion and then sort when done.
		03/27/96	Made several functions non-virtual inline.
		03/26/96	coerce CStrxxx_AC to const char* to get copies of the strings as 
							c style strings
		03/14/96	Replaced curly quotes with straight single quote.
		12/19/95	1222953 (Optionally) Used new/delete for TDynamicarray store. 
							Removed Lock method.
		11/28/95	Move to MacApp core library. 
		----- 3.3 -----
		09/19/95	Split off Jasik's The Debugger support to its own unit. 
		----- 3.3b1 -----
		06/29/95	It is not an error if we can't dynamic cast an object. 
		04/06/95	Don't lock the byName or byID lists when inserting! 
		04/04/95	Update support for The Debugger. 
		03/17/95	MAVolatile. 
		03/13/95	Change Free methods to destructors. 
		03/09/95	Add support for side-casting. Changed NewByXXX functions
		  					to return a void* instead of a TObject*. 
		03/01/95	Add debug and failure code to Call_DefaultConstructor. 
		03/01/95	Add CallRegisterClass and CallRegisterSignature so we break
		  					const-ness only in two places instead of wherever the register
							macro is invoked (many warnings). 
		02/28/95	Add RegisterClass. ClassDesc constructor no longer has a 
							default constructor parameter. Add signature list, 
							NewBySignature, GetClassDescFromSignature, GetSignature, 
							RegisterSignature, MA_REGISTER_SIGNATURE. 
							Remove gDontDeadStrip. 
		02/27/95	Add SideCast. Change DescendsFrom to check immediate ancestors
							first, in the hope of avoiding a few function calls. 
		02/27/95	Add ClassDescInheritanceCheck. 
		02/24/95	Merge AssignNewClassID into constructor. 
		02/22/95	Change to use OPF style RTTI. Remove subclass list. 
		02/13/95	Remove unnecessary initialization of static variables. See ARM §8.4 
		02/08/95	replace usage of staticLink with yourDataPtr. 
		07/12/94	Redo some of the changes in <2> for compatibility
							with Symantec. 
		07/06/94	Get rid of implicit pointer conversion warnings
							in CodeWarrior. 
		06/30/94	Return NULL from Call_DefaultConstructor if the
							constructor is nil. 
*/