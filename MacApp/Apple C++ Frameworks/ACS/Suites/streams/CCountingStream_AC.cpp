//----------------------------------------------------------------------------------------
// CCountingStream_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
// Originally written by Larry S. Rosenstein. Used by permission
//----------------------------------------------------------------------------------------

/*
	Change History
		02/09/01	Need to include tidy heap. 
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		03/24/99	Update copyright notice.
*/


#ifndef __CCountingStream_AC__
#include "CCountingStream_AC.h"
#endif

// ACS

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

//========================================================================================
// CLASS CCountingStreamRep_AC
//========================================================================================

class CCountingStreamRep_AC : public CRandomAccessStreamRep_AC
{
public:
	CCountingStreamRep_AC();

	virtual ~CCountingStreamRep_AC();

	//------------------------------------------------------------------------------------
	// Subclass implementations 
	//------------------------------------------------------------------------------------

	virtual long GetPosition() const;
	virtual void SetPosition(long newPosition);
	virtual long GetSize() const;
	virtual void SetSize(long newSize);

	virtual void WriteBytes(const void* p, long count);

	//------------------------------------------------------------------------------------
	// data members
	//------------------------------------------------------------------------------------

protected:
	virtual void ReadBytes(void*, long);

public:

	long	fPosition;		// The current position in the stream.
	long	fSize;			// The current size of the stream, in bytes.
};

//========================================================================================
// CLASS CCountingStream_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CCountingStream_AC constructor
//----------------------------------------------------------------------------------------

CCountingStreamRep_AC::CCountingStreamRep_AC() :
	fPosition(0),
	fSize(0)
{
}

//----------------------------------------------------------------------------------------
// CCountingStreamRep_AC destructor
//----------------------------------------------------------------------------------------

CCountingStreamRep_AC::~CCountingStreamRep_AC()
{
}

//----------------------------------------------------------------------------------------
// CCountingStreamRep_AC::GetPosition: 
//----------------------------------------------------------------------------------------

long CCountingStreamRep_AC::GetPosition() const				// override 
{
	return fPosition;
}

//----------------------------------------------------------------------------------------
// CCountingStreamRep_AC::SetPosition: 
//----------------------------------------------------------------------------------------

void CCountingStreamRep_AC::SetPosition(long newPosition )// Override
{
	OSErr err = noErr;

	if (newPosition < 0)						// Same error returned by File Manager. 
		::ThrowIfOSErr_AC(posErr);
	else if (newPosition > fSize)				// Hit the end of the stream. 
	{
		newPosition = fSize;					// We still want to position to end of the stream. 
		err = eofErr;
	}

	fPosition = newPosition;
	::ThrowIfOSErr_AC(err);
}

//----------------------------------------------------------------------------------------
// CCountingStreamRep_AC::GetSize: 
//----------------------------------------------------------------------------------------

long CCountingStreamRep_AC::GetSize() const					// override 
{
	return fSize;
}

//----------------------------------------------------------------------------------------
// CCountingStreamRep_AC::SetSize: 
//----------------------------------------------------------------------------------------

void CCountingStreamRep_AC::SetSize(long newSize)		// Override
{
	if (newSize < fPosition)					// If we shrunk the size, then we have to adjust the position. 
		fPosition = newSize;
	fSize = newSize;
}

//----------------------------------------------------------------------------------------
// CCountingStreamRep_AC::WriteBytes: 
//----------------------------------------------------------------------------------------

void CCountingStreamRep_AC::WriteBytes(const void*	/* p */ ,
								 long count)	// override 
{
	if (count < 0)								// Can't write negative number of bytes. 
		::ThrowIfOSErr_AC(paramErr);

	fPosition += count;							// Advance the position. 

	if (fPosition > fSize)						// Adjust the size if necessary. 
		fSize = fPosition;
}

//----------------------------------------------------------------------------------------
// CCountingStreamRep_AC::ReadBytes: 
//----------------------------------------------------------------------------------------

void CCountingStreamRep_AC::ReadBytes(void*, long)
{
}

//========================================================================================
// CLASS CCountingStream_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CCountingStream_AC constructor
//----------------------------------------------------------------------------------------

CCountingStream_AC::CCountingStream_AC()
	: CRandomAccessStream_AC(TH_new CCountingStreamRep_AC)
{
}

//----------------------------------------------------------------------------------------
// CCountingStream_AC destructor
//----------------------------------------------------------------------------------------

CCountingStream_AC::~CCountingStream_AC()
{
}


/*
	Historical Change Record:
		----- R13 -----
		07/16/97	Tidied up.
		06/22/97	Removed segmentation directives that I missed before. (doh!)
		05/19/97	Add CStreamRep_AC to streams abstraction.
		05/05/97	Changes for new streaming.
		04/18/97	Changes to streaming.
		04/14/97	Update for real xxx_cast operators.
		03/37/97	Broke out from CStream_AC
*/