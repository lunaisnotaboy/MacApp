//----------------------------------------------------------------------------------------
// CSIOUXTraceStream_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		02/09/01	Need to include tidy heap. 
		01/02/01	Update copyright.
		10/18/00	SIOUX is Metrowerks only. 
		07/31/00	[W] Don't include SIOUX.h.
		07/24/00	CW Pro 6: namespacing. 
		12/07/99	Corrected file name in banner.
		03/24/99	Update copyright notice.
*/


#ifndef __CSIOUXTraceStream_AC__
#include "CSIOUXTraceStream_AC.h"
#endif

#if qTrace_AC

// ACS

#ifndef __CBufferedStreamRep_AC__
#include "CBufferedStreamRep_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

// ANSI

#ifndef __cstdio__
#include <stdio.h>
#endif

#if defined(__MWERKS__) && !qMSWindows
	#ifndef __SIOUX__
	#include <SIOUX.h>
	#endif
#endif

#define kDefaultSize 256

using std::printf;

//----------------------------------------------------------------------------------------
// class CSIOUXTraceStreamRep_AC
//----------------------------------------------------------------------------------------

class CSIOUXTraceStreamRep_AC : public CBufferedStreamRep_AC
{
public:
	CSIOUXTraceStreamRep_AC() 
		: CBufferedStreamRep_AC(kDefaultSize)
	{}
	
	virtual ~CSIOUXTraceStreamRep_AC()
	{}

protected:
	virtual void WriteBufferedBytes(const void* inBytes, long inAmt);
	
};
	

//----------------------------------------------------------------------------------------
// CSIOUXTraceStreamRep_AC::WriteBufferedBytes
//----------------------------------------------------------------------------------------

void CSIOUXTraceStreamRep_AC::WriteBufferedBytes(const void* inBytes, long inAmt)
{
	long textlen = inAmt;

	char* walker = const_cast<char*>( static_cast<const char*>(inBytes) );

	while(textlen > 0)
	{
		static char text[kDefaultSize+2];
		
		long amtToCopy = Min_AC(kDefaultSize, textlen );
		
//		::BlockMove( walker, text, amtToCopy) ;
		
		for(long i = 0; i < amtToCopy; i++)
		{
			if (walker[i] == 0xD)
				text[i] = 0xA;
			else
				text[i] = walker[i];
		}
		
		walker += amtToCopy;
		textlen -= amtToCopy;
	
//		text[amtToCopy] = 0xA;
			// for some reason, a SIOUX bug I suspect, the new line char is required
			// for the text to print out.
//		text[amtToCopy+1] = '\0';

		text[amtToCopy] = '\0';
		
		printf(text);

	}
}

//----------------------------------------------------------------------------------------
// CSIOUXTraceStream_AC::CSIOUXTraceStream_AC
//----------------------------------------------------------------------------------------

CSIOUXTraceStream_AC::CSIOUXTraceStream_AC()
	: CCharOutputSink_AC( TH_new CSIOUXTraceStreamRep_AC)
{
	CTraceStream_AC::AddStream(*this);
}

//----------------------------------------------------------------------------------------
// CSIOUXTraceStream_AC::~CSIOUXTraceStream_AC
//----------------------------------------------------------------------------------------

CSIOUXTraceStream_AC::~CSIOUXTraceStream_AC()
{
	CTraceStream_AC::RemoveStream(*this);
}

#endif