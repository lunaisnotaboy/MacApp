//----------------------------------------------------------------------------------------
// CStream_AC.cpp 
// Copyright © 1990-2001 by Apple Computer, Inc. All rights reserved.
// Originally written by Larry S. Rosenstein.  Used by permission 
//----------------------------------------------------------------------------------------

/*
	Change History
		07/19/01	Must write class name if no signature in WriteStdObject.  Only
					register class if we get a classDesc in ReadObject.  Also return
					a false in ReadObject on a NULL object.
		05/11/01	WriteStdObject and WriteObject now convert name from typeid to
					real class name before using.  Explicitly check results of
					strcmp in WriteStdObject.
		02/15/01	Need to include CTidyHeap_AC. 
		02/08/01	Use vector instead of CLinkedList_AC. 
		01/02/01	Add a WriteString with a std::string for compatibility.
		01/02/01	Update copyright.
		11/15/00	In CStream_AC::ReadString, optimize by not calling ReadBytes
					when there is nothing to read.
		11/09/00	[PB] Change initialization order to match declaration. 
					Remove unused variable len. 
		11/01/00	[PB] Include MacErrors instead of Errors. 
		05/15/00	CW Pro 6: namespacing. 
		02/22/00	[W] Get byte order right in ReadStreamObject.
		03/24/99	Update copyright notice.
		10/15/98	[2279094] Include Types_AC.h for definition of kNoIdentifier_AC and kNoResource_AC.
		10/06/98	Clean up includes. 
*/

#ifndef __CStream_AC__
#include "CStream_AC.h"
#endif

// ACS

#ifndef __Types_AC__
#include "Types_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// ANSI

#ifndef _ALGORITHM
#include <algorithm>
#endif

using std::find;
using std::strlen;

//========================================================================================
// CStream_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CStream_AC constructor
//----------------------------------------------------------------------------------------

CStream_AC::CStream_AC(CStreamRep_AC* inRep)
 	:	fFilters(NULL),
		fClassMap(NULL),
		fClassMapSize(0),
		fStreamRep(inRep)
{
	AssertNotNULL_AC(inRep);
}

//----------------------------------------------------------------------------------------
// CStream_AC destructor
//----------------------------------------------------------------------------------------

CStream_AC::~CStream_AC()
{
	MLinkable_AC<CDataFilter_AC>::DeleteList(fFilters);
}

//----------------------------------------------------------------------------------------
// CStream_AC::GetWritePosition
//----------------------------------------------------------------------------------------

long CStream_AC::GetWritePosition() const
{
	return fStreamRep->GetWritePosition();
}

//----------------------------------------------------------------------------------------
// CStream_AC::GetReadPosition
//----------------------------------------------------------------------------------------

long CStream_AC::GetReadPosition() const
{
	return fStreamRep->GetReadPosition();
}

//----------------------------------------------------------------------------------------
// CStream_AC::SetReadPosition
//----------------------------------------------------------------------------------------

void CStream_AC::SetReadPosition(long newPosition)
{
	fStreamRep->SetReadPosition(newPosition);
}

//----------------------------------------------------------------------------------------
// CStream_AC::SetWritePosition
//----------------------------------------------------------------------------------------

void CStream_AC::SetWritePosition(long newPosition)
{
	fStreamRep->SetWritePosition(newPosition);
}

//----------------------------------------------------------------------------------------
// CStream_AC::ReadBytes
//----------------------------------------------------------------------------------------

void CStream_AC::ReadBytes(void* inBytes, long inAmt)
{
	fStreamRep->ReadBytes(inBytes, inAmt);
	FilterReadBytes(inBytes, inAmt);
}

//----------------------------------------------------------------------------------------
// CStream_AC::PipeOutputTo
//----------------------------------------------------------------------------------------

void CStream_AC::PipeOutputTo(CStream_AC* inStream)
{
	if (!fOutputPipes)
		fOutputPipes = TH_new CStreamList(1, inStream);
	else
		fOutputPipes->push_back(inStream);
}

//----------------------------------------------------------------------------------------
// CStream_AC::BreakPipeWith
//----------------------------------------------------------------------------------------

void CStream_AC::BreakPipeWith(CStream_AC* inStream)
{
	if (fOutputPipes)
	{
		CStreamList::iterator position = find(fOutputPipes->begin(), fOutputPipes->end(), inStream);
		if (position != fOutputPipes->end())
			fOutputPipes->erase(position);
	}
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteBytes
//----------------------------------------------------------------------------------------

void CStream_AC::WriteBytes(const void* inBytes, long inAmt)
{
	const void* bytes = FilterWriteBytes(inBytes, inAmt);
	
	fStreamRep->WriteBytes(bytes, inAmt);
	PipeBytes(bytes, inAmt);
}

//----------------------------------------------------------------------------------------
// CStream_AC::PipeBytes
//----------------------------------------------------------------------------------------

void CStream_AC::PipeBytes(const void* inBytes, long inAmt)
{
	if (fOutputPipes)
	{
		for (CStreamList::iterator iter = fOutputPipes->begin();
			 iter != fOutputPipes->end();
			 ++iter)
		{
			(*iter)->WriteBytes(inBytes, inAmt);
		}
	}
}

//----------------------------------------------------------------------------------------
// CStream_AC::Flush
//----------------------------------------------------------------------------------------

CStream_AC& CStream_AC::Flush()
{
	fStreamRep->Flush();

	if (fOutputPipes)
	{
		for (CStreamList::iterator iter = fOutputPipes->begin();
			 iter != fOutputPipes->end();
			 ++iter)
		{
			(*iter)->Flush();
		}
	}

	return *this;
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteStreamObject: 
//----------------------------------------------------------------------------------------

void CStream_AC::WriteStreamObject(MStreamable_AC* inData,bool stdObject)
{
	long sizePosition;
	short delimiter = kClassIDAndClassname;
	LocalObjectNumber itsObjectNumber;
	bool newEntry = false;

	if (!inData)
		delimiter = kNullObject;
	else
	{
		if (stdObject)
			delimiter = kSignatureAndClassname;

		CStreamContext_AC * itsContext = GetContext();
		if (itsContext)
		{
			itsObjectNumber = itsContext->Add(inData, kDontForceReplacement, newEntry);
			if (!newEntry)
				delimiter = kLocalObjectNumber;
		}
	}

	WriteInteger(delimiter);

	if (delimiter == kNullObject)
		;										// write nothing
	else if (delimiter == kLocalObjectNumber)
		WriteBytes(&itsObjectNumber, sizeof(itsObjectNumber));
	else
	{
		if (delimiter == kClassIDAndClassname)
			WriteObject(inData, sizePosition);	// Write the object header. 
		else
			WriteStdObject(inData, sizePosition);	// Write the object header. 

		if (inData)								// Write the private inData. 
			inData->WriteTo(this);

		WriteObjectSize(sizePosition);			// Write the object size. 
	}
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteStdObject: 
//----------------------------------------------------------------------------------------

void CStream_AC::WriteStdObject(MStreamable_AC* inData, long& sizePosition)
{
	IDType itsSignature = inData ? inData->GetStandardSignature() : kNoIdentifier_AC;

	WriteIDType(itsSignature);				// Write the signature. 

	sizePosition = GetWritePosition();		// Return the position of the object size

	WriteLong(LONG_MAX);					// Write a dummy size (maximum object size).

	CStr255_AC className;
	if (inData)								// inData is not NULL
	{
		const char*		pClassName = CClassRegistration_AC::GetClassNameFromTypeID(*inData);
		
		if (itsSignature != kNoIdentifier_AC)
		{
			const CClassRegistration_AC* signatureClassDesc = CClassRegistration_AC::GetClassDescFromSignature(itsSignature);
			if (signatureClassDesc && std::strcmp(pClassName, signatureClassDesc->GetName()) != 0)
				className = pClassName;		// The names are different so we need the class name in stream
											// since this is probably a subclass of the class with itsSignature.
		}
		else
			className = pClassName;			// Class name required if no signature.
	}

	WriteString(className);						// Write the class name (which may be empty).
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteObject: 
//----------------------------------------------------------------------------------------

void CStream_AC::WriteObject(MStreamable_AC* inData, long& sizePosition)
{
	CClassRegistration_AC*	classInfo = CClassRegistration_AC::GetClassDescFromTypeID(*inData);
	long					streamID = inData ? classInfo->GetClassID() : kNilClass_AC;

	WriteLong(streamID);					// Write the class ID. 

	sizePosition = GetWritePosition();		// Remember the position of the object size in the stream.

	WriteLong(LONG_MAX);					// Write a dummy size (maximum object size).

	CStr255_AC className;
	if ((inData) && (LookupClassID(streamID) == kNilClass_AC))
	// inData is not NULL, and this is the first object of the class. 
	{
		className = classInfo->GetName();	// Get the actual class name. 

		// Register the ID, so we don't write the class name the next time
		//	we write an object of this class.  The second parameter
		//	doesn't matter,  as long as it isn't kNilClass_AC.
		RegisterClassID(streamID, streamID);
	}

	WriteString(className);					// Write the class name (which may be empty).
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteObjectSize: 
//----------------------------------------------------------------------------------------

// This fills in the object's size at the position passed in. 
void CStream_AC::WriteObjectSize(long sizePosition)
{
	long currentPosition = GetWritePosition();		// Remember where we are. 
	SetWritePosition(sizePosition);					// Go back to position of size. 

	WriteLong(currentPosition - sizePosition);	// Write the size. 

	SetWritePosition(currentPosition);				// Go back to where we were. 
}


void CStream_AC::WriteHandle(const Handle aHandle)
{
	if (aHandle)
	{
		// write the size of the handle
		Size itsSize = GetHandleSize(aHandle);
		WriteLong(itsSize);

		// Write the contents of the handle. 
		// We definitely need to lock the handle here because
		// the code in Write may move memory before reading
		// the inData. 
		CTempHandleLock_AC tempHandleLock(aHandle);
		::ThrowIfMemError_AC();
		WriteBytes(*aHandle, itsSize);
	}
	else
		WriteLong(-1);
}

//----------------------------------------------------------------------------------------
// CStream_AC::LookupClassID: This returns the new class ID given a class ID found in the
// stream, or kNilClass_AC if it wasn't found. It does a simple linear search.
//----------------------------------------------------------------------------------------

long CStream_AC::LookupClassID(long id) const
{
	long returnVal = kNilClass_AC;

	if (id != static_cast<long>(kNilClass_AC))
		for (short i = 0; i < fClassMapSize; ++i)
			if ((*fClassMap)[i].fOldID == id)
			{
				returnVal = (*fClassMap)[i].fNewID;
				break;
			}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CStream_AC::RegisterClassID: This simply adds the mapping to the end of the list. It does
// not check to see if the mapping exists already.
//----------------------------------------------------------------------------------------

void CStream_AC::RegisterClassID(long oldID,
							  long newID)
{
	if (oldID != kNilClass_AC)
	{
		if (!fClassMap)
			fClassMap = (HClassArray) NewPermHandle_AC(0);

		++fClassMapSize;
		SetPermHandleSize_AC((Handle)(HClassArray)fClassMap, fClassMapSize * sizeof(ClassIDEntry));
		

		(*fClassMap)[fClassMapSize - 1].fOldID = oldID;
		(*fClassMap)[fClassMapSize - 1].fNewID = newID;
	}
}

//----------------------------------------------------------------------------------------
// CStream_AC::ReadString: 
//----------------------------------------------------------------------------------------

CStr255_AC CStream_AC::ReadString(short maxSize)
{
	CStr255_AC inData;

	ReadBytes(&inData, 1);						// Read the length byte. 

	if (inData.Length() + 1 > maxSize)
		::ThrowIfOSErr_AC(paramErr);			// Can't read that many bytes. 
	else if (inData.Length())					// Don't call unless want to read data
		ReadBytes(&inData[1], inData.Length());

	return inData;
}

//----------------------------------------------------------------------------------------
// CStream_AC::ReadHandle: 
//----------------------------------------------------------------------------------------

Handle CStream_AC::ReadHandle()
{
	Handle returnVal = NULL;

	// read the size of the handle in from the stream
	Size itsSize = ReadLong();

	if (itsSize >= 0)
	{
		// allocate the handle
		CTempHandle_AC aHandle = NewPermHandle_AC(itsSize); 

		// Lock the handle and read into it from the stream. 
		// We definitely need to lock the handle here because
		// the code in Read may move memory before reading
		// the inData. 
		CTempHandleLock_AC tempHandleLock(aHandle);
		::ThrowIfMemError_AC();
		ReadBytes(*(Handle)aHandle, itsSize);

		returnVal = aHandle.release();
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CStream_AC::ReadStdObject: 
//----------------------------------------------------------------------------------------

MStreamable_AC* CStream_AC::ReadStdObject(bool& wasValid)
{
	wasValid = false;

	IDType itsSignature = ReadIDType();				// Read the object's signature. 

	long sizePosition = GetReadPosition();				// Read its size and remember the current position.
	long objectSize = ReadLong();

	CStr255_AC className = ReadString(sizeof(className));		// Read its name. 

	MStreamable_AC* returnVal = NewObjectBySignature_AC(itsSignature, CChar255_AC(className));

	if (returnVal)
		wasValid = true;
	else										// Don't know about the class. 
		{
			// If the streamID is kNilClass_AC then the object was realy
			//	NULL, which is a known object, otherwise the class
			//	isn't available.
			wasValid = false;

			// Skip over the object's inData. 
			SetReadPosition(sizePosition + objectSize);// Skip over its inData. 
		}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CStream_AC::ReadObject: 
//----------------------------------------------------------------------------------------

MStreamable_AC* CStream_AC::ReadObject(bool& wasValid)
{
	MStreamable_AC* returnVal = NULL;
	wasValid = false;

	long currentID;						// Class ID in program. 

	long streamID = ReadLong();			// Read the object's class ID in stream.

	long sizePosition = GetReadPosition();	// Read its size and remember the current position.
	long objectSize = ReadLong();

	CStr255_AC className = ReadString(sizeof(className));	// Read its name. 

	if (className.IsEmpty())			// No class name. Must have seen the class
										// before, so convert the streamID to the
										// currentID.
		currentID = LookupClassID(streamID);
	else
	{											// Get ID from name ...
		const CClassRegistration_AC * classDesc = CClassRegistration_AC::GetClassDescFromClassName(CChar255_AC(className));
		if (classDesc)
		{
			currentID = classDesc->GetClassID();
			RegisterClassID(streamID, currentID);	// ... and register the IDs. 
		}
		else
			currentID = kNilClass_AC;
	}

	if (currentID == kNilClass_AC)			// Don't know about the class. 
	{
		// If the streamID is kNilClass_AC then the object was realy
		//	NULL, which is a known object, otherwise the class
		//	isn't available.
		wasValid = streamID == kNilClass_AC;

		// Skip over the object's inData. 
		SetReadPosition(sizePosition + objectSize);	// Skip over its inData. 
	}
	else
	{										// Create the object. 
		returnVal = CClassRegistration_AC::NewByClassID((ClassID_AC)currentID);
		wasValid = (returnVal != NULL);		// A NULL return indicates trouble!
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// CStream_AC::ReadStreamObject: 
//----------------------------------------------------------------------------------------

MStreamable_AC* CStream_AC::ReadStreamObject(bool& wasValid)
{
	MStreamable_AC* returnVal = NULL;

	wasValid = false;

	short delimiter;
	LocalObjectNumber itsObjectNumber;
	CStreamContext_AC * itsContext = GetContext();

	delimiter = ReadInteger();

	if (delimiter == kNullObject)
	{
		returnVal = NULL;
		wasValid = true;
	}
	else if (delimiter == kLocalObjectNumber)
	{
#if qMSWindows
		itsObjectNumber = this->ReadLong(); // Get the byte order right.
#else
		ReadBytes(&itsObjectNumber, sizeof(itsObjectNumber));
#endif
		if (itsContext)
			returnVal = itsContext->Find(itsObjectNumber);
#if qDebugMsg
		else
			::ProgramBreak_AC("###Need a CStreamContext_AC in CStream_AC::ReadStreamObject.");
#endif

		if (returnVal)
			wasValid = true;
	}
	else
	{
		if (delimiter == kClassIDAndClassname)
			returnVal = ReadObject(wasValid);			// Create an uninitialized object. 
		else if (delimiter == kSignatureAndClassname)
			returnVal = ReadStdObject(wasValid);		// Create an uninitialized object by signature. 
#if qDebugMsg
		else
			::ProgramBreak_AC("###Unknown delimiter in CStream_AC::ReadStreamObject.");
#endif

		if (wasValid)
		{
			bool newEntry = false;
			if (itsContext)
				itsObjectNumber = itsContext->Add(returnVal, kDontForceReplacement, newEntry);

			try
			{
				if (returnVal)						// If we got an object, then tell it to initialize itself.
					returnVal->ReadFrom(this);
			}
			catch(CException_AC& theException)
			{
				DoCatchMessage_AC(theException);
				delete returnVal;					// we don't want ReadFrom/Fields to delete object, we will
				returnVal = NULL;					// make sure that we return a null null reference.
				throw;
			}
			
		}
	}
	return returnVal;
}

//----------------------------------------------------------------------------------------
// CStream_AC::AddFilter
//----------------------------------------------------------------------------------------

void CStream_AC::AddFilter(CDataFilter_AC* inFilter)
{
	AssertNotNULL_AC(inFilter);
	fFilters = inFilter->Append(fFilters);
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteString
//----------------------------------------------------------------------------------------

void CStream_AC::WriteString(const char* inCString)
{	
	const char* strPtr = inCString;
	long len = ::strlen(strPtr);
	CDataFilter_AC* walker = fFilters; 
	while (walker)	
	{	
		strPtr = walker->FilterOutput(strPtr, len);
			// get new ptr from filter if any.	
		walker = walker->GetNextLink();	
	}	
	WriteBytes(strPtr, len);
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteString
//----------------------------------------------------------------------------------------

void CStream_AC::WriteString(const unsigned char* inPString)
{	
	const unsigned char* str = inPString;
	//long len = *str;
	CDataFilter_AC* walker = fFilters; 
	while (walker)	
	{	
		str = walker->FilterOutput(str);	
		walker = walker->GetNextLink();	
	}	
	WriteBytes(str, *str);
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteString
//----------------------------------------------------------------------------------------

void CStream_AC::WriteString(const CPascalStr_AC& inStr)
{		
	const unsigned char* str = inStr;
	CDataFilter_AC* walker = fFilters; 
	while (walker)	
	{	
		str = walker->FilterOutput(str);	
		walker = walker->GetNextLink();	
	}	
	WriteBytes(str, *str + 1);
}

//----------------------------------------------------------------------------------------
// CStream_AC::WriteString
//----------------------------------------------------------------------------------------

void CStream_AC::WriteString(const std::string& inStr)
{		
	const char* str = inStr.data();
	long len = inStr.length();
	CDataFilter_AC* walker = fFilters; 
	while (walker)	
	{	
		str = walker->FilterOutput(str, len);	
		walker = walker->GetNextLink();
	}	
	WriteBytes(str, len);
}

//----------------------------------------------------------------------------------------
// CStream_AC::RemoveFilter
//----------------------------------------------------------------------------------------

void CStream_AC::RemoveFilter(CDataFilter_AC* inFilter)
{
	if (fFilters)
	{
		fFilters = fFilters->Remove(inFilter);
	}
}

/*
	Historical Change Record:
		----- R13 -----
		07/16/97	Tidied up.
		07/15/97	Removed unnecessary includes (no-load), added lines.
		06/30/97	Make it go with iterator change.
		06/25/97	Changes to CLinkedListAC.cp
		05/27/97	Fix filter prob.
		05/21/97	Streams enhancements.
		05/20/97	Buffering and Stream improvements.
		05/19/97	Add CStreamRep_AC to streams abstraction.
		05/12/97	Fix streams related build errors.
		05/12/97	Streams be a changin'...
		05/06/97	Added StreamRep to streams.
		05/05/97	Changes for new streaming.
		04/23/97	ReadFields methods don't free themselves on failure.
		04/18/97	Oops, forgot to dereference typeid parameter to get dynamic type!
		04/18/97	Changes to streaming.
		04/14/97	Update for real xxx_cast operators.
		04/02/97	Include Code_Ac.h.
		03/27/97	Port from MacApp.
		03/26/97	Fix debug mode compile errors.
		03/25/97	AC_ to _AC Name change.
		03/24/97	Migrated Dependencies and Lists to ACS
		03/21/97	Reduce RTTI macro requirements
		03/21/97	Migrated to CLongRect_AC, CLongPoint_AC, ViewCoordinate.
		03/19/97	Convert to Native RTTI
		03/13/97	Update CW11 noDebug/68K support
		03/11/97	Update exception support to latest.
		03/07/97	Massive Changes: Use Exceptions_AC, new to TH_new, use Blah_AC,
							Update Copyright, Moved Obsolete APIs into Compatibility.h, etc..
		02/19/97	Use embedded objects instead of auto_ptr based object where possible.
		02/15/97	Fleshed out copy constructor.
		01/17/97	Updated qMSWindows conditionals.
		01/13/97	Updated qWindows conditionals.
		09/30/96	Fix cloning by turning clone methods into copy constructors
		08/16/96	Use constructors for all TView descendents
		08/12/96	Use constructors for all CStream_AC descendents
		08/07/96	Goodbye TObject!
		08/01/96	T[Sorted]List now takes a void* T[Sorted]VoidList now typedefed to T[Sorted]List
		07/18/96	Use CAutoPtr_AC based pointers for many instance variables.
		07/17/96	define template CAutoPtr_AC and use it in place of CTempObject
		07/16/96	Removed MAVolatile
		07/16/96	Replacing Failxxx with Throwxx procs
		07/16/96	Goodbye Exception Macros (TRY, CATCH_ALL, ENDTRY)
		07/16/96	Now include UExceptions.h instead of UFailure.h
		07/15/96	Boolean->bool
		----- R11 -----
		06/27/96	Make conditional tests implicit as in if (x) instead of if (x != 0).
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/26/96	==/!=NULL to implicit tests, except in the case of assignment to or passing/returning as bool/bool.
		06/09/96	Removed UStreamable to a separate file from UObject
		05/09/96	Adjust the Failure Handling macros to allow for easy switching to native exceptions.
		05/06/96	Combine Lockhandle and LockHandleHigh. Create CTempHandleLock_AC.
		04/29/96	Create and use functions that return their inData as results for:
							CStream_AC::ReadCharacter/CLongPoint_AC/Rect/CLongRect_AC/RGBColor/String. Create compatible inlines
							so users don't have to change their code.
		04/23/96	Use CTempObject/Handle/Region/Ptr, etc.
		04/23/96	Update iterators to be OD stylish.
		04/18/96	Use post-increment with iterators in while loops
		04/16/96	Use "while" style iteration
		----- R10 -----
		03/30/96	Remove keywords from:
							GetContext/SetContext//AtEnd/ReadByte/ReadBoolean/ReadCharacter/ReadInteger/
							ReadLong/ReadPoint/ReadLongPoint/ReadRect/ReadVRect/ReadRGBColor/ReadIDType/ReadString/
							ReadHandle/ReadObject/ReadStdObject/ReadStreamObject/ReadWordAlign/WriteByte/
							WriteBoolean/WriteCharacter/WriteInteger/WriteLong/WritePoint/WriteLongPoint/
							WriteRect/WriteVRect/WriteRGBColor/WriteIDType/WriteString/WriteHandle/WriteObject/
							WriteStdObject/WriteObjectSize/WriteStreamObject/WriteWordAlign/LookupClassID/RegisterClassID
		03/26/96	Cleanup references to gEmptyString and ""
		 12/8/95	Split TFileStream and TFileResourceStream off to
							UFileStream. 
		----- 3.3 -----
		----- 3.3b1 -----
		10/31/95	Add CurResFile_AC, Fix UseResFile_AC to avoid unnecessary UseResFile calls.
		 8/11/95	Don't need to lock handle in THandleStream::WriteBytes. 
		 5/14/95	Save/lock and restore handle state instead of lock and unlock. 
		 					Remove support for pre-system 7. 
		  4/8/95	Use size limits from limits.h instead of MacAppTypes. 
		 3/27/95	Change ReadStdObject and WriteStdObject to use TObject and
		 					ClassDesc functions instead of the old utilities in 
		 					UCoreGlobals. 
		 3/17/95	MAVolatile. 
		 3/13/95	Change Free methods to destructors. 
		  3/9/95	Changed ClassDesc NewByXXX functions to return a void* 
							instead of a TObject*. 
		02/22/95	1222850 MacApp should use BlockMove_AC and BlockMoveOverlap_AC everywhere
		 9/12/94	Added TFileResourceStream class per
							Eric Hanig's MADrag additions.
*/

//----------------------------------------------------------------------------------------
// End of CStream_AC.cpp 
