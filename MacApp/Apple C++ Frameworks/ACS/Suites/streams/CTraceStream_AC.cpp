//----------------------------------------------------------------------------------------
// CTraceStream_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		02/08/01	Use vector instead of CLinkedList_AC. 
		01/02/01	Update copyright.
		11/09/00	[PB] Change initialization order to match declaration. 
		12/07/99	Corrected file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef __CTraceStream_AC__
#include "CTraceStream_AC.h"
#endif

#if qTrace_AC

// ACS

#ifndef __CBufferedStreamRep_AC__
#include "CBufferedStreamRep_AC.h"
#endif

#ifndef __CLinkedList_AC__
#include "CLinkedList_AC.h"
#endif

//----------------------------------------------------------------------------------------
// local definitions
//----------------------------------------------------------------------------------------

#define kDefaultSize 256

//----------------------------------------------------------------------------------------
// static data
//----------------------------------------------------------------------------------------

CAutoPtr_AC<CTraceStream_AC> CTraceStream_AC::fgSelf;

//----------------------------------------------------------------------------------------
// CTraceStream_AC::CTraceStream_AC
//----------------------------------------------------------------------------------------
CTraceStream_AC::CTraceStream_AC() 
	:	CCharOutputSink_AC(TH_new CBufferedStreamRep_AC(kDefaultSize)),
		fPriorityFilter(kLowPriority), 
		fPrevPriorityFilter(0),
		fPriority(kDefaultPriority),
		fPrevPriority(0)
{
}

//----------------------------------------------------------------------------------------
// CTraceStream_AC::~CTraceStream_AC
//----------------------------------------------------------------------------------------

CTraceStream_AC::~CTraceStream_AC() 
{
}

//----------------------------------------------------------------------------------------
// CTraceStream_AC::GetStreamRef
//----------------------------------------------------------------------------------------

CTraceStream_AC& CTraceStream_AC::GetStreamRef()
{
	if(!fgSelf) fgSelf = TH_new CTraceStream_AC;
	return *fgSelf;
}

//----------------------------------------------------------------------------------------
// CTraceStream_AC::AddStream
//----------------------------------------------------------------------------------------

void CTraceStream_AC::AddStream(CStream_AC& in)
{
	GetStreamRef().PipeOutputTo(&in);
}

//----------------------------------------------------------------------------------------
// CTraceStream_AC::RemoveStream
//----------------------------------------------------------------------------------------

void CTraceStream_AC::RemoveStream(CStream_AC& stream)
{
	GetStreamRef().BreakPipeWith(&stream);
}

//----------------------------------------------------------------------------------------
// CTraceStream_AC::WriteCharBytes
//----------------------------------------------------------------------------------------

void CTraceStream_AC::WriteCharBytes(const char* inBytes, long inAmt)
{
	if((fPriority >= fPriorityFilter) && (fPriorityFilter > 0))
	{
		CCharOutputSink_AC::WriteCharBytes(inBytes, inAmt);
		
		if (fOutputPipes)
		{
			CCharOutputSink_AC* pipe = NULL;	

			for (CStreamList::iterator iter = fOutputPipes->begin();
				 iter != fOutputPipes->end();
				 ++iter)
			{
				pipe = dynamic_cast_AC(CCharOutputSink_AC*, *iter);
				if(pipe)
					pipe->WriteCharBytes(inBytes, inAmt);
				else
					(*iter)->WriteBytes(inBytes, inAmt);
			}
		}
	}		
}

#endif  // qTrace_AC

//----------------------------------------------------------------------------------------
// End of CTraceStream_AC.cpp
