//----------------------------------------------------------------------------------------
// MJavaView_AC.cpp
// Copyright � 1997-2001 by Apple Computer, Inc. All rights reserved. 
//
//	Dedicated to Carsten Brinkshulte who graciously contributed his example Java
//	code in the hopes that the MacApp team would refine it and make it an official
//	part of MacApp.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		01/19/01	Use CString_AC instead of CStr255_AC.  Pass a CString_AC to 
					SetTitleRequest in WinSetTitleRequestProc.  Include CPascalString_AC.h.
		01/02/01	Update copyright.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		12/07/99	Include CJavaText_AC.h and CReporter_AC.h.  Changed initialization
					in MJavaView_AC ctor.  Reworked JavaClose, AdoptFrame, GetJavaAppletContext,
					JavaSetFrame, JavaDraw, JavaMouseEvent, JavaKeyEvent, JavaResignedTarget,
					JavaIdle, ShowHideRequest, JavaViewFromFrameRef, WinResizeRequestProc,
					WinSetTitleRequestProc.
		11/18/99	Carbon: Java not currently in Carbon; new APIs to come.
		09/20/99	Carbon:OSEventAvail no longer in Carbon?
		03/24/99	Update copyright notice.
		10/07/98	Pass a RgnHandle instead of a CRegion_AC to JavaDraw. 
*/

#ifndef __MJavaView_AC__
#include "MJavaView_AC.h"
#endif

#ifndef __CJavaAppletContext_AC__
#include "CJavaAppletContext_AC.h"
#endif

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

#ifndef __CJavaSession_AC__
#include "CJavaSession_AC.h"
#endif

#ifndef __CJavaText_AC__
#include "CJavaText_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#if qCarbon
	//#pragma message ("Carbon: MJavaView_AC.cpp: Java not currently in Carbon; new APIs to come.")
#endif

//========================================================================================
// CLASS MJavaView_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// MJavaView_AC constructor
//----------------------------------------------------------------------------------------

MJavaView_AC::MJavaView_AC(	JMAWTContextRef		context,
							JMFrameRef			frame) :
	fContext(NULL),
	fFrame(NULL),
	fDeferredActivate(false)
{
	AdoptFrame(context, frame);
}

//----------------------------------------------------------------------------------------
// MJavaView_AC destructor
//----------------------------------------------------------------------------------------

MJavaView_AC::~MJavaView_AC()
{
	JavaClose();
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::JavaClose: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::JavaClose()
{
#if !qCarbon
	if (fFrame)
	{		
		OSStatus err = ::JMSetFrameData(fFrame, (JMClientData) NULL);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaClose: OSStatus(%d) returned from JMSetFrameData()", err);
#endif
		err = ::JMFrameGoAway(fFrame);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaClose: OSStatus(%d) returned from JMFrameGoAway()", err);
#endif
		fFrame = NULL;
	}
	
	CJavaAppletContext_AC* aJavaAppletContext = GetJavaAppletContext();		
	if (aJavaAppletContext)
	{
		aJavaAppletContext->RemoveView(this);
		fContext = NULL;
	}
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::AdoptFrame: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::AdoptFrame(JMAWTContextRef context, JMFrameRef frame)
{
#if qCarbon
	#pragma unused (context, frame)
#else
	if (frame && (frame != fFrame))
	{
		Assertion_AC( fFrame == NULL, "MJavaView_AC::AdoptFrame: Already adapted to another frame (MJavaView_AC::AdoptFrame)" );
		
		fFrame = frame;
		OSStatus err = ::JMSetFrameData(frame, (JMClientData) this);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::AdoptFrame: OSStatus(%d) returned from JMSetFrameData()", err);
#endif
	}
	
	if (context && (context != fContext))
	{
		Assertion_AC( fContext == NULL, "MJavaView_AC::AdoptFrame: Already adapted to another context (MJavaView_AC::AdoptFrame)" );

		fContext = context;
		CJavaAppletContext_AC* aJavaAppletContext = GetJavaAppletContext();
		
		if (aJavaAppletContext)
			aJavaAppletContext->AddView(this);
	}
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::GetAWTContext: 
//----------------------------------------------------------------------------------------

JMAWTContextRef MJavaView_AC::GetAWTContext()
{
	return fContext;
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::GetJavaAppletContext: 
//----------------------------------------------------------------------------------------

CJavaAppletContext_AC* MJavaView_AC::GetJavaAppletContext()
{
	CJavaAppletContext_AC* aJavaAppletContext = NULL;
	
#if !qCarbon
	if (fContext)
	{
		OSStatus err = ::JMGetAWTContextData(fContext, &reinterpret_cast<JMClientData&>(aJavaAppletContext));
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::GetJavaAppletContext: OSStatus(%d) returned from JMGetAWTContextData()", err);
#endif
	}
#endif	
	return aJavaAppletContext;
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::GetFrame: 
//----------------------------------------------------------------------------------------

JMFrameRef MJavaView_AC::JavaGetFrame()
{
	return fFrame;
}


//----------------------------------------------------------------------------------------
// MJavaView_AC::SetFrame: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::JavaSetFrame(const CRect_AC& newFrame)
{
#if qCarbon
	#pragma unused (newFrame)
#else
	if (fFrame)
	{
		CRect_AC oldFrame;
			
		OSStatus err = ::JMGetFrameSize(fFrame, oldFrame);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaSetFrame: OSStatus(%d) returned from JMGetFrameSize()", err);
#endif
		
		if (oldFrame != newFrame)
		{
			err = ::JMSetFrameSize(fFrame, newFrame);
#if qDebugMsg
			if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaSetFrame: OSStatus(%d) returned from JMSetFrameSize()", err);
#endif
		}
	}
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::Draw: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::JavaDraw(CRegion_AC visibleRegion)
{
#if qCarbon
	#pragma unused (visibleRegion)
#else
	if (fFrame)
	{
		CTempGrafPort_AC saveThePort();	
		
		OSStatus err = ::JMFrameUpdate(fFrame, visibleRegion);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaDraw: OSStatus(%d) returned from JMFrameUpdate()", err);
#endif
		
		// Need to call JMIdle in order to make sure the imaging gets drawn on-screen
		// This might to be a bug in MRJ
		err = ::JMIdle(CJavaSession_AC::GetSessionRef(), kDefaultJMTime);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaDraw: OSStatus(%d) returned from JMIdle()", err);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::JavaMouseEvent: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::JavaMouseEvent(const CPoint_AC& theMouse, short modifiers)
{
#if qCarbon
	#pragma unused (theMouse, modifiers)
#else
	if (fFrame)
	{
		OSStatus err = ::JMFrameClick(fFrame, theMouse, modifiers);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaMouseEvent: OSStatus(%d) returned from JMFrameClick()", err);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::JavaKeyEvent: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::JavaKeyEvent(char asciiChar, char keyCode, short modifiers)
{
#if qCarbon
	#pragma unused (asciiChar, keyCode, modifiers)
#else
	if (fFrame)
	{
		OSStatus err = ::JMFrameKey(fFrame, asciiChar, keyCode, modifiers);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaKeyEvent: OSStatus(%d) returned from JMFrameKey()", err);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::BecameTarget: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::JavaBecameTarget()
{
// ���  bombs at window open time
//	if (fFrame)
//		::JMFrameActivate(fFrame, true);
//	else
		fDeferredActivate = true;
	
	CJavaSession_AC::SetActiveJavaView(this);
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::JavaResignedTarget: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::JavaResignedTarget()
{
#if !qCarbon
	if (fFrame)
	{
		OSStatus err = ::JMFrameActivate(fFrame, false);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaResignedTarget: OSStatus(%d) returned from JMFrameActivate()", err);
#endif
	}
#endif	
	CJavaSession_AC::SetActiveJavaView(NULL);
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::JavaIdle: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::JavaIdle()
{
#if !qCarbon
	Point localPos;
	EventRecord event;

	if (fFrame)
	{
		CTempGrafPort_AC saveThePort();	
		OSEventAvail(0, &event);
		GetMouse(&localPos);
		
		OSStatus err = ::JMFrameMouseOver(fFrame, localPos, event.modifiers);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::JavaIdle: OSStatus(%d) returned from JMFrameMouseOver()", err);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::SetupPortRequest: 
//----------------------------------------------------------------------------------------

void* MJavaView_AC::SetupPortRequest()
{	
	return NULL;
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::RestorePortRequest: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::RestorePortRequest(void* /*refCon*/)
{
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::ResizeRequest: 
//----------------------------------------------------------------------------------------

bool MJavaView_AC::ResizeRequest(CRect_AC& /*desiredRect*/)
{
	bool requestProcOK = true;
	
	return requestProcOK;
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::ShowHideRequest: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::ShowHideRequest(bool showIt)
{
#if qCarbon
	#pragma unused (showIt)
#else
	if (fDeferredActivate && showIt) 
	{
		OSStatus err = ::JMFrameActivate(fFrame, true);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("MJavaView_AC::ShowHideRequest: OSStatus(%d) returned from JMFrameActivate()", err);
#endif
		fDeferredActivate = false;
	}
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::SetTitleRequest: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::SetTitleRequest(const CString_AC& title)
{
	#pragma unused (title)
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::CheckUpdateRequest: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::CheckUpdateRequest()
{

}

//----------------------------------------------------------------------------------------
// MJavaView_AC::InvalRectRequest: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::InvalRectRequest(const CRect_AC& invalidRect)
{
	#pragma unused (invalidRect)
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::StatusMessageRequest: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::StatusMessageRequest(const CString_AC& statusMsg)
{
	#pragma unused (statusMsg)
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::ReleaseFrameRequest: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::ReleaseFrameRequest()
{
	delete this;
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::JavaViewFromFrameRef: 
//----------------------------------------------------------------------------------------

MJavaView_AC* MJavaView_AC::JavaViewFromFrameRef(JMFrameRef ref)
{
	MJavaView_AC* aJavaView = NULL;
#if qCarbon
	#pragma unused (ref)
#else
	if (ref)
	{
		OSStatus err = ::JMGetFrameData(ref, &reinterpret_cast<JMClientData&>(aJavaView));
#if qDebugMsg
		if (err != noErr) ProgramReport_AC("MJavaView_AC::JavaViewFromFrameRef: OSStatus(%d) returned from JMGetFrameData()", err);
#endif
	
		if (err != noErr)
			aJavaView = NULL;
	}
#endif	
	return aJavaView;
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::JavaViewFromContextRef: 
//----------------------------------------------------------------------------------------

MJavaView_AC* MJavaView_AC::JavaViewFromContextRef(JMAWTContextRef ref)
{
	MJavaView_AC* aJavaView = NULL;
#if qCarbon
	#pragma unused (ref)
#else
	if (ref)
	{
		JMFrameRef frame;
		OSStatus err = ::JMGetAWTContextFrame(ref, 0, &frame);
	
		if (err == noErr)
			aJavaView = MJavaView_AC::JavaViewFromFrameRef(frame);
	}
#endif
	return aJavaView;
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::WinResizeRequestProc: 
//----------------------------------------------------------------------------------------

extern "C" void WinResizeRequestProc(JMFrameRef ref, const Rect* desired)
{
	bool result = false;
	
	MJavaView_AC* aJavaView = MJavaView_AC::JavaViewFromFrameRef(ref);
	
	if (aJavaView)
	{
		CRect_AC desiredRect(*desired);
		result = aJavaView->ResizeRequest(desiredRect);
		
		aJavaView->JavaAdjustVisibility();
	}
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::WinInvalRectRequestProc: 
//----------------------------------------------------------------------------------------

extern "C" void /* MJavaView_AC:: */ 
				WinInvalRectRequestProc(JMFrameRef ref, const Rect* r)
{
	MJavaView_AC* aJavaView = MJavaView_AC::JavaViewFromFrameRef(ref);
	
	if (aJavaView)
	{
		CRect_AC invalidRect(*r);
		aJavaView->InvalRectRequest(invalidRect);
	}
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::WinShowHideRequestProc: 
//----------------------------------------------------------------------------------------

extern "C" void /* MJavaView_AC:: */ 
				WinShowHideRequestProc(JMFrameRef ref, Boolean showIt)
{
	MJavaView_AC* aJavaView = MJavaView_AC::JavaViewFromFrameRef(ref);
	
	if (aJavaView)
	{
		aJavaView->ShowHideRequest(showIt);
		// Setup java frame so that subsequent update event can draw java frame properly.
		aJavaView->JavaAdjustVisibility();
	}
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::WinSetTitleRequestProc: 
//----------------------------------------------------------------------------------------

extern "C" void WinSetTitleRequestProc(JMFrameRef ref, JMTextRef title)
{
#if qCarbon
	#pragma unused (ref, title)
#else
	MJavaView_AC* aJavaView = MJavaView_AC::JavaViewFromFrameRef(ref);
	
	if (aJavaView)
		aJavaView->SetTitleRequest(CJavaText_AC(title));
#endif
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::WinCheckUpdateRequestProc: 
//----------------------------------------------------------------------------------------

extern "C" void /* MJavaView_AC:: */
				WinCheckUpdateRequestProc(JMFrameRef ref)
{
	MJavaView_AC* aJavaView = MJavaView_AC::JavaViewFromFrameRef(ref);
	
	if (aJavaView)
		aJavaView->CheckUpdateRequest();
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::WinSetResizeableRequestProc: 
//----------------------------------------------------------------------------------------

extern "C" void /* MJavaView_AC:: */
				WinFrameReorderRequestProc(	JMFrameRef			/* frame */, 
											enum ReorderRequest /* theRequest */)
{
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::WinSetResizeableRequestProc: 
//----------------------------------------------------------------------------------------

extern "C" void /* MJavaView_AC:: */
				WinSetResizeableRequestProc(JMFrameRef	/* frame */, 
											Boolean 	/* resizeable */)
{
}

//----------------------------------------------------------------------------------------
// MJavaView_AC::SetupCallbacks: 
//----------------------------------------------------------------------------------------

void MJavaView_AC::SetupCallbacks(JMFrameCallbacks* callbacks)
{
	callbacks->fVersion			= kJMVersion;
	callbacks->fSetFrameSize	= /* MJavaView_AC:: */ WinResizeRequestProc;
	callbacks->fInvalRect		= /* MJavaView_AC:: */ WinInvalRectRequestProc;
	callbacks->fShowHide		= /* MJavaView_AC:: */ WinShowHideRequestProc;
	callbacks->fSetTitle 		= /* MJavaView_AC:: */ WinSetTitleRequestProc;
	callbacks->fCheckUpdate		= /* MJavaView_AC:: */ WinCheckUpdateRequestProc;
	callbacks->fReorderFrame	= /* MJavaView_AC:: */ WinFrameReorderRequestProc;
	callbacks->fSetResizeable	= /* MJavaView_AC:: */ WinSetResizeableRequestProc;
}

//----------------------------------------------------------------------------------------
// end of file