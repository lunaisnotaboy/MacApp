//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//
//	Our sincere thanks to Carsten Brinkshulte who graciously contributed his example 
//	Java code in the hopes that the MacApp team would refine it and make it an 
//	official part of MacApp.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		01/20/01	Cleanup CJavaAppletContainer_AC ctor and GetAppletName.
		01/02/01	Update copyright.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		01/05/00	Move calls to Java runtime out of line. 
					Conditionalize calls not in Carbon. 
					CountApplets return value should be initialized. 
		12/07/99	Include CJavaText_AC.h.  Added CJavaAutoAppletLocator_AC for
					JMAppletLocatorRef management.  Reworked implementation of
					CJavaAppletContainer_AC ctors and dtor.  Changed actualCount
					to UInt32 in CountApplets.  Simplified LocatorCompleted and
					StartAllApplets.  LocatorCompletedProc is not longer member.
					Check error in LocatorCompletedProc.  Consolidated
					LocatorCompletedProcWrap into LocatorCompletedProc.
		11/18/99	Carbon: Java isn't supported yet in Carbon, so take out references.
		03/24/99	Update copyright notice.
		11/13/98	[2279260] Pass ‘url’ not ‘&url’ to JMNewTextRef.
		10/06/98	Clean up includes. 
*/

#ifndef __CJavaAppletContainer_AC__
#include "CJavaAppletContainer_AC.h"
#endif

// ACS

#ifndef __CJavaAppletContext_AC__
#include "CJavaAppletContext_AC.h"
#endif

#ifndef __CJavaSession_AC__
#include "CJavaSession_AC.h"
#endif

#ifndef __CJavaAppletLocator_AC__
#include "CJavaAppletLocator_AC.h"
#endif

#ifndef __CJavaText_AC__
#include "CJavaText_AC.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __Debug_AC__
#include "Debug_AC.h"
#endif

#if qCarbon
	//#pragma message ("Carbon: CJavaAppletContainer_AC.cpp: Java not currently in Carbon; new APIs to come.")
#endif

//========================================================================================
//	class CJavaAppletLocatorDeleter_AC
//========================================================================================
	
//----------------------------------------------------------------------------------------
// CJavaAppletLocatorDeleter_AC::DeleteRef
//----------------------------------------------------------------------------------------

void CJavaAppletLocatorDeleter_AC::DeleteRef(JMAppletLocatorRef appletLocatorRef)
{
	if (appletLocatorRef)
	{
#if qCarbon
//#pragma message ("Carbon: in CJavaAppletLocatorDeleter_AC::DeleteRef, JMDisposeAppletLocator not in Carbon")
#else
		OSStatus err = ::JMDisposeAppletLocator(appletLocatorRef);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaAppletLocatorDeleter_AC::DeleteRef: OSStatus(%d) returned from JMDisposeAppletLocator()", err);
#endif
#endif
	}
}


//========================================================================================
//	class CJavaAutoAppletLocator_AC
//========================================================================================
	
//----------------------------------------------------------------------------------------
// CJavaAutoAppletLocator_AC::CJavaAutoAppletLocator_AC
//----------------------------------------------------------------------------------------

CJavaAutoAppletLocator_AC::CJavaAutoAppletLocator_AC(	
							const JMAppletLocatorCallbacks* callbacks,
							JMClientData clientData,
							const CStr255_AC&	url,
							const CStr255_AC&	htmlText)
		// Locate an applet asynchronously by fetching an HTML document from a specified URL.
{
#if qCarbon
//#pragma message ("Carbon: in CJavaAutoAppletLocator_AC ctor, JMNewAppletLocator not in Carbon")
#pragma unused (callbacks, clientData, url, htmlText)
#else
	CJavaAutoText_AC urlTextRef(url);
	CJavaAutoText_AC htmlTextRef;	// JM will test NULL-ness of the htmlText parameter, not emptiness.
	if (htmlText.Length() > 0)
		htmlTextRef = CJavaAutoText_AC(htmlText);
	
	ThrowIfOSErr_AC(
		::JMNewAppletLocator( &fPointee,
							  CJavaSession_AC::GetSessionRef(),
							  callbacks, 
							  urlTextRef,
							  htmlTextRef,
							  clientData )
					);
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAutoAppletLocator_AC::CJavaAutoAppletLocator_AC
//----------------------------------------------------------------------------------------

CJavaAutoAppletLocator_AC::CJavaAutoAppletLocator_AC(
							JMClientData clientData,
							const CTempJavaAppletLocator_AC& locator)
	// locates an applet synchronously using CTempJavaAppletLocator_AC
{
#if qCarbon
//#pragma message ("Carbon: in CJavaAutoAppletLocator_AC, JMNewAppletLocatorFromInfo not in Carbon")
#pragma unused (clientData, locator)
#else
	ThrowIfOSErr_AC(
		::JMNewAppletLocatorFromInfo( &fPointee,
									  CJavaSession_AC::GetSessionRef(), 
									  &locator,
									  clientData )
					);
#endif
}


//========================================================================================
// CLASS CJavaAppletContainer_AC
//========================================================================================

JMAppletLocatorCallbacks CJavaAppletContainer_AC::fgAppletCallbacks
	 = {	kJMVersion,
			/* CJavaAppletContainer_AC:: */ LocatorCompletedProc };

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::CJavaAppletContainer_AC: 
//----------------------------------------------------------------------------------------

CJavaAppletContainer_AC::CJavaAppletContainer_AC(const CStr255_AC&	url,
												 const CStr255_AC&	htmlText)
	:	fURL(url),
		fAppletLocator(NULL),
		fContextList(::NewList_AC())
{
#if qCarbon
	#pragma unused (url, htmlText)
#elif 1
// •••  10/07/1998 - new implementation
	fAppletLocator = CJavaAutoAppletLocator_AC(&fgAppletCallbacks, JMClientData(this), url, htmlText);
	
#else
// •••  10/07/1998 - old implementation
	// Create the URL text reference.
	JMTextRef	urlTextRef = NULL;
	ThrowIfOSErr_AC(::JMNewTextRef(CJavaSession_AC::GetSessionRef(), &urlTextRef,
								   kTextEncodingMacRoman, &url[1], url.Length()));
		
	// JM will test NULL-ness of the htmlText parameter, not emptiness.
	JMTextRef	htmlTextRef = NULL;
	if (htmlText.Length() > 0)
		ThrowIfOSErr_AC(::JMNewTextRef(CJavaSession_AC::GetSessionRef(), &htmlTextRef,
									   kTextEncodingMacRoman, &htmlText[1], htmlText.Length()));
	
	ThrowIfOSErr_AC(::JMNewAppletLocator(&fAppletLocator,
										 CJavaSession_AC::GetSessionRef(),
										 &fgAppletCallbacks, 
										 urlTextRef,
										 htmlTextRef,
										 (JMClientData) this));

	// Dispose of the URL and HTML text references.
	::JMDisposeTextRef(urlTextRef);
	if (htmlTextRef != NULL)
		::JMDisposeTextRef(htmlTextRef);
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::CJavaAppletContainer_AC: 
//----------------------------------------------------------------------------------------

CJavaAppletContainer_AC::CJavaAppletContainer_AC(const CTempJavaAppletLocator_AC& locator)
	:	fAppletLocator(NULL),
		fContextList(::NewList_AC())
{
#if qCarbon
	#pragma unused (locator)
#else
	fURL = locator.GetURL();
	fAppletLocator = CJavaAutoAppletLocator_AC(JMClientData(this), locator);
	
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC destructor
//----------------------------------------------------------------------------------------

CJavaAppletContainer_AC::~CJavaAppletContainer_AC()
{
	Assertion_AC( fContextList->GetSize() == 0, "CJavaAppletContainer_AC::~CJavaAppletContainer_AC: CJavaAppletContainer_AC deleted while there are some CJavaAppletContext_AC still alive" );
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::GetURL: 
//----------------------------------------------------------------------------------------

CStr255_AC CJavaAppletContainer_AC::GetURL() const
{
	return fURL;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::GetAppletLocator: 
//----------------------------------------------------------------------------------------

JMAppletLocatorRef CJavaAppletContainer_AC::GetAppletLocator()
{
	return fAppletLocator;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::CountApplets: 
//----------------------------------------------------------------------------------------

UInt32 CJavaAppletContainer_AC::CountApplets()
{
	UInt32 actualCount = 0;
#if !qCarbon	
	ThrowIfOSErr_AC(::JMCountApplets(fAppletLocator, &actualCount));
#endif	
	return actualCount;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::GetAppletBounds: 
//----------------------------------------------------------------------------------------

CLongRect_AC CJavaAppletContainer_AC::GetAppletBounds(UInt32 appletIndex)
{
	UInt32	width = 0;
	UInt32	height = 0;
	
#if qCarbon	
	#pragma unused (appletIndex)
#else
	ThrowIfOSErr_AC(::JMGetAppletDimensions(fAppletLocator, appletIndex, &width, &height));
#endif	
	
	return CLongRect_AC(0, 0, width, height);
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::GetAppletName: 
//----------------------------------------------------------------------------------------

CStr255_AC CJavaAppletContainer_AC::GetAppletName(UInt32 appletIndex)
{
#if qCarbon
	#pragma unused (appletIndex)
	return "NoCarbonJava";
#else
	JMTextRef	appletNameRef = NULL;
	ThrowIfOSErr_AC(::JMGetAppletName(fAppletLocator, appletIndex, &appletNameRef));
	return static_cast<CStr255_AC>(CJavaAutoText_AC(appletNameRef));
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::GetAppletTag: 
//----------------------------------------------------------------------------------------

JMTextRef CJavaAppletContainer_AC::GetAppletTag(UInt32 appletIndex)
{
	JMTextRef	appletTagRef = NULL;
#if qCarbon
	#pragma unused (appletIndex)
#else	
	ThrowIfOSErr_AC(::JMGetAppletTag(fAppletLocator, appletIndex, &appletTagRef));
#endif
	return appletTagRef;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::LocatorCompleted: 
//----------------------------------------------------------------------------------------

void CJavaAppletContainer_AC::LocatorCompleted(JMLocatorErrors error)
{
	if (error != eLocatorNoErr)
	{
#if qCoreDebug
		switch (error)
		{
			case eHostNotFound:
				ReportError("Host not found: ", fURL);
				break;
				
			case eFileNotFound:
				ReportError("File not found: ", fURL);
				break;
				
			case eLocatorTimeout:
				ReportError("Timeout accessing: ", fURL);
				break;
			
			default:
				ReportError("Bad URL: ", fURL);
				break;
		}
#endif
		delete this;
	}
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::AddContext: 
//----------------------------------------------------------------------------------------

void CJavaAppletContainer_AC::AddContext(CJavaAppletContext_AC* aJavaAppletContext)
{
	fContextList->Insert(aJavaAppletContext);
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::RemoveContext: 
//----------------------------------------------------------------------------------------

void CJavaAppletContainer_AC::RemoveContext(CJavaAppletContext_AC* aJavaAppletContext)
{
	fContextList->Delete(aJavaAppletContext);
	ArrayIndex_AC count = fContextList->GetSize();
	
	if (count == 0)
		delete this;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::GetLastContext: 
//----------------------------------------------------------------------------------------

CJavaAppletContext_AC* CJavaAppletContainer_AC::GetLastContext()
{
	return reinterpret_cast<CJavaAppletContext_AC*> (fContextList->Last());
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::StartAllApplets: 
//----------------------------------------------------------------------------------------

void CJavaAppletContainer_AC::StartAllApplets()
{
	UInt32 countApplets = CountApplets();
	
	if (countApplets > 0)
	{
		for (UInt32 appletIndex = 0;  appletIndex < countApplets;  ++appletIndex)
			DoMakeContext(appletIndex);
	}
	else
	{
#if qCoreDebug
		ReportError("No applets on page: ", fURL);
#endif
		delete this;
	}
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::DoMakeContext: 
//----------------------------------------------------------------------------------------

CJavaAppletContext_AC* CJavaAppletContainer_AC::DoMakeContext(UInt32 appletIndex)
{
	return TH_new CJavaAppletContext_AC(this, appletIndex);
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::ReportError: 
//----------------------------------------------------------------------------------------

void CJavaAppletContainer_AC::ReportError(const CStr255_AC& errorMsg,
										const CStr255_AC& urlText)
{
	ProgramReport_AC(CChar255_AC(errorMsg + urlText));
}

//----------------------------------------------------------------------------------------
// CJavaAppletContainer_AC::LocatorCompletedProc: 
//----------------------------------------------------------------------------------------

void LocatorCompletedProc(JMAppletLocatorRef ref, JMLocatorErrors status)
{
	if (ref)
	{
		CJavaAppletContainer_AC* appletContainer = NULL;
	
#if qCarbon
//#pragma message ("Carbon: in LocatorCompletedProc, JMGetAppletLocatorData not in Carbon")
#else
		OSStatus err = ::JMGetAppletLocatorData(ref, (JMClientData*) &appletContainer);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaAppletContainer_AC.cpp: OSStatus(%d) returned from JMGetAppletLocatorData()", err);
#endif
#endif
		if (appletContainer)
			appletContainer->LocatorCompleted(status);
	}
}

//========================================================================================
// CLASS CJavaAutoAppletContainer_AC
//========================================================================================

#undef Inherited
#define Inherited CJavaAppletContainer_AC

//----------------------------------------------------------------------------------------
// CJavaAutoAppletContainer_AC::CJavaAutoAppletContainer_AC: 
//----------------------------------------------------------------------------------------

CJavaAutoAppletContainer_AC::CJavaAutoAppletContainer_AC(const CStr255_AC& url,
														 const CStr255_AC& htmlText)
	:	CJavaAppletContainer_AC(url, htmlText)
{
}

//----------------------------------------------------------------------------------------
// CJavaAutoAppletContainer_AC::CJavaAutoAppletContainer_AC: 
//----------------------------------------------------------------------------------------

CJavaAutoAppletContainer_AC::CJavaAutoAppletContainer_AC(const CTempJavaAppletLocator_AC& locator)
	:	CJavaAppletContainer_AC(locator)
{
}

//----------------------------------------------------------------------------------------
// CJavaAutoAppletContainer_AC destructor
//----------------------------------------------------------------------------------------

CJavaAutoAppletContainer_AC::~CJavaAutoAppletContainer_AC()
{
}

//----------------------------------------------------------------------------------------
// CJavaAutoAppletContainer_AC::LocatorCompleted: 
//----------------------------------------------------------------------------------------

void CJavaAutoAppletContainer_AC::LocatorCompleted(JMLocatorErrors error)
{
	if (error != eLocatorNoErr)
		Inherited::LocatorCompleted(error);
	else
		StartAllApplets();
}


//----------------------------------------------------------------------------------------
// End of CJavaAppletContainer_AC.cpp
