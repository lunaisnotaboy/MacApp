//----------------------------------------------------------------------------------------
// CJavaSession_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//
//	Our sincere thanks to Carsten Brinkshulte who graciously contributed his example 
//	Java code in the hopes that the MacApp team would refine it and make it an 
//	official part of MacApp.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		01/02/01	Update copyright.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		01/05/00	Fix implementation of URLToFSSpec to agree with header for Carbon. 
		12/07/99	Include CHandle_AC.h and CJavaText_AC.h.  JavaExitProc, 				// System.exit handler
					JavaAuthentificateURLProc and JavaLowMemoryProc now implemented
					in fgSessionCallbacks.  Check error in ~CJavaSession_AC,
					JavaIdle, JavaMenuSelect.
					Check fgJavaSession in JavaOpen.  Reworked FSSpecToURL and
					URLToFSSpec.  Added Exit, AuthentificateURL, LowMemory,
					JavaExitProc, JavaAuthentificateURLProc and JavaLowMemoryProc.
		11/18/99	Carbon: Java not currently in Carbon; new APIs to come.
		07/23/99	[C] API for JMURLToFSS changed in CarbonLib d10c3 043099
		03/24/99	Update copyright notice.
		12/26/98	Changed API in URLToFSSpec.
		11/13/98	[2279260] Pass ‘url’ not ‘&url’ to JMNewTextRef.
		11/05/98	For CarbonSeed110398, removed special definitions of ConsoleWriteProc and ConsoleErrorProc;
					in CJavaSession_AC::URLToFSSpec API for JMURLToFSS changed
		10/26/98	For Carbon, changed definitions of ConsoleWriteProc and ConsoleErrorProc
		10/07/98	Clean up includes. 
*/

#ifndef __CJavaSession_AC__
#include "CJavaSession_AC.h"
#endif

// ACS

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

#ifndef __MJavaView_AC__
#include "MJavaView_AC.h"
#endif

#ifndef __CJavaAppletContainer_AC__
#include "CJavaAppletContainer_AC.h"
#endif

#ifndef __CFSSpec_AC__
#include "CFSSpec_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CJavaText_AC__
#include "CJavaText_AC.h"
#endif

// ANSI

#ifndef __STDIO__
#include <stdio.h>
#endif

#if qCarbon
	//#pragma message ("Carbon: CJavaSession_AC.cpp: Java not currently in Carbon; new APIs to come.")
#endif

//========================================================================================
// CLASS CJavaSession_AC
//========================================================================================

CJavaSession_AC* CJavaSession_AC::fgInstance = NULL;
JMSessionRef CJavaSession_AC::fgJavaSession = NULL;
MJavaView_AC* CJavaSession_AC::fgActiveJavaView = NULL;
MJavaView_AC* CJavaSession_AC::fgMouseOverJavaView = NULL;

JMSessionCallbacks CJavaSession_AC::fgSessionCallbacks = {
					kJMVersion, 				// the current version
					ConsoleWriteProc, 			// JMConsoleProcPtr
					ConsoleErrorProc, 			// JMConsoleProcPtr
					ConsoleReadProc,			// JMConsoleReadProcPtr
					JavaExitProc, 				// System.exit handler
					JavaAuthentificateURLProc, 	// URL Authentication handler
					JavaLowMemoryProc 			// Low memory condition handler
};

//----------------------------------------------------------------------------------------
// CJavaSession_AC constructor
//----------------------------------------------------------------------------------------

CJavaSession_AC::CJavaSession_AC() :
	fStatus(noErr)
{
	fgInstance = this;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC destructor
//----------------------------------------------------------------------------------------

CJavaSession_AC::~CJavaSession_AC()
{
	if (fgJavaSession)
	{
#if !qCarbon
		OSStatus err = ::JMCloseSession(fgJavaSession);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaSession_AC::~CJavaSession_AC: OSStatus(%d) returned from JMCloseSession()", err);
#endif
#endif
		fgJavaSession = NULL;
	}
	fgInstance = NULL;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::JavaOpen:
//----------------------------------------------------------------------------------------

void CJavaSession_AC::JavaOpen()
{
#if !qCarbon
	if (!fgJavaSession)
		fStatus = ::JMOpenSession(&fgJavaSession,
								  eJManager2Defaults,
								  eCheckRemoteCode,
								  &fgSessionCallbacks,
								  kTextEncodingMacRoman,
								  0);
#endif
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::JavaIdle:
//----------------------------------------------------------------------------------------

void CJavaSession_AC::JavaIdle()
{
#if! qCarbon
	{
		CTempGrafPort_AC	saveThePort();	
	
		OSStatus err = ::JMIdle(fgJavaSession, kDefaultJMTime);	// This sometimes changes the GrafPort
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaSession_AC::JavaIdle: OSStatus(%d) returned from JMIdle()", err);
#endif
	}
	
	if (fgMouseOverJavaView)
		fgMouseOverJavaView->JavaIdle();
#endif
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::JavaMenuSelect: 
//----------------------------------------------------------------------------------------

void CJavaSession_AC::JavaMenuSelect(short theMenuNumber, short theItemNumber)
{
#if qCarbon
	#pragma unused (theMenuNumber, theItemNumber)
#else
	if (fgActiveJavaView)
	{
		JMAWTContextRef context = fgActiveJavaView->GetAWTContext();
		
		OSStatus err = ::JMMenuSelected(context, GetMenuHandle(theMenuNumber), theItemNumber);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaSession_AC::JavaMenuSelect: OSStatus(%d) returned from JMMenuSelected()", err);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::NewMenuIDRequest: 
//----------------------------------------------------------------------------------------

short CJavaSession_AC::NewMenuIDRequest(JMAWTContextRef /* ref */, bool isHier)
{
	static short theNormalMenus	= 20000;
	static short theHierMenus	= 128;
	
	return isHier? theHierMenus++ : theNormalMenus++;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::GetActiveJavaView: 
//----------------------------------------------------------------------------------------

MJavaView_AC* CJavaSession_AC::GetActiveJavaView()
{
	return fgActiveJavaView;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::SetActiveJavaView: 
//----------------------------------------------------------------------------------------

void CJavaSession_AC::SetActiveJavaView(MJavaView_AC* activeJavaView)
{
	fgActiveJavaView = activeJavaView;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::GetActiveJavaContext: 
//----------------------------------------------------------------------------------------

CJavaAppletContext_AC* CJavaSession_AC::GetActiveJavaContext()
{
	CJavaAppletContext_AC* aJavaAppletContext = NULL;
	
	MJavaView_AC* aJavaView = GetActiveJavaView();
	
	if (aJavaView)
		aJavaAppletContext = aJavaView->GetJavaAppletContext();
	
	return aJavaAppletContext;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::GetMouseOverJavaView: 
//----------------------------------------------------------------------------------------

MJavaView_AC* CJavaSession_AC::GetMouseOverJavaView()
{
	return fgMouseOverJavaView;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::SetMouseOverJavaView: 
//----------------------------------------------------------------------------------------

void CJavaSession_AC::SetMouseOverJavaView(MJavaView_AC* mouseOverJavaView)
{
	fgMouseOverJavaView = mouseOverJavaView;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::AddToClassPath: 
//----------------------------------------------------------------------------------------

void CJavaSession_AC::AddToClassPath(const CFSSpec_AC& spec)
{
#if qCarbon
	#pragma unused (spec)
#else
	// JMAddToClassPath requires a fully qualified FSSpec - no partial paths (this is a known bug)
	
	CFSSpec_AC fullSpec;
	
	ThrowIfOSErr_AC(::FSMakeFSSpec(spec.vRefNum, spec.parID, spec.name, &fullSpec));	
	ThrowIfOSErr_AC(::JMAddToClassPath(fgJavaSession, &fullSpec));
#endif
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::FSSpecToURL: 
//----------------------------------------------------------------------------------------

Handle CJavaSession_AC::FSSpecToURLHandle(const CFSSpec_AC& spec)
{
#if qCarbon
	#pragma unused (spec)
	return NULL;
#else
	return ::JMFSSToURL(fgJavaSession, &spec);
#endif
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::FSSpecToURL: 
//----------------------------------------------------------------------------------------

CStr255_AC CJavaSession_AC::FSSpecToURL(const CFSSpec_AC& spec)
{
	CStr255_AC url;
	
	CTempHandle_AC handle = FSSpecToURLHandle(spec);
	
	if (handle.get())
	{
		CTempHLock_AC lockit(handle.get());
		url.CopyFrom(*handle.get(), ::GetHandleSize(handle));
	}
	return url;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::URLToFSSpec: 
//----------------------------------------------------------------------------------------

#if qCarbon
void CJavaSession_AC::URLToFSSpec(JMTextRef url, CFSSpec_AC& spec)
{
#pragma unused (url, spec)
}
#else
void CJavaSession_AC::URLToFSSpec(const char* url, CFSSpec_AC& spec)
{
	CJavaAutoText_AC tempURL(url);
	ThrowIfOSErr_AC(::JMURLToFSS(fgJavaSession, tempURL, &spec));
}
#endif

//----------------------------------------------------------------------------------------
// CJavaSession_AC::FilterEndOfLineChars: 
//----------------------------------------------------------------------------------------

void CJavaSession_AC::FilterEndOfLineChars(char* text, UInt32 length)
{
	if (text)
	{
		char* p = text;
		char* pEnd = p + length;
		while (p < pEnd) {
			if (*p++ == '\r')
				p[-1] = '\n';
		}
	}
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::StdOut: 
//----------------------------------------------------------------------------------------

void CJavaSession_AC::StdOut(const char* message, UInt32 messageLen)
{
	fwrite(message, messageLen, 1, stdout);
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::StdErr: 
//----------------------------------------------------------------------------------------

void CJavaSession_AC::StdErr(const char* message, UInt32 messageLen)
{
	fwrite(message, messageLen, 1, stderr);
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::StdIn: 
//----------------------------------------------------------------------------------------

SInt32 CJavaSession_AC::StdIn(char* buffer, SInt32 maxBufferLength)
{
	return fread(buffer, maxBufferLength, 1, stdin);
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::Exit
//----------------------------------------------------------------------------------------

bool CJavaSession_AC::Exit(SInt32 status)
{
	#pragma unused (status)
	return true;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::AuthentificateURL
//----------------------------------------------------------------------------------------

bool CJavaSession_AC::AuthentificateURL(const char*		url,
										const char*		realm,
										char			userName[255],
										char			password[255])
{
	#pragma unused (url, realm)
	
	// Should be overriden to be useful.
	userName[0] = '\0';
	password[0] = '\0';
	return false;
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::LowMemory
//----------------------------------------------------------------------------------------

void CJavaSession_AC::LowMemory()
{ }	// Should be overriden to be useful.



//----------------------------------------------------------------------------------------
// CJavaSession_AC::ConsoleWriteProc: 
//----------------------------------------------------------------------------------------
extern "C" void ConsoleWriteProc(JMSessionRef session, const void* message, JavaProcMsgLenType messageLen)
{
	#pragma unused (session)
	CJavaSession_AC::Instance()->StdOut(static_cast<const char*>(message), messageLen);
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::ConsoleErrorProc: 
//----------------------------------------------------------------------------------------
extern "C" void ConsoleErrorProc(JMSessionRef session, const void* message, JavaProcMsgLenType messageLen)

{
	#pragma unused (session)
	CJavaSession_AC::Instance()->StdErr(static_cast<const char*>(message), messageLen);
}

//----------------------------------------------------------------------------------------
// CJavaSession_AC::ConsoleReadProc: 
//----------------------------------------------------------------------------------------

extern "C" SInt32 ConsoleReadProc(JMSessionRef session, void* buffer, SInt32 maxBufferLength)
{
	#pragma unused (session)
	return CJavaSession_AC::Instance()->StdIn(static_cast<char*>(buffer), maxBufferLength);
}

//----------------------------------------------------------------------------------------
// ::JavaExitProc: 
//----------------------------------------------------------------------------------------

Boolean JavaExitProc(JMSessionRef session, SInt32 status)
{
	#pragma unused (session)
	return CJavaSession_AC::Instance()->Exit(status);
}

//----------------------------------------------------------------------------------------
// ::JavaAuthentificateURLProc: 
//----------------------------------------------------------------------------------------

Boolean JavaAuthentificateURLProc(JMSessionRef session, const char *url, const char *realm, char userName[255], char password[255])
{
	#pragma unused (session)
	return CJavaSession_AC::Instance()->AuthentificateURL(url, realm, userName, password);
}

//----------------------------------------------------------------------------------------
// ::JavaLowMemoryProc: 
//----------------------------------------------------------------------------------------

void JavaLowMemoryProc(JMSessionRef session)
{
	#pragma unused (session)
	CJavaSession_AC::Instance()->LowMemory();
}

//----------------------------------------------------------------------------------------
// End of CJavaSession_AC.cpp