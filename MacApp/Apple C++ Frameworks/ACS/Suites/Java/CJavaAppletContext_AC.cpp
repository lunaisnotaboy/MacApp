//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//
//	Our sincere thanks to Carsten Brinkshulte who graciously contributed his example 
//	Java code in the hopes that the MacApp team would refine it and make it an 
//	official part of MacApp.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		01/19/01	Pass a CString_AC to StatusMessageRequest in AVSetStatusMsgProc.
		01/02/01	Update copyright.
		09/01/00	Stripped dead code.
		05/23/00	[2279264] Remove false from ProgramReport_AC. 
		01/05/00	Move calls to Java runtime out of line. 
					Conditionalize calls not in Carbon. 
		12/27/99	Stripped out unused code.
		12/07/99	Include CJavaText_AC.h.  Changed initialization in CJavaAppletContext_AC
					ctor.  Simplify ~CJavaAppletContext_AC.  Added error checking in
					QueueExecution, ReloadApplet, RestartApplet, SuspendApplet,
					ResumeApplet and GetContext.
					Do a NULL check in GetContext.  Initialize with 0 in
					CountContextFrames.  NewMenuIDProc now returns an SInt16.
					Simplify ExceptionOccurredProc.  Added cast in AVShowDocumentProc
					and AVSetStatusMsgProc.
		11/18/99	Use "#pragma unused" instead of commenting out variables.
					Carbon: Java isn't supported yet in Carbon, so take out references.
		03/24/99	Update copyright notice.
		10/07/98	Clean up includes. 
*/

#ifndef __CJavaAppletContext_AC__
#include "CJavaAppletContext_AC.h"
#endif

#ifndef __CJavaText_AC__
#include "CJavaText_AC.h"
#endif

// ACS

#ifndef __CJavaAppletContainer_AC__
#include "CJavaAppletContainer_AC.h"
#endif

#ifndef __CJavaSession_AC__
#include "CJavaSession_AC.h"
#endif

#ifndef __MJavaView_AC__
#include "MJavaView_AC.h"
#endif

#ifndef __CList_AC__
#include "CList_AC.h"
#endif

// Java

#ifndef __JMANAGER__
#include <JManager.h>
#endif

// ANSI

#ifndef __STDIO__
#include <stdio.h>
#endif

#if qCarbon
//#pragma message ("Carbon: CJavaAppletContext_AC.cpp: Java not currently in Carbon; new APIs to come.")
#endif

//========================================================================================
// class CJavaAWTContextDeleter_AC 
//========================================================================================

//----------------------------------------------------------------------------------------
// CJavaAWTContextDeleter_AC::DeleteRef
//----------------------------------------------------------------------------------------

void CJavaAWTContextDeleter_AC::DeleteRef(JMAWTContextRef context)
{
#if qCarbon
//#pragma message ("Carbon: in CJavaAWTContextDeleter_AC::DeleteRef, JMDisposeAWTContext not in Carbon")
#pragma unused (context)
#else
	if (context)
		ThrowIfOSErr_AC(::JMDisposeAWTContext(context));
#endif
}

//========================================================================================
// class CJavaAutoAWTContext_AC 
//========================================================================================

//----------------------------------------------------------------------------------------
// CJavaAutoAWTContext_AC ctor
//----------------------------------------------------------------------------------------

CJavaAutoAWTContext_AC::CJavaAutoAWTContext_AC(	const JMAWTContextCallbacks* callbacks,
												JMClientData data )
// Creates an AWT context
{
#if qCarbon
//#pragma message ("Carbon: in CJavaAutoAWTContext_AC, JMNewAWTContext not in Carbon")
#pragma unused (callbacks, data)
#else
	ThrowIfOSErr_AC(
		::JMNewAWTContext(	&fPointee,
							CJavaSession_AC::GetSessionRef(),
							callbacks,
							data )
					);
#endif
}


//========================================================================================
// class CJavaAppletViewerDeleter_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CJavaAppletViewerDeleter_AC::DeleteRef
//----------------------------------------------------------------------------------------

void CJavaAppletViewerDeleter_AC::DeleteRef(JMAppletViewerRef viewerRef)
{
#if qCarbon
//#pragma message ("Carbon: in CJavaAppletViewerDeleter_AC::DeleteRef, JMDisposeAppletViewer not in Carbon")
#pragma unused (viewerRef)
#else
	if (viewerRef)
		ThrowIfOSErr_AC(::JMDisposeAppletViewer(viewerRef));
#endif
}

//========================================================================================
// class CJavaAutoAppletViewer_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CJavaAutoAppletViewer_AC ctor
//----------------------------------------------------------------------------------------

CJavaAutoAppletViewer_AC::CJavaAutoAppletViewer_AC(	JMAWTContextRef context,
													JMAppletLocatorRef locatorRef,
													UInt32 appletIndex,
													const JMAppletSecurity* security,
													const JMAppletViewerCallbacks* callbacks,
													JMClientData data)
	// instantiates an applet
{
#if qCarbon
//#pragma message ("Carbon: in CJavaAutoAppletViewer_AC, JMNewAppletViewer not in Carbon")
#pragma unused (context, locatorRef, appletIndex, security, callbacks, data)
#else
	ThrowIfOSErr_AC(
		::JMNewAppletViewer(	&fPointee,
								context,
								locatorRef,
								appletIndex,
								security,
								callbacks,
								data )
					);
#endif
}


//========================================================================================
// CLASS CJavaAppletContext_AC
//========================================================================================

JMAWTContextCallbacks CJavaAppletContext_AC::fgContextCallbacks
			 = {	kJMVersion,
					/* CJavaAppletContext_AC:: */ RequestFrameProc,		// JMRequestFrameProcPtr
					/* CJavaAppletContext_AC:: */ ReleaseFrameProc,		// JMReleaseFrameProcPtr
					/* CJavaAppletContext_AC:: */ NewMenuIDProc,			// JMUniqueMenuIDProcPtr
					/* CJavaAppletContext_AC:: */ ExceptionOccurredProc };	// JMExceptionOccurredProcPtr


JMAppletViewerCallbacks CJavaAppletContext_AC::fgAppletViewerCallbacks
			 = {	kJMVersion,
					/* CJavaAppletContext_AC:: */ AVShowDocumentProc,		// JMShowDocumentProcPtr
					/* CJavaAppletContext_AC:: */ AVSetStatusMsgProc };	// JMSetStatusMsgProcPtr

JMAppletSecurity CJavaAppletContext_AC::fgAppletSecurity
			= {
					kJMVersion,			// should be set to kJMVersion
					eUnrestrictedAccess,// can this applet access network resources
					eAllFSAccess,		// can this applet access network resources
					false,				// restrict access to system packages (com.apple.*, sun.*, netscape.*) also found in the property "mrj.security.system.access"
					false,				// restrict classes from loading system packages (com.apple.*, sun.*, netscape.*) also found in the property "mrj.security.system.define"
					false,				// restrict access to application packages found in the property "mrj.security.application.access"
					false };			// restrict access to application packages found in the property "mrj.security.application.access" 

//----------------------------------------------------------------------------------------
// 
//----------------------------------------------------------------------------------------

CJavaAppletContext_AC::CJavaAppletContext_AC(CJavaAppletContainer_AC* appletContainer, UInt32 appletIndex) :
	fAppletContainer(NULL),
	fAppletViewer(NULL),
	fAWTContext(NULL),
	fAppletIndex(0),
	fNextJavaView(NULL),
	fJavaViewList(::NewList_AC())
{
	SetAppletContainer(appletContainer);
	SetAppletIndex(appletIndex);
	appletContainer->AddContext(this);
	
	// Context
	
	fAWTContext = CJavaAutoAWTContext_AC(&fgContextCallbacks, JMClientData(this));

	// now create an applet viewer

	fAppletViewer = CJavaAutoAppletViewer_AC(	fAWTContext,
												appletContainer->GetAppletLocator(),
												appletIndex,
												&fgAppletSecurity,
												&fgAppletViewerCallbacks,
												(JMClientData) this);
	
	ReloadApplet(); // non-virtual call
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC destructor
//----------------------------------------------------------------------------------------

CJavaAppletContext_AC::~CJavaAppletContext_AC()
{
#if !qCarbon
	fAppletViewer.reset();
	fAWTContext.reset();
	fAppletTag.reset();
#endif
	
	CJavaAppletContainer_AC* aJavaAppletContainer = GetAppletContainer();	
	if (aJavaAppletContainer)
		aJavaAppletContainer->RemoveContext(this);
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::AddView: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::AddView(MJavaView_AC* aJavaView)
{
	fJavaViewList->Insert(aJavaView);
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::RemoveView: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::RemoveView(MJavaView_AC* aJavaView)
{
	fJavaViewList->Delete(aJavaView);
	ArrayIndex_AC count = fJavaViewList->GetSize();
	
	if (count == 0)
		delete this;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::GetAppletContainer: 
//----------------------------------------------------------------------------------------

CJavaAppletContainer_AC* CJavaAppletContext_AC::GetAppletContainer()
{
	return fAppletContainer;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::SetAppletContainer: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::SetAppletContainer(CJavaAppletContainer_AC* appletContainer)
{
	fAppletContainer = appletContainer;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::GetAppletIndex: 
//----------------------------------------------------------------------------------------

UInt32 CJavaAppletContext_AC::GetAppletIndex()
{
	return fAppletIndex;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::SetAppletIndex: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::SetAppletIndex(UInt32 appletIndex)
{
	fAppletIndex = appletIndex;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::GetAppletTag: 
//----------------------------------------------------------------------------------------

JMTextRef CJavaAppletContext_AC::GetAppletTag()
{
	JMTextRef appletTag = NULL;
	
	UInt32 appletIndex	= GetAppletIndex();
	CJavaAppletContainer_AC* aJavaAppletContainer = GetAppletContainer();
	
	if (aJavaAppletContainer)
		appletTag = aJavaAppletContainer->GetAppletTag(appletIndex);
	
	return appletTag;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::GetAppletViewer: 
//----------------------------------------------------------------------------------------

JMAppletViewerRef CJavaAppletContext_AC::GetAppletViewer()
{
	return fAppletViewer;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::GetAWTContext: 
//----------------------------------------------------------------------------------------

JMAWTContextRef CJavaAppletContext_AC::GetAWTContext()
{
	return fAWTContext;
}

//----------------------------------------------------------------------------------------
// TJavaAppletContext::SetNextJavaView: 
//----------------------------------------------------------------------------------------
void CJavaAppletContext_AC::SetNextJavaView(MJavaView_AC* aJavaView)
{
	fNextJavaView = aJavaView;
}

//----------------------------------------------------------------------------------------
// TJavaAppletContext::GetNextJavaView: 
//----------------------------------------------------------------------------------------
MJavaView_AC* CJavaAppletContext_AC::GetNextJavaView()
{
	return fNextJavaView;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::CountContextFrames: 
//----------------------------------------------------------------------------------------

UInt32 CJavaAppletContext_AC::CountContextFrames()
{
	UInt32 countFrames = 0;
	
#if !qCarbon
	ThrowIfOSErr_AC(::JMCountAWTContextFrames(fAWTContext, &countFrames));
#endif	
	return countFrames;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::GetIndFrame: 
//----------------------------------------------------------------------------------------

JMFrameRef CJavaAppletContext_AC::GetIndFrame(UInt32 frameIndex)
{
	JMFrameRef frame = NULL;
	
#if qCarbon
	#pragma unused (frameIndex)
#else
	ThrowIfOSErr_AC(::JMGetAWTContextFrame(fAWTContext, frameIndex, &frame));
#endif	
	return frame;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::ReloadApplet: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::ReloadApplet()
{
#if !qCarbon
	if (fAppletViewer)
	{
		OSStatus err = ::JMReloadApplet(fAppletViewer);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaAppletContext_AC::ReloadApplet: OSStatus(%d) returned from JMReloadApplet()", err);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::RestartApplet: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::RestartApplet()
{
#if !qCarbon
	JMFrameRef frame = NULL;
	MJavaView_AC* aJavaView = NULL;
	OSStatus err;
	CRect_AC frameRect;
	bool resizeOK;
	
	if (fAppletViewer)
	{
		err = ::JMRestartApplet(fAppletViewer);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaAppletContext_AC::RestartApplet: OSStatus(%d) returned from JMRestartApplet()", err);
#endif
		UInt32 countFrames = CountContextFrames();
		
		for (UInt32 frameIndex = 0; frameIndex < countFrames; frameIndex++)
		{
			frame = GetIndFrame(frameIndex);
			
			if (frame)
			{
				err = ::JMGetFrameSize(frame, &frameRect);		
				if (err == noErr)
				{
					aJavaView = MJavaView_AC::JavaViewFromFrameRef(frame);
					resizeOK = aJavaView->ResizeRequest(frameRect);
					
					if (!resizeOK)
					{
						err = ::JMSetFrameSize(frame, &frameRect);
#if qDebugMsg
						if ( err != noErr ) ProgramReport_AC("CJavaAppletContext_AC::RestartApplet: OSStatus(%d) returned from JMSetFrameSize()", err);
#endif
					}
				}
#if qDebugMsg
				else ProgramReport_AC("CJavaAppletContext_AC::RestartApplet: OSStatus(%d) returned from JMGetFrameSize()", err);	
#endif
			}
		}
	}
#endif
}
	
//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::SuspendApplet: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::SuspendApplet()
{
#if !qCarbon
	if (fAppletViewer)
	{
		OSStatus err = ::JMSuspendApplet(fAppletViewer);
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaAppletContext_AC::SuspendApplet: OSStatus(%d) returned from JMSuspendApplet()", err);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::ResumeApplet: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::ResumeApplet()
{
#if !qCarbon
	if (fAppletViewer)
	{
		OSStatus err = ::JMResumeApplet(fAppletViewer);
#if qDebugMsg
		if (err != noErr)
			ProgramReport_AC("CJavaAppletContext_AC::ResumeApplet: OSStatus(%d) returned from JMResumeApplet()", err);
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::GetContext: 
//----------------------------------------------------------------------------------------

CJavaAppletContext_AC* CJavaAppletContext_AC::GetContext(JMAWTContextRef context) // static
{
	CJavaAppletContext_AC* aJavaAppletContext = NULL;
#if qCarbon
	#pragma unused (context)
#else
	if (context)
	{
		OSStatus err = ::JMGetAWTContextData(context, &reinterpret_cast<JMClientData&>(aJavaAppletContext));
#if qDebugMsg
		if ( err != noErr ) ProgramReport_AC("CJavaAppletContext_AC::GetContext: OSStatus(%d) returned from JMGetAWTContextData()", err);
#endif
	}
#endif
	return aJavaAppletContext;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::NewMenuIDProc: 
//----------------------------------------------------------------------------------------

extern "C" SInt16 NewMenuIDProc(JMAWTContextRef ref, Boolean isHier)
{
	return CJavaSession_AC::Instance()->NewMenuIDRequest(ref, isHier);
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::ExceptionOccurredProc:
//----------------------------------------------------------------------------------------

extern "C" void ExceptionOccurredProc(JMAWTContextRef	context,
									  JMTextRef			exceptionName,
									  JMTextRef			exceptionMsg,
									  JMTextRef			stackTrace)
{
#if qCarbon
	#pragma unused (context, exceptionName, exceptionMsg, stackTrace)
#else
	#pragma unused (context)
	// Convert the components of the exception message into proper strings.
	CTempHandle_AC hExceptionName = ::JMTextToMacOSCStringHandle(exceptionName);
	CTempHandle_AC hExceptionMsg = NULL;
	if ( exceptionMsg != NULL)
		hExceptionMsg = ::JMTextToMacOSCStringHandle(exceptionMsg);
	
	// Display an exception message.
	{
		CTempHLock_AC lockName(hExceptionName);
		CTempHLock_AC lockMsg(hExceptionMsg);
		
		fprintf(stderr, "_exceptionOccurred: %s (%s)\r", *hExceptionName,
				hExceptionMsg.IsNULL()? "" : *hExceptionMsg);
	}

	// Display the stack trace.
	if (stackTrace != NULL)
	{
		CTempHandle_AC hStackTrace = ::JMTextToMacOSCStringHandle(stackTrace);
		{
			CTempHLock_AC lockIt(hStackTrace);
			fwrite(*hStackTrace, GetHandleSize(hStackTrace), 1, stderr);
		}
	}
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::RequestFrame: 
//----------------------------------------------------------------------------------------

void CJavaAppletContext_AC::RequestFrame(JMAWTContextRef context,
										JMFrameRef newFrame,
										JMFrameKind kind,
										const CLongPoint_AC& initialSize,
										bool resizeable,
										JMFrameCallbacks* callbacks)
{
	CJavaSession_AC::Instance()->RequestFrame(context, newFrame, kind, initialSize, resizeable, callbacks);
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::RequestFrameProc: 
//----------------------------------------------------------------------------------------

extern "C" OSStatus /* CJavaAppletContext_AC:: */
								RequestFrameProc(JMAWTContextRef	context,
												 JMFrameRef			newFrame,
												 JMFrameKind		kind,
												 const Rect*		initialBounds,
												 Boolean			resizeable,
												 JMFrameCallbacks*	callbacks)
{
	OSStatus err = noErr;
	CLongRect_AC	bounds(*initialBounds);
	try
	{
		CJavaAppletContext_AC* appletContext = CJavaAppletContext_AC::GetContext(context);
		ThrowIfNULL_AC(appletContext);// ??? Is this appropriate under all circumstances?
		appletContext->RequestFrame(context, newFrame, kind, bounds.GetSize(), resizeable, callbacks);
	}
	catch (CException_AC& theException)
	{
		err = theException.GetError();
	}	
	return err;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::ReleaseFrameProc: 
//----------------------------------------------------------------------------------------

extern "C" OSStatus /* CJavaAppletContext_AC:: */ 
								ReleaseFrameProc(JMAWTContextRef /* context */,
												 JMFrameRef oldFrame)
{
	MJavaView_AC* aJavaView = MJavaView_AC::JavaViewFromFrameRef(oldFrame);
	
	if (aJavaView)
		aJavaView->ReleaseFrameRequest();
	
	return noErr;
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::AVShowDocumentProc: 
//----------------------------------------------------------------------------------------

extern "C" void AVShowDocumentProc( JMAppletViewerRef	viewer,
									JMTextRef			urlString,
									JMTextRef			windowName)
{
	CJavaAppletContext_AC* appletContext = NULL;
	
#if qCarbon
	#pragma unused (viewer, urlString, windowName)
#else
	#pragma unused (urlString, windowName)
	ThrowIfOSErr_AC (::JMGetAppletViewerData(viewer, &reinterpret_cast<JMClientData&>(appletContext)));
#endif
}

//----------------------------------------------------------------------------------------
// CJavaAppletContext_AC::AVSetStatusMsgProc: 
//----------------------------------------------------------------------------------------

extern "C" void AVSetStatusMsgProc(	JMAppletViewerRef	viewer, 
									JMTextRef			statusMsg)
{
#if qCarbon
	#pragma unused (viewer, statusMsg)
#else
	CJavaAppletContext_AC* appletContext = NULL;
	
	ThrowIfOSErr_AC (::JMGetAppletViewerData(viewer, &reinterpret_cast<JMClientData&>(appletContext)));
	
	if (appletContext)
	{
		JMAWTContextRef context = appletContext->GetAWTContext();
		MJavaView_AC* aJavaView = MJavaView_AC::JavaViewFromContextRef(context);

		if (aJavaView)
			aJavaView->StatusMessageRequest(CJavaText_AC(statusMsg));
	}
#endif
}

//----------------------------------------------------------------------------------------
// End of CJavaAppletContext_AC.cpp
