//----------------------------------------------------------------------------------------
// CJavaText_AC.cpp
// Copyright © 1988-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		01/19/01	Added ToCString.
		01/02/01	Update copyright.
		01/05/00	Move calls to Java runtime out of line. 
							Conditionalize calls not in Carbon. 
*/

#ifndef __CJavaText_AC__
#include "CJavaText_AC.h"
#endif

// Suite

// ACS

// Java

#ifndef __JMANAGER__
#include <JManager.h>
#endif

// ANSI

#ifndef __STRING__
#include <string.h>
#endif


#if qCarbon
	//#pragma message ("Carbon: CJavaText_AC.cpp: Java not currently in Carbon; new APIs to come.")
#endif

//========================================================================================
// class CJavaTextRef_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CJavaTextRef_AC::NewTextRef
//----------------------------------------------------------------------------------------

JMTextRef CJavaTextRef_AC::NewTextRef(const CStr255_AC& inStr, JMTextEncoding encoding)
	// construct from CStr255_AC
{
	JMTextRef textRef = NULL;

#if qCarbon
//#pragma message ("Carbon: in CJavaTextRef_AC::NewTextRef, JMNewTextRef not in Carbon")
#pragma unused (inStr, encoding)
#else
	ThrowIfOSErr_AC(
		::JMNewTextRef(	CJavaSession_AC::GetSessionRef(),
						&textRef,
						encoding,
						&inStr[1],
						inStr.Length() )
					);
#endif
					
	return textRef;
}

//----------------------------------------------------------------------------------------
// CJavaTextRef_AC::NewTextRef
//----------------------------------------------------------------------------------------

JMTextRef CJavaTextRef_AC::NewTextRef(const char* inStr, JMTextEncoding encoding)
	// construct from c-string
{
	JMTextRef textRef = NULL;
	
#if qCarbon
//#pragma message ("Carbon: CJavaTextRef_AC::NewTextRef, JMNewTextRef not in Carbon")
#pragma unused (inStr, encoding)
#else
	ThrowIfOSErr_AC(
		::JMNewTextRef(	CJavaSession_AC::GetSessionRef(),
						&textRef,
						encoding,
						inStr,
						strlen(inStr) )
					);
#endif

	return textRef;
}

//----------------------------------------------------------------------------------------
// CJavaTextRef_AC::CopyTextRef
//----------------------------------------------------------------------------------------

JMTextRef CJavaTextRef_AC::CopyTextRef(const JMTextRef textRefSrc)
	// deep copy
{
	JMTextRef duplicated = NULL;
#if qCarbon
//#pragma message ("Carbon: in CJavaTextRef_AC::CopyTextRef, JMCopyTextRef not in Carbon")
#pragma unused (textRefSrc)
#else
	ThrowIfOSErr_AC( JMCopyTextRef(textRefSrc, &duplicated) );
#endif
	return duplicated;
}

//----------------------------------------------------------------------------------------
// CJavaTextRef_AC::ToHandle
//----------------------------------------------------------------------------------------

Handle CJavaTextRef_AC::ToHandle(const JMTextRef textRef)
	// convert to text handle
{
	CTempHandle_AC hText;
#if qCarbon
//#pragma message ("Carbon: in CJavaTextRef_AC::ToHandle, JMTextToMacOSCStringHandle not in Carbon")
#pragma unused (textRef)
#else
	hText = ::JMTextToMacOSCStringHandle(textRef);
	ThrowIfNULL_AC(hText.get());
#endif
	return hText.release();
}
	
//----------------------------------------------------------------------------------------
// CJavaTextRef_AC::ToStr255
//----------------------------------------------------------------------------------------

CStr255_AC CJavaTextRef_AC::ToStr255(JMTextRef textRef)
	// convert to CStr255_AC
{
	CStr255_AC str;
	CTempHandle_AC hText(ToHandle(textRef));
	if (!hText.IsNULL())
	{
		CTempHLock_AC lockit(hText.get());
		str.CopyFrom(*hText.get(), ::GetHandleSize(hText.get()));
	}
	return str;
}

//----------------------------------------------------------------------------------------
// CJavaTextRef_AC::ToCString
//----------------------------------------------------------------------------------------

CString_AC CJavaTextRef_AC::ToCString(JMTextRef textRef)
// convert to CString_AC
{
	CTempHandle_AC hText(ToHandle(textRef));
	if (!hText.IsNULL())
	{
		CTempHLock_AC lockit(hText.get());
		return CString_AC(*hText.get(), ::GetHandleSize(hText.get()));
	}
	return CString_AC();
}

//========================================================================================
// class CJavaTextDeleter_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CJavaTextDeleter_AC::DeleteRef
//----------------------------------------------------------------------------------------

void CJavaTextDeleter_AC::DeleteRef(JMTextRef textRef)
{
#if qCarbon
//#pragma message ("Carbon: in CJavaTextDeleter_AC::DeleteRef, JMDisposeTextRef not in Carbon")
#pragma unused (textRef)
#else
	if (textRef)
		ThrowIfOSErr_AC(::JMDisposeTextRef(textRef));
#endif
}

//========================================================================================
// Global Functions
//========================================================================================

static void Test()
{
	CJavaAutoText_AC testAutoText;
	CJavaText_AC testText;
}

//----------------------------------------------------------------------------------------
// End of CJavaText_AC.cpp