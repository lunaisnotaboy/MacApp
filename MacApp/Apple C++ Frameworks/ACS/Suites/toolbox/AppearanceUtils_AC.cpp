//----------------------------------------------------------------------------------------
// AppearanceUtils_AC.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/09/00	Tick value in DelayFutureWhileStillDown_AC should be unsigned. 
		09/11/00	HasAppearanceMgr_AC(): Assume appearance manager is 
					always installed and available for Carbon, so inline it for Carbon.
		07/24/00	Carbon: don't abort if appearance client is already registered. 
		02/22/00	[W] Changed HasAppearance_AC and several other functions to
					short-circuit for Windows.
		03/24/99	Update copyright notice.
		11/13/98	[Carbon] use TickCount instead of LMGetTicks
		10/06/98	Clean up includes. 
*/

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// Toolbox

#ifndef __GESTALT__
#include <Gestalt.h>
#endif

#ifndef __OSUTILS__
#include <OSUtils.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __APPEARANCE__
#include <Appearance.h>
#endif

#if !qMSWindows

//----------------------------------------------------------------------------------------
// RegisterAppearance_AC
//----------------------------------------------------------------------------------------

void RegisterAppearance_AC()
{
	if (HasAppearanceMgr_AC())
	{
		OSStatus err = ::RegisterAppearanceClient();
#if qCarbon
		if (err != themeProcessRegisteredErr)
#endif
			::ThrowIfOSErr_AC((OSErr) err);
	}
}

//----------------------------------------------------------------------------------------
// TerminateAGA_AC
//----------------------------------------------------------------------------------------

void UnregisterAppearance_AC()
{
	if (HasAppearanceMgr_AC())
	{
		OSStatus err = ::UnregisterAppearanceClient();
#if qCoreDebug
		if (err != noErr)
			ProgramReport_AC("call to UnregisterAppearanceClient failed.");
#endif
	}
}

#if !qCarbon
//----------------------------------------------------------------------------------------
// HasAppearanceMgr_AC
//----------------------------------------------------------------------------------------

bool HasAppearanceMgr_AC()
{
	static bool hasAppearanceMgr = false;
	static bool	hasAppearanceMgrInitialized = false;
	if (!hasAppearanceMgrInitialized)
	{
		hasAppearanceMgrInitialized = true;
	
		// Check for presence of the Appearance Manager.
		// Note that we also test for compatibility mode and honor that if Appearance isn't required.
		SInt32	gestaltResponse;
		OSErr result = ::Gestalt(gestaltAppearanceAttr, &gestaltResponse);
		hasAppearanceMgr = (result == noErr) && 
#if !qNeedsAppearance
							((gestaltResponse & (1 << gestaltAppearanceCompatMode)) == 0) &&
#endif
							((gestaltResponse & (1 << gestaltAppearanceExists)) != 0);
	}
	return hasAppearanceMgr;
}
#endif

//----------------------------------------------------------------------------------------
// AppearanceMgrVersion_AC
//----------------------------------------------------------------------------------------

SInt32 AppearanceMgrVersion_AC()
{
	static bool	appearanceMgrVersionInitialized = false;
	static SInt32 appearanceVersion = 0;
	if (!appearanceMgrVersionInitialized && HasAppearanceMgr_AC())
	{
		appearanceMgrVersionInitialized = true;
	
		// Check for the Appearance Manager version.
		// Note that we have aleady checked that the Appearance Mgr is present;
		// 1.0 did not implement the version gestalt, but we still want to handle 
		// that case and return the correct version number.
		OSErr result = ::Gestalt(gestaltAppearanceVersion, &appearanceVersion);		
		if (result != noErr)
			appearanceVersion = 0x0100; 
	}
	return appearanceVersion;
}

#endif

//----------------------------------------------------------------------------------------
// DelayFuture_AC
// Delay for the specified number of ticks.
//----------------------------------------------------------------------------------------

void DelayFuture_AC(SInt32 delayTicks)
{
	UInt32	dontCare;
	::Delay(delayTicks, &dontCare);
}

//----------------------------------------------------------------------------------------
// DelayFutureWhileStillDown_AC
// Delay for the specified number of ticks, but bail
// out if the user lets go of the mouse first.
//----------------------------------------------------------------------------------------

void DelayFutureWhileStillDown_AC(SInt32 delayTicks)
{
	UInt32	future = delayTicks + ::TickCount();

	while (::StillDown() && (::TickCount() < future))
		;
}


//----------------------------------------------------------------------------------------
// End of AppearanceUtils_AC.cpp
