//----------------------------------------------------------------------------------------
// CClipboard_AC.cpp
// Copyright © 1996-2001 by Apple Computer. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		05/21/01	Always using CTempHandle_AC. 
		05/09/01	Added conditional definition of kScrapRefNone.
		05/01/01	Added a GetFlavorInfoList method that returns a vector of flavors. 
					Implemented GetFlavorCount and GetFlavorInfoList for non-Carbon. 
		05/01/01	GetFlavorData and GetScrap do not return a length or error code, 
					so it doesn't make sense to call them without a destination. 
					Now we enforce it. 
		04/30/01	Include CHandle_AC to get CTempHLock_AC. 
		04/25/01	Support for debugging the scrap state. 
		04/23/01	Redesigned for Carbon. 
		04/17/01	Can't access Carbon scrap in background. 
		01/02/01	Update copyright.
		11/27/00	GetScrapCount throws when launching a Carbon application from
					AppleScript. 
		09/18/00	[C] Changed implementation of GetScrapCount, GetScrapCountMinusOne
					and IsScrapEmpty.  Changed ScrapCountStillValid to ScrapStillValid
					(for Carbon).  DonÕt clear scrap in ctor or dtor.
		09/01/00	Changed pragma warning to pragma message.  Cosmetic.
		01/13/00	oldScrapCount is unused in ScrapCountStillValid.
		10/18/99	Carbon:ScrapCountStillValid() now not a const, as it needs to
					reset the scrap ref.
		10/05/99	Carbon: Need to reset the reference when have new data in scrap.
		09/28/99	Carbon: Need to stop assigning scrap ref.
		09/28/99	Carbon: Put in real ScrapStillValid() method.
		09/23/99	Carbon: Change #warning to #pragma message
		09/22/99	Carbon: Took out support for GetScrapSeed and GetScrapFlavorSize, as no longer in carbon?
		06/15/99	[C] Carbonised CClipBoard_AC implemention.
		03/24/99	Update copyright notice.
*/

#ifndef __CClipboard_AC__
#include "CClipboard_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CHandleStream_AC__
#include "CHandleStream_AC.h"
#endif

#ifndef __CProcess_AC__
#include "CProcess_AC.h"
#endif

#if qDebug
	#ifndef __CReporter_AC__
	#include "CReporter_AC.h"
	#endif
#endif

//========================================================================================
// Local
//========================================================================================

#if qDebug
static void TraceScrapState(char* function)
{
	static bool pTraceStackState;
	if (pTraceStackState)
		ProgramReport_AC("CClipboard_AC::%s\n", function);
}
#endif

//========================================================================================
// CClipboard_AC
//========================================================================================

#ifndef kScrapRefNone
#define kScrapRefNone ((ScrapRef)NULL)
#endif

//----------------------------------------------------------------------------------------
// CClipboard_AC constructor
//----------------------------------------------------------------------------------------

CClipboard_AC::CClipboard_AC()
#if qCarbon
	:	fScrapRef(kScrapRefNone)
#endif
{
#if !qCarbon
	fScrapStuff.scrapSize = 0;
	fScrapStuff.scrapHandle = NULL;
	fScrapStuff.scrapCount = 0;
	fScrapStuff.scrapState = 0;
	fScrapStuff.scrapName = NULL;
#endif
}

//----------------------------------------------------------------------------------------
// GetCurrent
//----------------------------------------------------------------------------------------

void CClipboard_AC::GetCurrent()
{
#if qCarbon
	// Get the current scrap reference
	ThrowIfOSErr_AC(GetCurrentScrap(&fScrapRef));
#else
	// Copy over from low memory to our private record
	fScrapStuff = *(InfoScrap());
#endif
#if qDebug
	TraceScrapState("GetCurrent");
#endif
}

//----------------------------------------------------------------------------------------
// GetFlavorFlags
//----------------------------------------------------------------------------------------

ScrapFlavorFlags CClipboard_AC::GetFlavorFlags(ScrapFlavorType flavorType) const
{
	ScrapFlavorFlags flavorFlags  = 0;
#if qDebug
	TraceScrapState("GetFlavorFlags");
#endif
#if qCarbon
	ThrowIfOSErr_AC(GetScrapFlavorFlags(fScrapRef, flavorType, &flavorFlags));
#else
#pragma unused (flavorType)
#endif
	return flavorFlags;
}

//----------------------------------------------------------------------------------------
// GetFlavorSize
//----------------------------------------------------------------------------------------

long CClipboard_AC::GetFlavorSize(ScrapFlavorType flavorType) const
{
	Size byteCount = 0;
#if qDebug
	TraceScrapState("GetFlavorSize");
#endif
#if qCarbon
	OSStatus err = GetScrapFlavorSize(fScrapRef, flavorType, &byteCount);
	if (err < 0)
		byteCount = err;
#else
	long offset = 0;
	byteCount = ::GetScrap(NULL, flavorType, &offset);
#endif
	return byteCount;
}

//----------------------------------------------------------------------------------------
// GetFlavorData
//----------------------------------------------------------------------------------------

void CClipboard_AC::GetFlavorData(ScrapFlavorType flavorType, Size* byteCount, void* destination) const
{
	if (!destination)
		ThrowError_AC(paramErr);

#if qDebug
	TraceScrapState("GetFlavorData");
#endif
#if qCarbon
	ThrowIfOSErr_AC(GetScrapFlavorData(fScrapRef, flavorType, byteCount, destination));
#else
	CTempHandle_AC dataHandle(NewHandle(0));
	ThrowIfBadAlloc_AC(dataHandle);
	long offset = 0;
	long result = ::GetScrap(dataHandle, flavorType, &offset);
	if (result < 0)
		ThrowIfOSErr_AC(result);
	else
	{
		*byteCount = result;
		if (result)
			BlockMove_AC(*dataHandle, destination, result);
	}
#endif
}

//----------------------------------------------------------------------------------------
// GetFlavorData
//----------------------------------------------------------------------------------------

void CClipboard_AC::GetScrap(Handle destination, ScrapFlavorType flavorType) const
{
	if (!destination)
		ThrowError_AC(paramErr);

#if qDebug
	TraceScrapState("GetScrap");
#endif
#if qCarbon
	Size byteCount = GetFlavorSize(flavorType);
	SetHandleSize(destination, byteCount);
	CTempHLock_AC destinationLock(destination);
	ThrowIfOSErr_AC(GetScrapFlavorData(fScrapRef, flavorType, &byteCount, *destination));
#else
	long offset = 0;
	long result = ::GetScrap(destination, flavorType, &offset);
	if (result < 0)
		ThrowIfOSErr_AC(result);
#endif
}

//----------------------------------------------------------------------------------------
// ClearCurrent
//----------------------------------------------------------------------------------------

void CClipboard_AC::ClearCurrent()
{
#if qCarbon
	ThrowIfOSErr_AC(ClearCurrentScrap());
#else
	ThrowIfOSErr_AC(ZeroScrap());
#endif
#if qDebug
	TraceScrapState("ClearCurrent");
#endif
}

//----------------------------------------------------------------------------------------
// PutFlavor
//----------------------------------------------------------------------------------------

void CClipboard_AC::PutFlavor(ScrapFlavorType flavorType, ScrapFlavorFlags flavorFlags,
							  Size flavorSize, const void* flavorData)
{
#if qDebug
	TraceScrapState("PutFlavor");
#endif
#if qCarbon
	ThrowIfOSErr_AC(PutScrapFlavor(fScrapRef, flavorType, flavorFlags, 
								   flavorSize, flavorData));
#else
#pragma unused (flavorFlags)
	ThrowIfOSErr_AC(::PutScrap(flavorSize, flavorType, flavorData));
#endif
}

//----------------------------------------------------------------------------------------
// PutFlavor
//----------------------------------------------------------------------------------------

void CClipboard_AC::PutScrap(Size flavorSize, ScrapFlavorType flavorType, const void* flavorData)
{
	PutFlavor(flavorType, 0, flavorSize, flavorData);
}

//----------------------------------------------------------------------------------------
// GetFlavorCount
//----------------------------------------------------------------------------------------

UInt32 CClipboard_AC::GetFlavorCount() const
{
	UInt32 infoCount = 0;
#if qCarbon
	ThrowIfOSErr_AC(GetScrapFlavorCount(fScrapRef, &infoCount));
#else
	CClipboard_AC::Load();
	PScrapStuff pScrpInf = InfoScrap();
	CHandleStream_AC theScrapStream(pScrpInf->scrapHandle, 0);
	while ((theScrapStream.GetPosition() + 8) < pScrpInf->scrapSize)
	{
		DescType theScrapType = theScrapStream.ReadLong();
#if qProjectBuilder
		(void) theScrapType;
#endif
		theScrapStream.OffsetPosition(theScrapStream.ReadLong());
		++infoCount;
	}
#endif
	return infoCount;
}

//----------------------------------------------------------------------------------------
// GetFlavorInfoList
//----------------------------------------------------------------------------------------

void CClipboard_AC::GetFlavorInfoList(UInt32* infoCount, ScrapFlavorInfo info[]) const
{
#if qCarbon
	ThrowIfOSErr_AC(GetScrapFlavorInfoList(fScrapRef, infoCount, info));
#else
	CClipboard_AC::Load();
	PScrapStuff pScrpInf = InfoScrap();
	CHandleStream_AC theScrapStream(pScrpInf->scrapHandle, 0);
	UInt32 i = 0;
	while ((theScrapStream.GetPosition() + 8) < pScrpInf->scrapSize)
	{
		info[i].flavorType = theScrapStream.ReadLong();
		info[i].flavorFlags = 0;
		++i;
		theScrapStream.OffsetPosition(theScrapStream.ReadLong());
	}
	if (infoCount)
		*infoCount = i;
#endif
}

//----------------------------------------------------------------------------------------
// GetFlavorInfoList
//----------------------------------------------------------------------------------------

CFlavorInfoList_AC CClipboard_AC::GetFlavorInfoList() const
{
	CFlavorInfoList_AC flavorList;
	UInt32 infoCount = GetFlavorCount();
	if (infoCount > 0)
	{
		flavorList.resize(infoCount);
		GetFlavorInfoList(&infoCount, flavorList.begin());
	}
	return flavorList;
}

#if qCarbon
//----------------------------------------------------------------------------------------
// SetPromiseKeeper
//----------------------------------------------------------------------------------------

void CClipboard_AC::SetPromiseKeeper(ScrapPromiseKeeperUPP upp, const void* userData)
{
	ThrowIfOSErr_AC(SetScrapPromiseKeeper(fScrapRef, upp, userData));
}

//----------------------------------------------------------------------------------------
// CallInPromises
//----------------------------------------------------------------------------------------

void CClipboard_AC::CallInPromises()
{
	ThrowIfOSErr_AC(CallInScrapPromises());
}

#endif // qCarbon

//----------------------------------------------------------------------------------------
// operator==
//----------------------------------------------------------------------------------------

bool CClipboard_AC::operator==(const CClipboard_AC& other) const
{
#if qCarbon
	return fScrapRef == other.fScrapRef;
#else
	return fScrapStuff.scrapCount == other.fScrapStuff.scrapCount;
#endif
}

//----------------------------------------------------------------------------------------
// IsInMemory
//----------------------------------------------------------------------------------------

bool CClipboard_AC::IsInMemory() const
{
#if qCarbon
	return true;
#else
	return fScrapStuff.scrapState > 0;
#endif
}

//----------------------------------------------------------------------------------------
// IsEmpty
//----------------------------------------------------------------------------------------

bool CClipboard_AC::IsEmpty() const
{
#if qCarbon
	return (fScrapRef == kScrapRefNone) || (GetFlavorCount() == 0);
#else
	return (fScrapStuff.scrapHandle == NULL) && (fScrapStuff.scrapSize == 0);
#endif
}

//----------------------------------------------------------------------------------------
// GetScrapCount
//----------------------------------------------------------------------------------------

long CClipboard_AC::GetScrapCount() const
{
#if qCarbon
	return reinterpret_cast<long>(fScrapRef);
#else
	return fScrapStuff.scrapCount;
#endif
}


//----------------------------------------------------------------------------------------
// End of CClipboard_AC.cpp
