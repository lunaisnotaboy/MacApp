//----------------------------------------------------------------------------------------
// CTextStyle_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/21/01	Organize includes. 
		01/02/01	Update copyright.
		08/09/00	Include Events to get KeyScript. 
		06/14/00	Eliminate GetRegionCode.  Change SetKeyScript so that it does not
					call GetRegionFromScript.
		05/09/00	Update copyright notice.
					Add ImagingUtils_AC routines.
		03/24/99	Update copyright notice.
		02/18/99	Change QuickDraw.h to Quickdraw.h.
		12/16/98	Add unused in Normalize.  There is no GetSysDirection in Windows
					so workaround in RuntimeJustify.
		10/23/98	Carbonize
		10/07/98	Clean up includes. 
*/

#ifndef __CTextStyle_AC__
#include "CTextStyle_AC.h"
#endif

// ACS

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

// Toolbox

#ifndef __QUICKDRAW__
#include <Quickdraw.h>
#endif

#ifndef __EVENTS__
#include <Events.h>
#endif

#ifndef __FONTS__
#include <Fonts.h>
#endif

#ifndef __SCRIPT__
#include <Script.h>
#endif



//========================================================================================
// GLOBAL STextStyles
//========================================================================================

#if !qMSWindows
const CTextStyle_AC CTextStyle_AC::kSystemStyle(systemFont, normal, 0, CRGBColor_AC::kRGBBlack);
const CTextStyle_AC CTextStyle_AC::kApplicationStyle(applFont, normal, 0, CRGBColor_AC::kRGBBlack);
const CTextStyle_AC CTextStyle_AC::kApplicationSmallStyle(applFont, normal, 9, CRGBColor_AC::kRGBBlack);
#else
const CTextStyle_AC CTextStyle_AC::kSystemStyle(systemFont, normal, 0, CRGBColor_AC::kRGBBlack);
const CTextStyle_AC CTextStyle_AC::kApplicationStyle(0, normal, 0, CRGBColor_AC::kRGBBlack);
const CTextStyle_AC CTextStyle_AC::kApplicationSmallStyle(0, normal, 9, CRGBColor_AC::kRGBBlack);
#pragma message ( "NOTE: Need to pass right fontNum in CTextStyle_AC::kSystemStyle, etc." __FILE__)
#endif

//========================================================================================
// CLASS CTextStyle_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Constructor
//----------------------------------------------------------------------------------------
	
CTextStyle_AC::CTextStyle_AC(WhatPortInfo_AC inWhatPortInfo)
{
	if (inWhatPortInfo == kCurrentPortInfo_AC)
		GetPortTextStyle();
	else
		Clear();
}

//----------------------------------------------------------------------------------------
//		¥ Set
//----------------------------------------------------------------------------------------
	
void CTextStyle_AC::Set(const TextStyle& textStyle)
{
	*static_cast<TextStyle*>(this) = *static_cast<const TextStyle*>(&textStyle);
}

//----------------------------------------------------------------------------------------
//		¥ Set
//----------------------------------------------------------------------------------------
	
void CTextStyle_AC::Set(short theFont,
					  short theFace,
					  short theSize,
					  const CRGBColor_AC& theColor)
{
	tsFont = theFont;
	tsFace = theFace;
	tsSize = theSize;
	tsColor = theColor;
}

//----------------------------------------------------------------------------------------
//		¥ Set
//----------------------------------------------------------------------------------------

void CTextStyle_AC::Set(GrafPtr grafPort)
{
#if !qCarbon
	tsFont = grafPort->txFont;
	tsFace = grafPort->txFace;
	tsSize = grafPort->txSize;
	tsColor = (CRGBColor_AC &) ((CGrafPtr) grafPort)->rgbFgColor; // ??? need colorport test?
#else
	tsFont = ::GetPortTextFont(grafPort);
	tsFace = ::GetPortTextFace(grafPort);
	tsSize = ::GetPortTextSize(grafPort);
	::GetPortForeColor(grafPort, &tsColor);
#endif
}

//----------------------------------------------------------------------------------------
// Comparison operators for CTextStyle_AC
//----------------------------------------------------------------------------------------
	
bool CTextStyle_AC::operator ==(const CTextStyle_AC& textStyle) const
{
	return tsFont == textStyle.tsFont && tsFace == textStyle.tsFace && tsSize == textStyle.tsSize && ((CRGBColor_AC)tsColor) == ((CRGBColor_AC)textStyle.tsColor);
}

//----------------------------------------------------------------------------------------
// Normalize: 
//----------------------------------------------------------------------------------------

void CTextStyle_AC::Normalize(SInt16 systemFontNum, SInt16 applFontNum)
{
#if !qMSWindows
	if (tsFont == systemFontNum)
		tsFont = systemFont;
	else if (tsFont == applFontNum)
		tsFont = applFont;
#else
	#pragma message ( "NOTE: Need to implement proper font determination in Normalize." __FILE__)
	#pragma unused (systemFontNum, applFontNum)
	tsFont = 0;
#endif
}

//----------------------------------------------------------------------------------------
// SetPortTextStyle: 
//----------------------------------------------------------------------------------------

void CTextStyle_AC::SetPortTextStyle() const
{
	// Used to try to keep from setting the font all the time but the script may have changed
	// so if the font is applFont or sysFont we always force the change since they can
	// be different fonts for different scripts.
#if !qMSWindows
	GrafPtr thePort;
	GetPort(&thePort);

	short itsFontNum = tsFont;
	short itsFontSize = tsSize;
	Style itsFontFace = tsFace & CMultiLocale_AC::RunTimeFont(itsFontNum, itsFontSize);

	if (GetPortTextFont_AC(thePort) != itsFontNum)
		::TextFont(itsFontNum);

	if (GetPortTextSize_AC(thePort) != itsFontSize)
		::TextSize(itsFontSize);

	if (GetPortTextFace_AC(thePort) != itsFontFace)
		::TextFace(itsFontFace);

#else
		::TextFont(tsFont);
		::TextSize(tsSize);
		::TextFace(tsFace);
#pragma message ( "NOTE: Need to implement proper text drawing in TextBox_AC." __FILE__)
#endif
	
	CRGBColor_AC(tsColor).SetForeColor();
}

//----------------------------------------------------------------------------------------
// GetPortTextStyle: 
//----------------------------------------------------------------------------------------
	
void CTextStyle_AC::GetPortTextStyle()
{
	// Set our text style information to the current port.
	GrafPtr	currentPort;

	::GetPort(&currentPort);
	Set(currentPort);
}

//----------------------------------------------------------------------------------------
// SetKeyScript: 
//----------------------------------------------------------------------------------------

short CTextStyle_AC::SetKeyScript() const
// SetKeyScript 
{
	short	oldScript = ::GetScriptVariable(smCurrentScript, smScriptNumber);
	::KeyScript(FontToScript(tsFont));
	return oldScript;
}

//----------------------------------------------------------------------------------------
// RuntimeJustify: 
//----------------------------------------------------------------------------------------

short CTextStyle_AC::RuntimeJustify(short userJust)
{
	// Return the actual runtime justification value for
	// the supplied value. The caller can use the result
	// alone to know determine drawing direction.
	// If the supplied value specifies default, we need
	// to check the current system script direction.
	// Otherwise, whatever was specified is OK as is.

#if qMSWindows
	return userJust;
#else
	return userJust == teFlushDefault ? (::GetSysDirection() == 0 ? teFlushLeft : teFlushRight) : userJust;
#endif
}

//========================================================================================
// CLASS CWhileOutlinePreferred_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CWhileOutlinePreferred_AC::CWhileOutlinePreferred_AC: 
//----------------------------------------------------------------------------------------

CWhileOutlinePreferred_AC::CWhileOutlinePreferred_AC(bool preferOutline) :
	fPreferOutline(preferOutline),
	fOutlinePreferredChanged(
#if !qMSWindows
							 (::GetOutlinePreferred() != preferOutline)
#else
							 false
#endif
							 )
{
	// change outline preferred, if necessary
#if !qMSWindows
	if (fOutlinePreferredChanged)
		::SetOutlinePreferred(fPreferOutline);
#endif
}

//----------------------------------------------------------------------------------------
// CWhileOutlinePreferred_AC::~CWhileOutlinePreferred_AC: 
//----------------------------------------------------------------------------------------

CWhileOutlinePreferred_AC::~CWhileOutlinePreferred_AC()
{
	// restore outline preferred, if necessary
#if !qMSWindows
	if (fOutlinePreferredChanged)
		::SetOutlinePreferred(!fPreferOutline);
#endif
}

//----------------------------------------------------------------------------------------
// End of CTextStyle_AC.cpp
