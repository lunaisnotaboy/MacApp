//----------------------------------------------------------------------------------------
// CAEDesc_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/25/01	Use Lock_AC instead of HLock.
		06/26/01	Include CString_AC.h.  Cast resourceName to const unsigned char* in WriteTo.
		05/07/01	Comment out pragma messages for Carbon. 
		04/05/01	Add a GetData method. 
							SizeOfNthItem and SizeOfKeyDesc should not throw. 
		12/28/00	All strings are now CString_AC.
		01/02/01	Update copyright.
		12/05/00	Add preflight count check in GetNthItem.  Include CReporter_AC.h.
		11/15/00	GetKeyDesc should return true on noErr.
		11/01/00	[PB] Don't include SegLoad. 
		06/14/00	Eliminate unnecessary GetRegionCode calls.
		03/23/00	Use AsCStr255_AC in GetString and GetKeyString.
		02/23/00	Took out Set via handle for Carbon.
		02/18/00	Added Set implementation for Carbon.
		02/03/00	Don't dispose of handles in CAEDesc_AC on Carbon. 
		11/11/99	Add Put/GetShort and Put/GetPoint methods.
		09/20/99	Carbon:AEGetDescData parameters changed.
		07/14/99	Fix a crashing bug where the copy constructors called the CreateDesc 
							method without first initializing dataHandle to NULL. Renamed the
							CreateDesc method to reset so it is obvious that it disposes of 
							existing data in the AEDesc. Added some more Set methods so the
							constructors, reset and Set methods are orthogonal. 
		03/24/99	Update copyright notice.
		02/10/99	Work on the handle ownership issues introduced with Carbon
							compatibility. 
		02/08/99	Replaced CAEDesc_AC version of CreateDesc with AppleEvent version.
		02/04/99	Include CHandle_AC.h.
		02/03/99	Removed the need for the Set function.
		02/02/99	Include CPascalString_AC.h.  [C] GetDataHandle cannot access
							dataHandle so (for Carbon) it is called GetDataAsHandle and 
							returns a new handle to the data.  NOTE: The implementation of
							TotalSize is different for Carbon.
		01/16/99	Don't dereference a null descriptor dataHandle. 
		01/12/99	Add ThrowIfNULLDesc_AC. 
		01/11/99	Fill in the complete AEDesc API. 
							Add CAEValue. 
		01/09/99	Moved from MacApp to ACS. 
*/

#ifndef __CAEDesc_AC__
#include "CAEDesc_AC.h"
#endif

// ACS

#ifndef __CAECompare_AC__
#include "CAECompare_AC.h"
#endif

#ifndef __CAEValue_AC__
#include "CAEValue_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CFile_AC__
#include "CFile_AC.h"
#endif

#ifndef __CFSSpec_AC__
#include "CFSSpec_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __CRGBColor_AC__
#include "CRGBColor_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CStream_AC__
#include "CStream_AC.h"
#endif

#ifndef __CString_AC__
#include "CString_AC.h"
#endif

#ifndef __ResFileUtils_AC__
#include "ResFileUtils_AC.h"
#endif

// Toolbox

#ifndef __AEREGISTRY__
#include <AERegistry.h>
#endif

#ifndef __PROCESSES__
#include <Processes.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

//========================================================================================
// CLASS CAEDesc_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CAEDesc_AC global data
//----------------------------------------------------------------------------------------

const CAEDesc_AC CAEDesc_AC::fgNullDesc;

//----------------------------------------------------------------------------------------
// CAEDesc_AC::Set: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::Set(const CAEValue_AC& value)
{
	Set(value.GetDescriptorType(), value.GetPtr(), value.GetSize());
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::Set: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::Set(DescType typeCode, const void* dataPtr, Size dataSize)
{
	::ThrowIfOSErr_AC(::AECreateDesc(typeCode, dataPtr, dataSize, this));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetData: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::GetData(void* dataPtr, Size maximumSize) const
{
#if qCarbon
	::ThrowIfOSErr_AC(::AEGetDescData(this, dataPtr, maximumSize));
#else
	if (dataHandle)
	{
		Size dataSize = Min_AC(::GetHandleSize(dataHandle), maximumSize);
		if (dataSize > 0)
			BlockMove_AC(*dataHandle, dataPtr, dataSize);
	}
#endif
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetDataAsHandle: 
//----------------------------------------------------------------------------------------

Handle CAEDesc_AC::GetDataAsHandle() const
{
	CTempHandle_AC newDataHandle = NULL;
	Size dataSize = GetDataSize();
	if (dataSize)
	{
		newDataHandle = ::NewHandle(dataSize);
#if qCarbon
		::Lock_AC(static_cast<Handle>(newDataHandle));
		::ThrowIfOSErr_AC(::AEGetDescData(this, *newDataHandle, dataSize));
#else
		BlockMove_AC(*dataHandle, *newDataHandle, dataSize);
#endif
	}

	return newDataHandle.release();
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::TotalSize: 
//----------------------------------------------------------------------------------------

Size CAEDesc_AC::TotalSize(bool justLocked) const
{
#if qCarbon
	#pragma unused (justLocked)
	return GetDataSize();
#else
	return GetHandleSizeIfLocked_AC(dataHandle, justLocked);
#endif
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetDataSize: 
//----------------------------------------------------------------------------------------

long CAEDesc_AC::GetDataSize() const
{
#if qCarbon
	//#pragma message ("CAEDesc_AC::GetDataSize: Is AEGetDescDataSize adequate here.")
	return ::AEGetDescDataSize(this);
#else
	return dataHandle ? ::GetHandleSize(dataHandle) : 0;
#endif
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::EqualDesc: 
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::EqualDesc(const CAEDesc_AC& otherDesc) const
{
	return CompareDesc(otherDesc, kAEEquals);
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::CompareDesc: 
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::CompareDesc(const CAEDesc_AC& otherDesc, DescType compareHow) const
{
	bool theResult = false;

	if (compareHow == kAEEquals && (dataHandle == otherDesc.dataHandle))
		theResult = true;
	else
	{
		if (descriptorType != otherDesc.descriptorType)
		{
			// Try coercing otherDesc to descriptorType
			CTempDesc_AC tempDesc;
			if (::AECoerceDesc(otherDesc, descriptorType, tempDesc) == noErr)
			{
				theResult = CompareDesc(tempDesc, compareHow);
			}
			// Try coercing myself to otherDesc.descriptorType
			else if (::AECoerceDesc(*this, otherDesc.descriptorType, tempDesc) == noErr)
			{
				theResult = tempDesc.CompareDesc(otherDesc, compareHow);
			}
			// Give up
		}
		else
		{
			try
			{
				theResult = CAECompare_AC::CompareDesc(this, otherDesc, compareHow);
			}
			catch(CException_AC& theException)
			{
				DoCatchMessage_AC(theException);

				// Don't resignal failure, just return false
				theResult = false;
			}
		}
	}

	return theResult;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::CanCoerceDesc: 
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::CanCoerceDesc(DescType toType) const
{
	CTempDesc_AC tempDesc;
	return ::AECoerceDesc(this, toType, tempDesc) == noErr;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::CoerceDesc: 
//----------------------------------------------------------------------------------------

CAEDesc_AC CAEDesc_AC::CoerceDesc(DescType toType) const
{
	CTempDesc_AC result;
	::ThrowIfOSErr_AC(::AECoerceDesc(this, toType, result));
	return result.release();
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::CoerceDesc: 
//----------------------------------------------------------------------------------------

CAEDesc_AC CAEDesc_AC::Coerce(DescType toType) const
{
	CAEDesc_AC result;
	OSErr err = ::AECoerceDesc(this, toType, result);
	if (err != noErr)
		result.reset();
	return result.release();
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::reset: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::reset(const AEDesc& theDesc)
{
	if (dataHandle)
		::ThrowIfOSErr_AC(DisposeDesc());
	
	Set(theDesc);
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::reset: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::reset(const CAEValue_AC& value)
{
	if (dataHandle)
		::ThrowIfOSErr_AC(DisposeDesc());
	
	Set(value);
}

#if !qCarbon
//----------------------------------------------------------------------------------------
// CAEDesc_AC::reset: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::reset(DescType theType, Handle theHandle)
{
	if (dataHandle)
		::ThrowIfOSErr_AC(DisposeDesc());

	Set(theType, theHandle);
}
#endif // !qCarbon

//----------------------------------------------------------------------------------------
// CAEDesc_AC::reset: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::reset(DescType typeCode, const void* dataPtr, Size dataSize)
{
	if (dataHandle)
		::ThrowIfOSErr_AC(DisposeDesc());

	Set(typeCode, dataPtr, dataSize);
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::DisposeDesc: 
//----------------------------------------------------------------------------------------

OSErr CAEDesc_AC::DisposeDesc()
// DisposeDesc returns a status because it is used in destructors, where we can't fail,
// and it is also used independently, as in reset. 
{
	OSErr result = noErr;

	if (dataHandle)
		result = ::AEDisposeDesc(this);

	if (result == noErr)
	{
		dataHandle = NULL;
		descriptorType = typeNull;
	}

	return result;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::DuplicateDesc: 
//----------------------------------------------------------------------------------------

CAEDesc_AC CAEDesc_AC::DuplicateDesc() const
{
	CTempDesc_AC result;
	::ThrowIfOSErr_AC(::AEDuplicateDesc(this, &result));
	return result.release();
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::CreateList: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::CreateList()
{
	::ThrowIfOSErr_AC(::AECreateList(NULL, 0, false, this));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::CountListItems: 
//----------------------------------------------------------------------------------------

long CAEDesc_AC::CountListItems() const
{
	long theCount = 0;
	::ThrowIfOSErr_AC(::AECountItems(this, &theCount));
	return theCount;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutListPtr: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutListPtr(long index, DescType typeCode, const void *dataPtr, Size dataSize)
{
	::ThrowIfOSErr_AC(::AEPutPtr(this, index, typeCode, dataPtr, dataSize));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutListItem: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutListItem(long index, const CAEDesc_AC& theDesc)
{
	::ThrowIfOSErr_AC(::AEPutDesc(this, index, theDesc));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutListPtr: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutListValue(long index, const CAEValue_AC& value)
{
	PutListPtr(index, value.GetDescriptorType(), value.GetPtr(), value.GetSize());
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetNthPtr: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::GetNthPtr(long index, DescType desiredType, DescType *typeCode,
						   void *dataPtr, Size maximumSize, Size *actualSize) const
{
	DescType key = 0;
	::ThrowIfOSErr_AC(::AEGetNthPtr(this, index, desiredType, &key, typeCode,
								  dataPtr, maximumSize, actualSize));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetNthItem: 
//----------------------------------------------------------------------------------------

CAEDesc_AC CAEDesc_AC::GetNthItem(long index, DescType desiredType) const
{
#if qDebug
	long theCount = 0;
	::ThrowIfOSErr_AC(::AECountItems(this, &theCount));
	if (index > theCount)
		ProgramBreak_AC("CAEDesc_AC::GetNthItem: index (%d) is greater than count of items (%d).",
						index, theCount);
#endif

	DescType key = 0;
	CAEDesc_AC theDesc;

	::ThrowIfOSErr_AC(::AEGetNthDesc(this, index, desiredType, &key, &theDesc));
	return theDesc;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::SizeOfNthItem: 
//----------------------------------------------------------------------------------------

Size CAEDesc_AC::SizeOfNthItem(long index, DescType *typeCode) const
{
	Size dataSize = 0;
	DescType typeCodeLocal = 0;
	OSErr err = ::AESizeOfNthItem(this, index, &typeCodeLocal, &dataSize);
	if (err)
		dataSize = 0;
	else if (typeCode)
		*typeCode = typeCodeLocal;
	return dataSize;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutArray: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutArray(AEArrayType arrayType, const AEArrayDataPointer arrayPtr,
						  DescType itemType, Size itemSize, long itemCount)
{
	if (dataHandle)						// optimization
		::ThrowIfOSErr_AC(DisposeDesc());

	::ThrowIfOSErr_AC(::AEPutArray(this, arrayType, arrayPtr, itemType, itemSize, itemCount));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetArray: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::GetArray(AEArrayType arrayType, AEArrayDataPointer arrayPtr, Size maximumSize,
						  DescType *itemType, Size *itemSize, long *itemCount) const
{
	::ThrowIfOSErr_AC(::AEGetArray(this, arrayType, arrayPtr, maximumSize,
								 itemType, itemSize, itemCount));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::DeleteListItem: 
//----------------------------------------------------------------------------------------

OSErr CAEDesc_AC::DeleteListItem(long index)
{
	return AEDeleteItem(this, index);
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::CreateRecord: 
//----------------------------------------------------------------------------------------

void CAEDesc_AC::CreateRecord()
{
	::ThrowIfOSErr_AC(::AECreateList(NULL, 0, true, this));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyPtr:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyPtr(AEKeyword key, DescType typeCode,
						   const void* dataPtr, Size dataSize)
{
	::ThrowIfOSErr_AC(::AEPutKeyPtr(this, key, typeCode, dataPtr, dataSize));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyDesc:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyDesc(AEKeyword key, const CAEDesc_AC& theAEDesc)
{
	::ThrowIfOSErr_AC(::AEPutKeyDesc(this, key, theAEDesc));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyPtr:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyValue(AEKeyword key, const CAEValue_AC& value)
{
	PutKeyPtr(key, value.GetDescriptorType(), value.GetPtr(), value.GetSize());
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyPtr:
//----------------------------------------------------------------------------------------

OSErr CAEDesc_AC::GetKeyPtr(AEKeyword key, DescType desiredType, DescType* typeCode,
							void* dataPtr, Size maximumSize, Size* actualSize) const
{
	return AEGetKeyPtr(this, key, desiredType, typeCode, dataPtr, maximumSize,
					   actualSize);
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyDesc:
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::GetKeyDesc(AEKeyword key, DescType desiredType, CAEDesc_AC& theAEDesc) const
{
	return (AEGetKeyDesc(this, key, desiredType, theAEDesc) == noErr);
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::SizeOfKeyDesc: 
//----------------------------------------------------------------------------------------

Size CAEDesc_AC::SizeOfKeyDesc(AEKeyword key, DescType *typeCode) const
{
	Size dataSize = 0;
	DescType typeCodeLocal = 0;
	OSErr err = ::AESizeOfKeyDesc(this, key, &typeCodeLocal, &dataSize);
	if (err)
		dataSize = 0;
	else if (typeCode)
		*typeCode = typeCodeLocal;
	return dataSize;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::DeleteKeyDesc:
//----------------------------------------------------------------------------------------

OSErr CAEDesc_AC::DeleteKeyDesc(AEKeyword key)
{
	return AEDeleteKeyDesc(this, key);
}


//----------------------------------------------------------------------------------------
// CAEDesc_AC::ReadFrom
//----------------------------------------------------------------------------------------

void CAEDesc_AC::ReadFrom(CStream_AC* aStream)
{
	::ThrowIfOSErr_AC(DisposeDesc());

#if !qCarbon
	descriptorType = aStream->ReadLong();
	bool hasHandle = aStream->ReadBoolean();
	if (hasHandle)
		dataHandle = aStream->ReadHandle();
#else
	DescType theType = aStream->ReadLong();
	bool hasHandle = aStream->ReadBoolean();
	if (hasHandle)
	{
		CTempHandle_AC tempHandle = aStream->ReadHandle();
		Set(theType, *tempHandle, GetHandleSize(tempHandle));
	}
	else
		Set(theType, NULL, 0);
#endif
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::ReadFrom
//----------------------------------------------------------------------------------------

void CAEDesc_AC::ReadFrom(CFile_AC* aFile, ResType resourceType, short resourceID)
{
#if qDebug
	::ThrowIfNonObject_AC(aFile);
#endif

	::ThrowIfOSErr_AC(DisposeDesc());
	if (aFile->HasRsrcFork())
	{
		CTempUseResFile_AC tempUseResFile(aFile->GetRsrcRefNum());
		Handle descHandle = CMultiLocale_AC::Get1Resource(resourceType, resourceID);
#if !qCarbon
		if (descHandle)
		{
			DetachResource(descHandle);
			Set(resourceType, descHandle);
		}
#else
		if (descHandle)
		{
			{
				CTempHLock_AC descHandleLock(descHandle);
				Set(resourceType, *descHandle, GetHandleSize(descHandle));
			}
			ReleaseResource(descHandle);
		}
#endif
	}
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::WriteTo
//----------------------------------------------------------------------------------------

void CAEDesc_AC::WriteTo(CStream_AC* aStream) const
{
	aStream->WriteLong(static_cast<long>(descriptorType));
	aStream->WriteBoolean(dataHandle != NULL);
	if (dataHandle)
#if qCarbon
	{
		CTempHandle_AC tempHandle(GetDataAsHandle());
		aStream->WriteHandle(tempHandle);
	}
#else
		aStream->WriteHandle(dataHandle);
#endif
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::WriteTo
//----------------------------------------------------------------------------------------

void CAEDesc_AC::WriteTo(CFile_AC* aFile, short resourceID, const CString_AC& resourceName) const
{
#if qDebug
	::ThrowIfNonObject_AC(aFile);
#endif

	if (aFile->HasRsrcFork() && dataHandle)
	{
		CTempHandle_AC tempdataHandle(GetDataAsHandle());

		CTempUseResFile_AC tempUseResFile(aFile->GetRsrcRefNum());
		CMultiLocale_AC::AddResource(tempdataHandle, descriptorType, resourceID,
									 reinterpret_cast<const unsigned char*>(resourceName.c_str()));
		::ThrowIfResError_AC();
		WriteResource(tempdataHandle);
		ReleaseResource(tempdataHandle.release());
	}
}

#if qOldAEDescAccessors

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetFSSpec: Note that this method provides transparent coercion of alias records into
// CFSSpec_AC records.
//--------------------------------------------------------------------------------------------------

CFSSpec_AC CAEDesc_AC::GetFSSpec() const
{
	return CAEFSSpec_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutFSSpec: 
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutFSSpec(const CFSSpec_AC& fileSpec)
{
	reset(CAEFSSpec_AC(fileSpec));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetRect: 
//--------------------------------------------------------------------------------------------------

CRect_AC CAEDesc_AC::GetRect() const
{
	return CAERect_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutRect: 
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutRect(const CRect_AC& theRect)
{
	reset(CAERect_AC(theRect));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetType: 
//--------------------------------------------------------------------------------------------------

DescType CAEDesc_AC::GetType() const
{
	return CAEDescType_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutType: 
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutType(DescType theType)
{
	reset(CAEDescType_AC(theType));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetString: 
//--------------------------------------------------------------------------------------------------

CString_AC CAEDesc_AC::GetString() const
{
	return CAEString_AC(*this).AsString();
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutString: 
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutString(const CString_AC& theString)
{
	reset(CAEString_AC(theString));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetBoolean: 
//--------------------------------------------------------------------------------------------------

Boolean CAEDesc_AC::GetBoolean() const
{
	return CAEBoolean_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutBoolean: 
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutBoolean(Boolean theBoolean)
{
	reset(CAEBoolean_AC(theBoolean));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetShort:
//--------------------------------------------------------------------------------------------------

short CAEDesc_AC::GetShort() const
{
	return CAEShort_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutShort: 
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutShort(short theShort)
{
	reset(CAEShort_AC(theShort));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetPoint:
//--------------------------------------------------------------------------------------------------

Point CAEDesc_AC::GetPoint() const
{
	return CAEPoint_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutPoint: 
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutPoint(Point thePoint)
{
	reset(CAEPoint_AC(thePoint));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetEnum: 
//--------------------------------------------------------------------------------------------------

DescType CAEDesc_AC::GetEnum() const
{
	return CAEEnum_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutEnum:
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutEnum(DescType theEnum)
{
	reset(CAEEnum_AC(theEnum));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetLong:
//--------------------------------------------------------------------------------------------------

long CAEDesc_AC::GetLong() const
{
	return CAELong_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutLong:
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutLong(long theLong)
{
	reset(CAELong_AC(theLong));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetDateTime:
//--------------------------------------------------------------------------------------------------

unsigned long CAEDesc_AC::GetDateTime() const
{
	return CAEDateTime_AC(*this).GetTime();
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutDateTime:
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutDateTime(unsigned long theDateTime)
{
	reset(CAEDateTime_AC(theDateTime));
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::GetRGBColor:
//--------------------------------------------------------------------------------------------------

CRGBColor_AC CAEDesc_AC::GetRGBColor() const
{
	return CAERGBColor_AC(*this);
}

//--------------------------------------------------------------------------------------------------
// CAEDesc_AC::PutRGBColor:
//--------------------------------------------------------------------------------------------------

void CAEDesc_AC::PutRGBColor(const CRGBColor_AC& theColor)
{
	reset(CAERGBColor_AC(theColor));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyLong:
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::GetKeyLong(AEKeyword key, long& theNum) const
{
	bool found = false;
	theNum = CAELong_AC(*this, key, &found);
	return found;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyLong:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyLong(AEKeyword key, long theNum)
{
	PutKeyValue(key, CAELong_AC(theNum));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyRect:
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::GetKeyRect(AEKeyword key, CRect_AC& theRect) const
{
	bool found = false;
	theRect = CAERect_AC(*this, key, &found);
	return found;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyRect:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyRect(AEKeyword key, CRect_AC& theRect)
{
	PutKeyValue(key, CAERect_AC(theRect));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyString:
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::GetKeyString(AEKeyword key, CString_AC& theStr) const
{
	bool found = false;
	theStr = CAEString_AC(*this, key, &found).AsString();
	return found;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyString:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyString(AEKeyword key, const CString_AC& theStr)
{
	PutKeyValue(key, CAEString_AC(theStr));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyDateTime:
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::GetKeyDateTime(AEKeyword key, unsigned long& theDate) const
{
	bool found = false;
	theDate = CAEDateTime_AC(*this, key, &found).GetTime();
	return found;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyDateTime:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyDateTime(AEKeyword key, unsigned long theDate)
{
	PutKeyValue(key, CAEDateTime_AC(theDate));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyBoolean:
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::GetKeyBoolean(AEKeyword key, Boolean& theBoolean) const
{
	bool found = false;
	theBoolean = CAEBoolean_AC(*this, key, &found);
	return found;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyBoolean:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyBoolean(AEKeyword key, Boolean theBoolean)
{
	PutKeyValue(key, CAEBoolean_AC(theBoolean));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyColor:
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::GetKeyColor(AEKeyword key, CRGBColor_AC& theColor) const
{
	bool found = false;
	theColor = CAERGBColor_AC(*this, key, &found);
	return found;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyColor:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyColor(AEKeyword key, CRGBColor_AC& theColor)
{
	PutKeyValue(key, CAERGBColor_AC(theColor));
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::GetKeyEnum:
//----------------------------------------------------------------------------------------

bool CAEDesc_AC::GetKeyEnum(AEKeyword key, DescType& theEnum) const
{
	bool found = false;
	theEnum = CAEEnum_AC(*this, key, &found);
	return found;
}

//----------------------------------------------------------------------------------------
// CAEDesc_AC::PutKeyEnum:
//----------------------------------------------------------------------------------------

void CAEDesc_AC::PutKeyEnum(AEKeyword key, DescType theEnum)
{
	PutKeyValue(key, CAEEnum_AC(theEnum));
}

#endif // qOldAEDescAccessors


//========================================================================================
// CLASS CTempDesc_AC
//========================================================================================

#if qCarbon
//----------------------------------------------------------------------------------------
// CTempDesc_AC Constructor
//----------------------------------------------------------------------------------------

CTempDesc_AC::CTempDesc_AC(DescType theType, Handle theHandle)
	:	CAEDesc_AC()
{
	Set(theType, theHandle);
}

//----------------------------------------------------------------------------------------
// CTempDesc_AC::Set: 
//----------------------------------------------------------------------------------------

void CTempDesc_AC::Set(DescType theType, Handle theHandle)
{
	// Traditionally, the AEDesc takes over ownership of the provided handle. 
	// Under Carbon, the AEDesc "dataHandle" is an opaque reference, so we 
	// have to copy the handle's contents and dispose of the handle ourselves. 
	CTempHandle_AC	theHandleTemp(theHandle);
	const void*		dataPtr = NULL;
	Size			dataSize = 0;

	if (theHandle)
	{
		::Lock_AC(theHandle);
		dataPtr = *theHandle;
		dataSize = ::GetHandleSize(theHandle);
	}

	Set(theType, dataPtr, dataSize);
}
#endif // qCarbon


//========================================================================================
// Global Functions
//========================================================================================

#if qDebugExceptions
//----------------------------------------------------------------------------------------
// DebugThrowIfNULLDesc_AC:
//----------------------------------------------------------------------------------------

void DebugThrowIfNULLDesc_AC(const CAEDesc_AC& desc, const char* inFileName, short inLineNum)
{
	if (desc.IsNULL())
		::DebugThrowError_AC(errAEDescIsNull, inFileName, inLineNum);
}

#else
//----------------------------------------------------------------------------------------
// ThrowIfNULLDesc_AC
//----------------------------------------------------------------------------------------

void ThrowIfNULLDesc_AC(const CAEDesc_AC& desc)
{
	if (desc.IsNULL())
		::ThrowError_AC(errAEDescIsNull);
}
#endif // qDebugExceptions

//----------------------------------------------------------------------------------------
// End of CAEDesc_AC.cpp