//----------------------------------------------------------------------------------------
// CWindow_AC.cpp
// Copyright © 2000-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		02/14/01	Don't include Windows_AC. 
		01/04/01	Make GetSheetParent const, as this is how it is declared in
							header.
							Update copyright.
		01/02/01	Fixes to build with vanilla CW Pro 6. 
		12/29/00	Make getters const. 
							Check for -1 returned from GetWindowRegion. 
		12/28/00	Reorganize CWindow_AC as separate classes based on whether
							functions require Carbon, Mac OS 8.5 Appearance, or are
							always available. 
							Move code for saving and restoring the theme drawing state 
							from SetBackgroundTheme to CSaveThemeDrawingState_AC. 
		12/18/00	Initial version. 
*/

#ifndef __CWindow_AC__
#include "CWindow_AC.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CErrorMessage_AC__
#include "CErrorMessage_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CFile_AC__
#include "CFile_AC.h"
#endif

#ifndef __Configuration_AC__
#include "Configuration_AC.h"
#endif

#ifndef __CProcess_AC__
#include "CProcess_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __WindowUtils_AC__
#include "WindowUtils_AC.h"
#endif

// Toolbox

#ifndef __FIXMATH__
#include <FixMath.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#if qMSWindows
	#ifndef __QTML__
	#include <QTML.h>
	#endif
#endif


//========================================================================================
// Local Functions
//========================================================================================

//----------------------------------------------------------------------------------------
// RequiresAppearance
//----------------------------------------------------------------------------------------

#if qCarbon
inline void RequiresAppearance() {}
#else
inline void RequiresAppearance()
{
	if (!HasAppearanceMgr_AC())
		ThrowError_AC(errRequiresAppearance);
}
#endif

//----------------------------------------------------------------------------------------
// RequiresWindowManager85
//----------------------------------------------------------------------------------------

#if qCarbon
inline void RequiresWindowManager85() {}
#else
inline void RequiresWindowManager85()
{
	if (!HasWindowManager85_AC())
		ThrowError_AC(errRequiresSystem8_5);
}
#endif

//----------------------------------------------------------------------------------------
// RequiresSystem9
//----------------------------------------------------------------------------------------

#if qCarbon
inline void RequiresSystem9() {}
#else
inline void RequiresSystem9()
{
	if (GetSystemVersion_AC() < 0x900)
		ThrowError_AC(errRequiresSystem9);
}
#endif

//----------------------------------------------------------------------------------------
// RequiresCarbonEvents
//----------------------------------------------------------------------------------------

#if qCarbon
inline void RequiresCarbonEvents()
{
	if (!HasCarbonEvents_AC())
		ThrowError_AC(errRequiresCarbonEvents);
}
#endif


//========================================================================================
// CClassicWindow_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CClassicWindow_AC::CClassicWindow_AC(short windowID, void* wStorage, WindowRef behind)
	:	fWMgrWindow(Create(windowID, wStorage, behind))
{
}

CClassicWindow_AC::CClassicWindow_AC(void* wStorage, const Rect& boundsRect, ConstStr255Param title, 
									 bool visible, short procID, WindowRef behind, bool goAwayFlag, 
									 long refCon)
	:	fWMgrWindow(Create(wStorage, boundsRect, title, visible, procID, behind, 
						   goAwayFlag, refCon))
{
}

//----------------------------------------------------------------------------------------
// Window Creation & Persistence
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

WindowRef CClassicWindow_AC::Create(short windowID, void* wStorage, WindowRef behind)
{
	WindowRef window = GetNewCWindow(windowID, wStorage, behind);
	ThrowIfNULL_AC(window);
	return window;
}

WindowRef CClassicWindow_AC::Create(void* wStorage, const Rect& boundsRect, ConstStr255Param title, 
									bool visible, short procID, WindowRef behind, bool goAwayFlag, 
									long refCon)
{
	WindowRef window = NewCWindow(wStorage, &boundsRect, title, visible, procID, behind, 
								  goAwayFlag, refCon);
	ThrowIfNULL_AC(window);
	return window;
}

//----------------------------------------------------------------------------------------
// Dispose
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Dispose()
{
	if (fWMgrWindow)
	{
		DisposeWindow(fWMgrWindow);
		fWMgrWindow = NULL;
	}
}

#if !qCarbon
//----------------------------------------------------------------------------------------
// Close
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Close()
{
	MacCloseWindow(fWMgrWindow);
}
#endif

//----------------------------------------------------------------------------------------
// Release
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Release()
{
	DisposeWindow(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// Background Image
//----------------------------------------------------------------------------------------

#if !qCarbon
//----------------------------------------------------------------------------------------
// SetColor
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetColor(WCTabHandle newColorTable)
{
	SetWinColor(fWMgrWindow, newColorTable);
}
#endif

//----------------------------------------------------------------------------------------
// Low-Level Region & Painting Routines
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// ClipAbove
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::ClipAbove()
{
	::ClipAbove(fWMgrWindow);
}

#if !qCarbon
//----------------------------------------------------------------------------------------
// SaveOld
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SaveOld()
{
	::SaveOld(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// DrawNew
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::DrawNew(bool update)
{
	::DrawNew(fWMgrWindow, update);
}

#endif // !qCarbon

//----------------------------------------------------------------------------------------
// PaintOne
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::PaintOne(RgnHandle clobberedRgn)
{
	::PaintOne(fWMgrWindow, clobberedRgn);
}

//----------------------------------------------------------------------------------------
// PaintBehind
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::PaintBehind(RgnHandle clobberedRgn)
{
	::PaintBehind(fWMgrWindow, clobberedRgn);
}

//----------------------------------------------------------------------------------------
// CalcVis
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::CalcVis()
{
	::CalcVis(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// CalcVisBehind
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::CalcVisBehind(RgnHandle clobberedRgn)
{
	::CalcVisBehind(fWMgrWindow, clobberedRgn);
}

//----------------------------------------------------------------------------------------
// Window List
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Find
//----------------------------------------------------------------------------------------

CClassicWindow_AC::FindWindowResult CClassicWindow_AC::Find(Point where)
{
	FindWindowResult result = {0, NULL};

#if !qMSWindows
	result.partCode = ::MacFindWindow(where, &result.window);
#else
	// Under Windows MacFindWindow will not always find the correct windows window.  The
	// assumption here is that Windows handles the cases where the mouse click is not in
	// the content area of the window, so it will always be an inContent return code.
	// The Window itself will be the top most HWND that has a GrafPtr associated with it
	POINT point;
	point.x = where.h;
	point.y = where.v;
	MapWindowPoints(CApplication_AC::fgProcess->fChildClientWindow, HWND_DESKTOP, &point, 1);

	HWND window = WindowFromPoint(point);
	HWND parent = GetParent(window);
	GrafPtr port = NULL;
	if (parent != NULL)
		port = GetHWNDPort(parent);
	while ((parent != NULL) && (port != NULL))
	{
		window = parent;
		parent = GetParent(window);
		if (parent != NULL)
			port = GetHWNDPort(parent);
	}
	result.window = GetHWNDPort(window);
	result.partCode = inContent;
#endif

	return result;
}

//----------------------------------------------------------------------------------------
// Front
//----------------------------------------------------------------------------------------

WindowRef CClassicWindow_AC::Front()
{
	return FrontWindow();
}

//----------------------------------------------------------------------------------------
// BringToFront
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::BringToFront()
{
	::BringToFront(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// SendBehind
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SendBehind(WindowRef behindWindow)
{
	::SendBehind(fWMgrWindow, behindWindow);
}

//----------------------------------------------------------------------------------------
// Select
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Select()
{
#if !qMSWindows
	SelectWindow(fWMgrWindow);
#else
	HWND hwnd = GetPortHWND(fWMgrWindow);
	SendMessage(CApplication_AC::fgProcess->fChildClientWindow, WM_MDIACTIVATE, (WPARAM)hwnd, 0);
#endif
}

//----------------------------------------------------------------------------------------
// Various & Sundry Window Accessors
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Hilite
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Hilite(bool fHilite)
{
	HiliteWindow(fWMgrWindow, fHilite);
}

//----------------------------------------------------------------------------------------
// SetRefCon
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetRefCon(long data)
{
	SetWRefCon(fWMgrWindow, data);
}

//----------------------------------------------------------------------------------------
// GetRefCon
//----------------------------------------------------------------------------------------

long CClassicWindow_AC::GetRefCon() const
{
	return GetWRefCon(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// SetPic
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetPic(PicHandle pic)
{
	SetWindowPic(fWMgrWindow, pic);
}

//----------------------------------------------------------------------------------------
// GetPic
//----------------------------------------------------------------------------------------

PicHandle CClassicWindow_AC::GetPic() const
{
	return GetWindowPic(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// GetVariant
//----------------------------------------------------------------------------------------

short CClassicWindow_AC::GetVariant() const
{
	return GetWVariant(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// GetFeatures
//----------------------------------------------------------------------------------------

UInt32 CClassicWindow_AC::GetFeatures() const
{
	RequiresAppearance();
	UInt32 outFeatures = 0;
	ThrowIfOSErr_AC(GetWindowFeatures(fWMgrWindow, &outFeatures));
	return outFeatures;
}

//----------------------------------------------------------------------------------------
// GetRegion
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::GetRegion(WindowRegionCode inRegionCode, RgnHandle ioWinRgn) const
{
	RequiresAppearance();
	OSStatus err = GetWindowRegion(fWMgrWindow, inRegionCode, ioWinRgn);

	// Inside Mac suggests that WDEFs should return -1 for unsupported region codes. 
	// Throwing a -1 is confusing, so we just look for it and make sure the out
	// region is empty. 
	if (err == -1)
	{
		if (ioWinRgn)
			SetEmptyRgn(ioWinRgn);
	}
	else
		ThrowIfOSErr_AC(err);
}

//----------------------------------------------------------------------------------------
// Update Events
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// BeginUpdate
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::BeginUpdate()
{
	::BeginUpdate(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// EndUpdate
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::EndUpdate()
{
	::EndUpdate(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// DrawGrowIcon
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// DrawGrowIcon
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::DrawGrowIcon()
{
	::DrawGrowIcon(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// Window Titles
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// SetTitle
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetTitle(ConstStr255Param title)
{
#if !qMSWindows
	// to minimize flash, we only set the title if it's different from the current title
	CStr255_AC oldTitle;
	GetWTitle(fWMgrWindow, oldTitle);
	if (oldTitle != title)
		SetWTitle(fWMgrWindow, title);
#else
	HWND windowsWindow = GetPortHWND(fWMgrWindow);
	if (windowsWindow)
	{
		char theTitle[256];
		CopyPascalStringToC(title, theTitle);
		//title.CopyTo(theTitle);
		SetWindowText(windowsWindow, (const char*)theTitle);
	}
#endif
}

//----------------------------------------------------------------------------------------
// GetTitle
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::GetTitle(Str255 title) const
{
#if !qMSWindows
	GetWTitle(fWMgrWindow, title);
#else
	HWND windowsWindow = GetPortHWND(fWMgrWindow);
	if (windowsWindow)
	{
		char theTitle[256];
		GetWindowText(windowsWindow, theTitle, sizeof(theTitle));
		CopyCStringToPascal(theTitle, title);
	}
#endif
}

//----------------------------------------------------------------------------------------
// Window Positioning
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Move
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Move(short hGlobal, short vGlobal, bool front)
{
	MacMoveWindow(fWMgrWindow, hGlobal, vGlobal, front);
}

//----------------------------------------------------------------------------------------
// Size
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Size(short w, short h, bool fUpdate)
{
	SizeWindow(fWMgrWindow, w, h, fUpdate);
}

//----------------------------------------------------------------------------------------
// Grow
//----------------------------------------------------------------------------------------

long CClassicWindow_AC::Grow(Point startPt, const Rect& bBox)
{
	return GrowWindow(fWMgrWindow, startPt, &bBox);
}

//----------------------------------------------------------------------------------------
// Drag
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Drag(Point startPt, const Rect& boundsRect)
{
	DragWindow(fWMgrWindow, startPt, &boundsRect);
}

//----------------------------------------------------------------------------------------
// Zoom
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Zoom(WindowPartCode partCode, bool front)
{
	ZoomWindow(fWMgrWindow, partCode, front);
}

//----------------------------------------------------------------------------------------
// IsCollapsable
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::IsCollapsable() const
{
	RequiresAppearance();
	return IsWindowCollapsable(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// IsCollapsed
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::IsCollapsed() const
{
	RequiresAppearance();
	return IsWindowCollapsed(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// Collapse
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Collapse(bool collapse)
{
	RequiresAppearance();
	ThrowIfOSErr_AC(CollapseWindow(fWMgrWindow, collapse));
}

//----------------------------------------------------------------------------------------
// Window Visibility
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Hide
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Hide()
{
	HideWindow(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// Show
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::Show()
{
	MacShowWindow(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// ShowHide
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::ShowHide(bool showFlag)
{
	::ShowHide(fWMgrWindow, showFlag);
}

//----------------------------------------------------------------------------------------
// Window Part Tracking
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// TrackBox
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::TrackBox(Point thePt, WindowPartCode partCode)
{
	return ::TrackBox(fWMgrWindow, thePt, partCode);
}

//----------------------------------------------------------------------------------------
// TrackGoAway
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::TrackGoAway(Point thePt)
{
	return ::TrackGoAway(fWMgrWindow, thePt);
}

#if !OPAQUE_TOOLBOX_STRUCTS
#if !qCarbon
//----------------------------------------------------------------------------------------
// Auxiliary Window Information
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// GetAux
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::GetAux(AuxWinHandle* awHndl) const
{
	return GetAuxWin(fWMgrWindow, awHndl);
}

#endif // !qCarbon
#endif // !OPAQUE_TOOLBOX_STRUCTS

//----------------------------------------------------------------------------------------
// Window Accessors
//----------------------------------------------------------------------------------------

#if !qCarbon

//----------------------------------------------------------------------------------------
// GetGoAwayFlag
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::GetGoAwayFlag() const
{
	return GetWindowGoAwayFlag(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// GetSpareFlag
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::GetSpareFlag() const
{
#if UNIVERSAL_INTERFACES_VERSION <= 0x0332
	return Peek()->spareFlag;
#else
	return GetWindowSpareFlag(fWMgrWindow);
#endif
}

#endif // !qCarbon

//----------------------------------------------------------------------------------------
// GetPort
//----------------------------------------------------------------------------------------

CGrafPtr CClassicWindow_AC::GetPort() const
{
	return GetWindowPort(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// GetKind
//----------------------------------------------------------------------------------------

short CClassicWindow_AC::GetKind() const
{
	return GetWindowKind(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// IsVisible
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::IsVisible() const
{
	return MacIsWindowVisible(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// IsHilited
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::IsHilited() const
{
	return IsWindowHilited(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// IsUpdatePending
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::IsUpdatePending() const
{
#if UNIVERSAL_INTERFACES_VERSION <= 0x0332
#if qCarbon
	CTempRegion_AC updateRgn;
	GetUpdateRgn(updateRgn);
    return updateRgn && !EmptyRgn(updateRgn);
#else
    return (Peek()->updateRgn != NULL) && !EmptyRgn(Peek()->updateRgn);
#endif
#else
	return IsWindowUpdatePending(fWMgrWindow);
#endif
}

//----------------------------------------------------------------------------------------
// GetList
//----------------------------------------------------------------------------------------

WindowRef CClassicWindow_AC::GetList()
{
#if !qCarbon
	return LMGetWindowList();
#else
	return GetWindowList();
#endif
}

//----------------------------------------------------------------------------------------
// GetNext
//----------------------------------------------------------------------------------------

WindowRef CClassicWindow_AC::GetNext() const
{
	return MacGetNextWindow(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// GetStandardState
//----------------------------------------------------------------------------------------

Rect CClassicWindow_AC::GetStandardState() const
{
	Rect rect = {0, 0, 0, 0};
	GetWindowStandardState(fWMgrWindow, &rect);
	return rect;
}

//----------------------------------------------------------------------------------------
// GetUserState
//----------------------------------------------------------------------------------------

Rect CClassicWindow_AC::GetUserState() const
{
	Rect rect = {0, 0, 0, 0};
	GetWindowUserState(fWMgrWindow, &rect);
	return rect;
}

//----------------------------------------------------------------------------------------
// SetKind
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetKind(short kind)
{
	SetWindowKind(fWMgrWindow, kind);
}

//----------------------------------------------------------------------------------------
// SetStandardState
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetStandardState(const Rect& rect)
{
	SetWindowStandardState(fWMgrWindow, &rect);
}

//----------------------------------------------------------------------------------------
// SetUserState
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetUserState(const Rect& rect)
{
	SetWindowUserState(fWMgrWindow, &rect);
}

//----------------------------------------------------------------------------------------
// GetPortBounds
//----------------------------------------------------------------------------------------

Rect CClassicWindow_AC::GetPortBounds() const
{
#if UNIVERSAL_INTERFACES_VERSION <= 0x0332
#if qCarbon
	Rect bounds = {0, 0, 0, 0};
	::GetPortBounds(::GetWindowPort(fWMgrWindow), &bounds);
	return bounds;
#else
	return fWMgrWindow->portRect;
#endif
#else
	Rect bounds = {0, 0, 0, 0};
	GetWindowPortBounds(fWMgrWindow, &bounds);
	return bounds;
#endif
}

//----------------------------------------------------------------------------------------
// old accessors
//----------------------------------------------------------------------------------------

#if !qCarbon

//----------------------------------------------------------------------------------------
// GetDataHandle
//----------------------------------------------------------------------------------------

Handle CClassicWindow_AC::GetDataHandle() const
{
	return GetWindowDataHandle(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// SetDataHandle
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetDataHandle(Handle data)
{
	SetWindowDataHandle(fWMgrWindow, data);
}

#endif // !qCarbon

//----------------------------------------------------------------------------------------
// GetZoomFlag
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::GetZoomFlag() const
{
	return GetWindowZoomFlag(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// GetStructureRgn
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::GetStructureRgn(RgnHandle r) const
{
#if !qCarbon
	GetWindowStructureRgn(fWMgrWindow, r);
#else
	GetRegion(kWindowStructureRgn, r);
#endif
}

//----------------------------------------------------------------------------------------
// GetContentRgn
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::GetContentRgn(RgnHandle r) const
{
#if !qCarbon
	GetWindowContentRgn(fWMgrWindow, r);
#else
	GetRegion(kWindowContentRgn, r);
#endif
}

//----------------------------------------------------------------------------------------
// GetUpdateRgn
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::GetUpdateRgn(RgnHandle r) const
{
#if !qCarbon
	GetWindowUpdateRgn(fWMgrWindow, r);
#else
	GetRegion(kWindowUpdateRgn, r);
#endif
}

//----------------------------------------------------------------------------------------
// GetTitleWidth
//----------------------------------------------------------------------------------------

SInt16 CClassicWindow_AC::GetTitleWidth() const
{
#if !qCarbon
	return GetWindowTitleWidth(fWMgrWindow);
#else
	CTempRegion_AC r;
	GetRegion(kWindowTitleTextRgn, r);
	return r.Bounds().Width();
#endif
}

//----------------------------------------------------------------------------------------
// Utilities
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// InWindowList
//----------------------------------------------------------------------------------------

bool CClassicWindow_AC::InWindowList() const
{
	bool found = false;

	// Use the low mem accessor instead of FrontWindow
	// because we need to look at hidden windows. 
	CClassicWindow_AC w = GetList();
	while (w)
	{
		if (w.fWMgrWindow == fWMgrWindow)
		{
			found = true;
			break;
		}
		w = w.GetNext();
	}

	return found;
}

#if !qCarbon

//----------------------------------------------------------------------------------------
// GetWindowDefProc
//----------------------------------------------------------------------------------------

Handle CClassicWindow_AC::GetWindowDefProc() const
{
	return Peek()->windowDefProc;
}

//----------------------------------------------------------------------------------------
// SetWindowDefProc
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetWindowDefProc(Handle windowDef)
{
	Peek()->windowDefProc = windowDef;
}

//----------------------------------------------------------------------------------------
// LoadDefProc:
//----------------------------------------------------------------------------------------

Handle CClassicWindow_AC::LoadDefProc(Handle windowDefProc)
{
	Handle returnVal = NULL;

	// strip the variant code
	Handle wDefProc = reinterpret_cast<Handle>(StripLong_AC(windowDefProc));

	if (*wDefProc)
		returnVal = wDefProc;
	else
	{
		// if Master Ptr is NULL => resource is purged
		::MacLoadResource(wDefProc);
		if (ResError() == noErr)
		{
			// only return it if the LoadResource worked
			returnVal = wDefProc;
		}
	}

	return returnVal;
}

//----------------------------------------------------------------------------------------
// GetAndLoadWDefProc:
//----------------------------------------------------------------------------------------

Handle CClassicWindow_AC::GetAndLoadWDefProc() const
{
	return LoadDefProc(GetWindowDefProc());
}

#endif // !qCarbon

#if !qMSWindows
//----------------------------------------------------------------------------------------
// DrawResizeIcon:
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::DrawResizeIcon()
{
	CRect_AC r(GetPortBounds());	// CRect_AC r(GetQDExtent());
	enum
	{
		kSBarSize = 16,
		kSBarSizeMinus1 = kSBarSize - 1
	};
	r[topLeft] = r[botRight] - CPoint_AC(kSBarSizeMinus1, kSBarSizeMinus1);

	// clip down and avoid drawing the lines that delimit scroll bars

	CTempRegion_AC tempRgn;
	CTempRegion_AC tempRgn2;

	// Avoid drawing the GrowIcon if it would have been clipped
	::GetClip(tempRgn);
	::RectRgn(tempRgn2, &r);
	::SectRgn(tempRgn2, tempRgn, tempRgn2);
	if (!::EmptyRgn(tempRgn2))
	{
		::SetClip(tempRgn2);
		::PenNormal();
		::DrawGrowIcon(fWMgrWindow);
		::SetClip(tempRgn);
	}
}
#endif

//----------------------------------------------------------------------------------------
// SetBackgroundTheme:
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::SetBackgroundTheme(ThemeBrush theBrush, bool invalidate)
{
#if !qMSWindows
	RequiresAppearance();

	CSaveThemeDrawingState_AC savedState(GetWindowCGrafPtr_AC(fWMgrWindow));

	::ThrowIfBadOSStatus_AC(::SetThemeWindowBackground(fWMgrWindow, theBrush, invalidate));
#else
	#pragma message ("CClassicWindow_AC::SetBackgroundTheme: Themes not available for Windows.")
	#pragma unused (theBrush, invalidate)
#endif
}

//----------------------------------------------------------------------------------------
// operators for C++meisters
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// release
//----------------------------------------------------------------------------------------

WindowRef CClassicWindow_AC::release()
{
	WindowRef window = fWMgrWindow;
	fWMgrWindow = NULL;
	return window;
}

//----------------------------------------------------------------------------------------
// reset
//----------------------------------------------------------------------------------------

void CClassicWindow_AC::reset()
{
	Dispose();
}


//========================================================================================
// CAppearanceWindow_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CAppearanceWindow_AC::CAppearanceWindow_AC(short windowID, void* wStorage, WindowRef behind)
	:	CClassicWindow_AC(windowID, wStorage, behind)
{
}

CAppearanceWindow_AC::CAppearanceWindow_AC(void* wStorage, const Rect& boundsRect, ConstStr255Param title, 
										   bool visible, short procID, WindowRef behind, bool goAwayFlag, 
										   long refCon)
	:	CClassicWindow_AC(wStorage, boundsRect, title, visible, procID, behind, 
						  goAwayFlag, refCon)
{
}

#if qPowerPC

CAppearanceWindow_AC::CAppearanceWindow_AC(WindowClass windowClass, WindowAttributes attributes, 
										   const Rect& contentBounds)
	:	CClassicWindow_AC(Create(windowClass, attributes, contentBounds))
{
}

CAppearanceWindow_AC::CAppearanceWindow_AC(EFromResource tag, SInt16 resID)
	:	CClassicWindow_AC(Create(tag, resID))
{
}

CAppearanceWindow_AC::CAppearanceWindow_AC(EFromCollection tag, Collection collection)
	:	CClassicWindow_AC(Create(tag, collection))
{
}

//----------------------------------------------------------------------------------------
// Window Creation & Persistence
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Create
//----------------------------------------------------------------------------------------

WindowRef CAppearanceWindow_AC::Create(WindowClass windowClass, WindowAttributes attributes, 
									   const Rect& contentBounds)
{
	WindowRef window = NULL;
	RequiresWindowManager85();
	ThrowIfOSErr_AC(CreateNewWindow(windowClass, attributes, &contentBounds, &window));
	return window;
}

WindowRef CAppearanceWindow_AC::Create(EFromResource, SInt16 resID)
{
	WindowRef window = NULL;
	RequiresWindowManager85();
	ThrowIfOSErr_AC(CreateWindowFromResource(resID, &window));
	return window;
}

WindowRef CAppearanceWindow_AC::Create(EFromCollection, Collection collection)
{
	WindowRef window = NULL;
	RequiresWindowManager85();
	ThrowIfOSErr_AC(CreateWindowFromCollection(collection, &window));
	return window;
}

//----------------------------------------------------------------------------------------
// StoreIntoCollection
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::StoreIntoCollection(Collection collection)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(StoreWindowIntoCollection(fWMgrWindow, collection));
}

//----------------------------------------------------------------------------------------
// GetRetainCount
//----------------------------------------------------------------------------------------

ItemCount CAppearanceWindow_AC::GetRetainCount() const
{
	UInt32 outCount = 0;
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowOwnerCount(fWMgrWindow, &outCount));
	return outCount;
}

//----------------------------------------------------------------------------------------
// Retain
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::Retain()
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(CloneWindow(fWMgrWindow));
}

//----------------------------------------------------------------------------------------
// Window part tracking
//----------------------------------------------------------------------------------------

#if UNIVERSAL_INTERFACES_VERSION > 0x0332
//----------------------------------------------------------------------------------------
// GetWidgetHilite
//----------------------------------------------------------------------------------------

WindowDefPartCode CAppearanceWindow_AC::GetWidgetHilite() const
{
	WindowDefPartCode outHilite = 0;
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowWidgetHilite(fWMgrWindow, &outHilite));
	return outHilite;
}
#endif // UNIVERSAL_INTERFACES_VERSION > 0x0332

//----------------------------------------------------------------------------------------
// Window Metainformation Accessors
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// GetClass
//----------------------------------------------------------------------------------------

WindowClass CAppearanceWindow_AC::GetClass() const
{
	WindowClass outClass = 0;
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowClass(fWMgrWindow, &outClass));
	return outClass;
}

//----------------------------------------------------------------------------------------
// GetAttributes
//----------------------------------------------------------------------------------------

WindowAttributes CAppearanceWindow_AC::GetAttributes() const
{
	WindowAttributes outAttributes = 0;
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowAttributes(fWMgrWindow, &outAttributes));
	return outAttributes;
}

//----------------------------------------------------------------------------------------
// Background Image
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// SetContentColor
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetContentColor(const RGBColor& color)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(SetWindowContentColor(fWMgrWindow, &color));
}

//----------------------------------------------------------------------------------------
// GetContentColor
//----------------------------------------------------------------------------------------

RGBColor CAppearanceWindow_AC::GetContentColor() const
{
	RGBColor color = {0, 0, 0};
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowContentColor(fWMgrWindow, &color));
	return color;
}

//----------------------------------------------------------------------------------------
// GetContentPattern
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::GetContentPattern(PixPatHandle outPixPat) const
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowContentPattern(fWMgrWindow, outPixPat));
}

//----------------------------------------------------------------------------------------
// SetContentPattern
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetContentPattern(PixPatHandle pixPat)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(SetWindowContentPattern(fWMgrWindow, pixPat));
}

//----------------------------------------------------------------------------------------
// InstallContentPaintProc
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::InstallContentPaintProc(WindowPaintUPP paintProc, 
												   WindowPaintProcOptions options, void* refCon)
{
	if (GetSystemVersion_AC() >= 0x900)
		ThrowIfOSErr_AC(InstallWindowContentPaintProc(fWMgrWindow, paintProc, options, refCon));
}

//----------------------------------------------------------------------------------------
// Window List
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// FrontNonFloating
//----------------------------------------------------------------------------------------

WindowRef CAppearanceWindow_AC::FrontNonFloating()
{
	RequiresWindowManager85();
	return FrontNonFloatingWindow();
}

//----------------------------------------------------------------------------------------
// Misc Low-Level stuff
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// IsValid
//----------------------------------------------------------------------------------------

bool CAppearanceWindow_AC::IsValid() const
{
	RequiresWindowManager85();
	return IsValidWindowPtr(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// Various & Sundry Window Accessors
//----------------------------------------------------------------------------------------

#if UNIVERSAL_INTERFACES_VERSION > 0x0332
//----------------------------------------------------------------------------------------
// GetStructureWidths
//----------------------------------------------------------------------------------------

Rect CAppearanceWindow_AC::GetStructureWidths() const
{
	Rect outRect = {0, 0, 0, 0};
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowStructureWidths(fWMgrWindow, &outRect));
	return outRect;
}
#endif // UNIVERSAL_INTERFACES_VERSION > 0x0332

//----------------------------------------------------------------------------------------
// Update Events
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Invalidate
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::Invalidate(RgnHandle region)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(InvalWindowRgn(fWMgrWindow, region));
}

//----------------------------------------------------------------------------------------
// Invalidate
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::Invalidate(const Rect& bounds)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(InvalWindowRect(fWMgrWindow, &bounds));
}

//----------------------------------------------------------------------------------------
// Validate
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::Validate(RgnHandle region)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(ValidWindowRgn(fWMgrWindow, region));
}

//----------------------------------------------------------------------------------------
// Validate
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::Validate(const Rect& bounds)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(ValidWindowRect(fWMgrWindow, &bounds));
}

//----------------------------------------------------------------------------------------
// Window Proxies
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// SetProxyFSSpec
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetProxyFSSpec(const FSSpec& inFile)
{
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(SetWindowProxyFSSpec(fWMgrWindow, &inFile));
}

//----------------------------------------------------------------------------------------
// GetProxyFSSpec
//----------------------------------------------------------------------------------------

FSSpec CAppearanceWindow_AC::GetProxyFSSpec() const
{
	CFSSpec_AC outFile;
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(GetWindowProxyFSSpec(fWMgrWindow, &outFile));
	return outFile;
}

//----------------------------------------------------------------------------------------
// SetProxyAlias
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetProxyAlias(AliasHandle alias)
{
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(SetWindowProxyAlias(fWMgrWindow, alias));
}

//----------------------------------------------------------------------------------------
// GetProxyAlias
//----------------------------------------------------------------------------------------

AliasHandle CAppearanceWindow_AC::GetProxyAlias() const
{
	AliasHandle alias = NULL;
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(GetWindowProxyAlias(fWMgrWindow, &alias));
	return alias;
}

//----------------------------------------------------------------------------------------
// SetProxyCreatorAndType
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetProxyCreatorAndType(OSType fileCreator, OSType fileType, SInt16 vRefNum)
{
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(SetWindowProxyCreatorAndType(fWMgrWindow, fileCreator, fileType, vRefNum));
}

//----------------------------------------------------------------------------------------
// GetProxyIcon:
//----------------------------------------------------------------------------------------

IconRef CAppearanceWindow_AC::GetProxyIcon() const
{
	IconRef icon = NULL;
	if (::HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(::GetWindowProxyIcon(fWMgrWindow, &icon));
	return icon;
}

//----------------------------------------------------------------------------------------
// SetProxyIcon:
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetProxyIcon(IconRef icon)
{
	if (::HasWindowProxyIcons_AC())
	{
		CTempDrawingEnvironment_AC savedPort(kSaveGrafPort);
		ThrowIfOSErr_AC(::SetWindowProxyIcon(fWMgrWindow, icon));
	}
}

//----------------------------------------------------------------------------------------
// SetProxyIconByFile:
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetProxyIconByFile(CFile_AC* proxyFile)
{
	// Do not set the proxy icon if I am a modal window, since WM will not draw the
	// title bar correctly, and won't track the mouse in the right areas.
	if (/*!IsModalWindow(fWMgrWindow) &&*/ ::HasWindowProxyIcons_AC())
	{
		CTempGrafPort_AC saveGrafPort;		// The GrafPort may get changed and we won't know.

		if (proxyFile->GetFileSpec().Exists())
		{
			AliasHandle alias;
			ThrowIfOSErr_AC(proxyFile->GetAlias(alias));
			ThrowIfOSErr_AC(::SetWindowProxyAlias(fWMgrWindow, alias));
			SetModified(false);
		}
		else
		{
			ThrowIfOSErr_AC(::SetWindowProxyCreatorAndType(fWMgrWindow,
														   proxyFile->GetCachedFileCreator(),
														   proxyFile->GetCachedFileType(),
														   -1 /* boot volume */));
			SetModified(true);
		}
	}
}

//----------------------------------------------------------------------------------------
// RemoveProxy
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::RemoveProxy()
{
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(RemoveWindowProxy(fWMgrWindow));
}

//----------------------------------------------------------------------------------------
// BeginProxyDrag
//----------------------------------------------------------------------------------------

DragReference CAppearanceWindow_AC::BeginProxyDrag(RgnHandle outDragOutlineRgn)
{
	DragReference outNewDrag = NULL;
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(BeginWindowProxyDrag(fWMgrWindow, &outNewDrag, outDragOutlineRgn));
	return outNewDrag;
}

//----------------------------------------------------------------------------------------
// EndProxyDrag
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::EndProxyDrag(DragReference theDrag)
{
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(EndWindowProxyDrag(fWMgrWindow, theDrag));
}

//----------------------------------------------------------------------------------------
// TrackProxyFromExistingDrag
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::TrackProxyFromExistingDrag(Point startPt, DragReference drag, 
													  RgnHandle inDragOutlineRgn)
{
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(TrackWindowProxyFromExistingDrag(fWMgrWindow, startPt, drag, 
														 inDragOutlineRgn));
}

//----------------------------------------------------------------------------------------
// TrackProxyDrag:
//----------------------------------------------------------------------------------------

OSStatus CAppearanceWindow_AC::TrackProxyDrag(Point startPt)
{
	OSStatus err = noErr;
	if (HasWindowProxyIcons_AC())
		err = TrackWindowProxyDrag(fWMgrWindow, startPt);
	return err;
}

//----------------------------------------------------------------------------------------
// IsModified:
//----------------------------------------------------------------------------------------

bool CAppearanceWindow_AC::IsModified() const
{
	return HasWindowProxyIcons_AC() ? IsWindowModified(fWMgrWindow) : false;
}

//----------------------------------------------------------------------------------------
// SetModified:
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetModified(bool isModified)
{
	if (HasWindowProxyIcons_AC())
		ThrowIfOSErr_AC(::SetWindowModified(fWMgrWindow, isModified));
}

//----------------------------------------------------------------------------------------
// IsPathSelectClick
//----------------------------------------------------------------------------------------

bool CAppearanceWindow_AC::IsPathSelectClick(const EventRecord& event)
{
	return HasWindowProxyIcons_AC() ? IsWindowPathSelectClick(fWMgrWindow, &event) : false;
}

//----------------------------------------------------------------------------------------
// PathSelect
//----------------------------------------------------------------------------------------

OSStatus CAppearanceWindow_AC::PathSelect(MenuRef menu, SInt32* outMenuResult)
{
	OSStatus err = 0;
	if (HasWindowProxyIcons_AC())
		err = WindowPathSelect(fWMgrWindow, menu, outMenuResult);
	return err;
}

//----------------------------------------------------------------------------------------
// HandlePathSelect:
//----------------------------------------------------------------------------------------

bool CAppearanceWindow_AC::HandlePathSelect(const EventRecord& event)
{
	// Implementation note: the error code errWindowDoesNotHaveProxy is
	// returned even if the window has a proxy icon; what the error means is,
	// there is no saved _file_ associated with the window.  This error code
	// led to the disabling of the inProxyDrag case in HandleMouseDown, and the
	// disabling and the debugging ProgramReport calls.  The only way to check
	// for this condition is to either maintain it ourselves in CAppearanceWindow_AC (why
	// bother?), or ignore the error.  We'll use the latter.

	bool didPathSelect = false;

	didPathSelect = IsPathSelectClick(event);
	if (didPathSelect)
	{
		OSStatus err = PathSelect();

		// It's okay to cancel or not have a proxy.  There's no way to
		// check for the latter except by ignoring the error as we
		// do here.
		didPathSelect = (err == noErr);
		if (didPathSelect)
		{
			// switch to the Finder (signature 'MACS')
			CProcess_AC psn = CProcess_AC::FindBySignature('MACS');
			if (psn)
				psn.MakeFrontProcess();
		}
	}

	return didPathSelect;
}

//----------------------------------------------------------------------------------------
// HiliteWindowFrameForDrag
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// HiliteFrameForDrag
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::HiliteFrameForDrag(bool hilited)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(HiliteWindowFrameForDrag(fWMgrWindow, hilited));
}

//----------------------------------------------------------------------------------------
// Window Transitions
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Transition
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::Transition(WindowTransitionEffect effect, WindowTransitionAction action, 
									  const Rect& rect)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(TransitionWindow(fWMgrWindow, effect, action, &rect));
}

void CAppearanceWindow_AC::Transition(WindowTransitionEffect effect, WindowTransitionAction action)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(TransitionWindow(fWMgrWindow, effect, action, NULL));
}

//----------------------------------------------------------------------------------------
// Window Positioning
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// GetBounds
//----------------------------------------------------------------------------------------

Rect CAppearanceWindow_AC::GetBounds(WindowRegionCode regionCode) const
{
	Rect globalBounds = {0, 0, 0, 0};
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowBounds(fWMgrWindow, regionCode, &globalBounds));
	return globalBounds;
}

//----------------------------------------------------------------------------------------
// Resize
//----------------------------------------------------------------------------------------

CAppearanceWindow_AC::ResizeResult CAppearanceWindow_AC::Resize(Point startPoint, const Rect& sizeConstraints)
{
	ResizeResult result = {false, {0, 0, 0, 0}};
	RequiresWindowManager85();
	result.resized = ResizeWindow(fWMgrWindow, startPoint, &sizeConstraints, &result.newContentRect);
	return result;
}

CAppearanceWindow_AC::ResizeResult CAppearanceWindow_AC::Resize(Point startPoint)
{
	ResizeResult result = {false, {0, 0, 0, 0}};
	RequiresWindowManager85();
	result.resized = ResizeWindow(fWMgrWindow, startPoint, NULL, &result.newContentRect);
	return result;
}

//----------------------------------------------------------------------------------------
// SetBounds
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetBounds(WindowRegionCode regionCode, const Rect& globalBounds)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(SetWindowBounds(fWMgrWindow, regionCode, &globalBounds));
}

//----------------------------------------------------------------------------------------
// Reposition
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::Reposition(WindowRef parentWindow, WindowPositionMethod method)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(RepositionWindow(fWMgrWindow, parentWindow, method));
}

//----------------------------------------------------------------------------------------
// MoveStructure
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::MoveStructure(short hGlobal, short vGlobal)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(MoveWindowStructure(fWMgrWindow, hGlobal, vGlobal));
}

//----------------------------------------------------------------------------------------
// IsInStandardState
//----------------------------------------------------------------------------------------

bool CAppearanceWindow_AC::IsInStandardState(Point* idealSize, Rect* idealStandardState) const
{
	RequiresWindowManager85();
	return IsWindowInStandardState(fWMgrWindow, idealSize, idealStandardState);
}

//----------------------------------------------------------------------------------------
// ZoomIdeal
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::ZoomIdeal(WindowPartCode partCode, Point* ioIdealSize)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(ZoomWindowIdeal(fWMgrWindow, partCode, ioIdealSize));
}

//----------------------------------------------------------------------------------------
// GetIdealUserState
//----------------------------------------------------------------------------------------

Rect CAppearanceWindow_AC::GetIdealUserState() const
{
	Rect userState = {0, 0, 0, 0};
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowIdealUserState(fWMgrWindow, &userState));
	return userState;
}

//----------------------------------------------------------------------------------------
// SetIdealUserState
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetIdealUserState(const Rect& userState)
{
	RequiresWindowManager85();
#if UNIVERSAL_INTERFACES_VERSION <= 0x0332
	// Work around non-const API
	Rect userStateCopy(userState);
	ThrowIfOSErr_AC(SetWindowIdealUserState(fWMgrWindow, &userStateCopy));
#else
	ThrowIfOSErr_AC(SetWindowIdealUserState(fWMgrWindow, &userState));
#endif
}

//----------------------------------------------------------------------------------------
// Window Properties
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// GetProperty
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::GetProperty(PropertyCreator propertyCreator, PropertyTag propertyTag, 
									   UInt32 bufferSize, UInt32* actualSize, void* propertyBuffer) const
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowProperty(fWMgrWindow, propertyCreator, propertyTag, 
									  bufferSize, actualSize, propertyBuffer));
}

//----------------------------------------------------------------------------------------
// GetPropertySize
//----------------------------------------------------------------------------------------

UInt32 CAppearanceWindow_AC::GetPropertySize(PropertyCreator creator, PropertyTag tag) const
{
	UInt32 size = 0;
	RequiresWindowManager85();
	ThrowIfOSErr_AC(GetWindowPropertySize(fWMgrWindow, creator, tag, &size));
	return size;
}

//----------------------------------------------------------------------------------------
// SetProperty
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::SetProperty(PropertyCreator propertyCreator, PropertyTag propertyTag, 
									   UInt32 propertySize, void* propertyBuffer)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(SetWindowProperty(fWMgrWindow, propertyCreator, propertyTag, 
									  propertySize, propertyBuffer));
}

//----------------------------------------------------------------------------------------
// RemoveProperty
//----------------------------------------------------------------------------------------

void CAppearanceWindow_AC::RemoveProperty(PropertyCreator propertyCreator, PropertyTag propertyTag)
{
	RequiresWindowManager85();
	ThrowIfOSErr_AC(RemoveWindowProperty(fWMgrWindow, propertyCreator, propertyTag));
}

//----------------------------------------------------------------------------------------
// Window Accessors
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// GetGoAwayFlag
//----------------------------------------------------------------------------------------

bool CAppearanceWindow_AC::GetGoAwayFlag() const
{
#if !qCarbon
	return CClassicWindow_AC::GetGoAwayFlag();
#else
	return GetAttributes() & kWindowCloseBoxAttribute;
#endif
}

//----------------------------------------------------------------------------------------
// GetSpareFlag
//----------------------------------------------------------------------------------------

bool CAppearanceWindow_AC::GetSpareFlag() const
{
#if !qCarbon
	return CClassicWindow_AC::GetSpareFlag();
#else
	return GetAttributes() & kWindowFullZoomAttribute;
#endif
}

#endif // qPowerPC


//========================================================================================
// CCarbonWindow_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CCarbonWindow_AC::CCarbonWindow_AC(short windowID, void* wStorage, WindowRef behind)
	:	CAppearanceWindow_AC(windowID, wStorage, behind)
{
}

CCarbonWindow_AC::CCarbonWindow_AC(void* wStorage, const Rect& boundsRect, ConstStr255Param title, 
								   bool visible, short procID, WindowRef behind, bool goAwayFlag, 
								   long refCon)
	:	CAppearanceWindow_AC(wStorage, boundsRect, title, visible, procID, behind, 
							 goAwayFlag, refCon)
{
}

#if qPowerPC

CCarbonWindow_AC::CCarbonWindow_AC(WindowClass windowClass, WindowAttributes attributes, 
								   const Rect& contentBounds)
	:	CAppearanceWindow_AC(windowClass, attributes, contentBounds)
{
}

CCarbonWindow_AC::CCarbonWindow_AC(EFromResource tag, SInt16 resID)
	:	CAppearanceWindow_AC(tag, resID)
{
}

CCarbonWindow_AC::CCarbonWindow_AC(EFromCollection tag, Collection collection)
	:	CAppearanceWindow_AC(tag, collection)
{
}

#endif // qPowerPC

#if qCarbon

CCarbonWindow_AC::CCarbonWindow_AC(const WindowDefSpec& def, WindowClass windowClass, 
								   WindowAttributes attributes, const Rect& contentBounds)
	:	CAppearanceWindow_AC(Create(def, windowClass, attributes, contentBounds))
{
}

//----------------------------------------------------------------------------------------
// Window Creation & Persistence
//----------------------------------------------------------------------------------------

WindowRef CCarbonWindow_AC::Create(const WindowDefSpec& def, WindowClass windowClass, 
								   WindowAttributes attributes, const Rect& contentBounds)
{
	WindowRef window = NULL;
	ThrowIfOSErr_AC(CreateCustomWindow(&def, windowClass, attributes, &contentBounds, 
									   &window));
	return window;
}

//----------------------------------------------------------------------------------------
// Close
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::Close()
{
#if qDebugMsg
	ProgramReport_AC("CloseWindow is not supported in Carbon");
#endif
}

#if UNIVERSAL_INTERFACES_VERSION > 0x0332

//----------------------------------------------------------------------------------------
// GetRetainCount
//----------------------------------------------------------------------------------------

ItemCount CCarbonWindow_AC::GetRetainCount() const
{
	return GetWindowRetainCount(fWMgrWindow);
}

//----------------------------------------------------------------------------------------
// Retain
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::Retain()
{
	ThrowIfOSErr_AC(RetainWindow(fWMgrWindow));
}

//----------------------------------------------------------------------------------------
// Release
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::Release()
{
	ThrowIfOSErr_AC(ReleaseWindow(fWMgrWindow));
}

#endif // UNIVERSAL_INTERFACES_VERSION > 0x0332

//----------------------------------------------------------------------------------------
// Custom Windows
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// ReshapeCustomWindow
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::ReshapeCustomWindow()
{
	ThrowIfOSErr_AC(::ReshapeCustomWindow(fWMgrWindow));
}

//----------------------------------------------------------------------------------------
// Window Metainformation Accessors
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// ChangeAttributes
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::ChangeAttributes(WindowAttributes setTheseAttributes, 
										WindowAttributes clearTheseAttributes)
{
	ThrowIfOSErr_AC(ChangeWindowAttributes(fWMgrWindow, setTheseAttributes, 
										   clearTheseAttributes));
}

#if UNIVERSAL_INTERFACES_VERSION > 0x0332

//----------------------------------------------------------------------------------------
// SetClass
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::SetClass(WindowClass inWindowClass)
{
	ThrowIfOSErr_AC(SetWindowClass(fWMgrWindow, inWindowClass));
}

#endif // UNIVERSAL_INTERFACES_VERSION > 0x0332

//----------------------------------------------------------------------------------------
// Window Modality
//----------------------------------------------------------------------------------------

#if qCarbonEvents

//----------------------------------------------------------------------------------------
// SetModality
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::SetModality(WindowModality inModalKind, WindowRef inUnavailableWindow)
{
	RequiresCarbonEvents();
	ThrowIfOSErr_AC(SetWindowModality(fWMgrWindow, inModalKind, inUnavailableWindow));
}

//----------------------------------------------------------------------------------------
// GetModality
//----------------------------------------------------------------------------------------

WindowModality CCarbonWindow_AC::GetModality(WindowRef* outUnavailableWindow) const
{
	WindowModality outModalKind = 0;
	RequiresCarbonEvents();
	ThrowIfOSErr_AC(GetWindowModality(fWMgrWindow, &outModalKind, outUnavailableWindow));
	return outModalKind;
}

#endif // qCarbonEvents

//----------------------------------------------------------------------------------------
// Scrolling Routines
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// ScrollRect
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::ScrollRect(const Rect& inScrollRect, SInt16 inHPixels, SInt16 inVPixels, 
								  ScrollWindowOptions inOptions, RgnHandle outExposedRgn)
{
	ThrowIfOSErr_AC(ScrollWindowRect(fWMgrWindow, &inScrollRect, inHPixels, inVPixels, 
									 inOptions, outExposedRgn));
}

//----------------------------------------------------------------------------------------
// ScrollRegion
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::ScrollRegion(RgnHandle inScrollRgn, SInt16 inHPixels, SInt16 inVPixels, 
									ScrollWindowOptions inOptions, RgnHandle outExposedRgn)
{
	ThrowIfOSErr_AC(ScrollWindowRegion(fWMgrWindow, inScrollRgn, inHPixels, inVPixels, 
									   inOptions, outExposedRgn));
}

//----------------------------------------------------------------------------------------
// Window List
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Find
//----------------------------------------------------------------------------------------

CCarbonWindow_AC::FindWindowResult CCarbonWindow_AC::Find(Point where, WindowClass inWindowClass)
{
	FindWindowResult result = {0, NULL};
	ThrowIfOSErr_AC(FindWindowOfClass(&where, inWindowClass, &result.window, &result.partCode));
	return result;
}

//----------------------------------------------------------------------------------------
// Front
//----------------------------------------------------------------------------------------

WindowRef CCarbonWindow_AC::Front(WindowClass inWindowClass, bool mustBeVisible)
{
	return GetFrontWindowOfClass(inWindowClass, mustBeVisible);
}

//----------------------------------------------------------------------------------------
// GetNextOfClass
//----------------------------------------------------------------------------------------

WindowRef CCarbonWindow_AC::GetNextOfClass(WindowClass inWindowClass, bool mustBeVisible) const
{
	return GetNextWindowOfClass(fWMgrWindow, inWindowClass, mustBeVisible);
}

#if UNIVERSAL_INTERFACES_VERSION > 0x0332

//----------------------------------------------------------------------------------------
// SetAlternateTitle
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::SetAlternateTitle(CFStringRef inTitle)
{
	ThrowIfOSErr_AC(SetWindowAlternateTitle(fWMgrWindow, inTitle));
}

//----------------------------------------------------------------------------------------
// CopyAlternateTitle
//----------------------------------------------------------------------------------------

CFStringRef CCarbonWindow_AC::CopyAlternateTitle() const
{
	CFStringRef outTitle = NULL;
	ThrowIfOSErr_AC(CopyWindowAlternateTitle(fWMgrWindow, &outTitle));
	return outTitle;
}

//----------------------------------------------------------------------------------------
// Window Titles
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// SetTitle
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::SetTitle(CFStringRef inString)
{
	ThrowIfOSErr_AC(SetWindowTitleWithCFString(fWMgrWindow, inString));
}

//----------------------------------------------------------------------------------------
// CopyTitle
//----------------------------------------------------------------------------------------

CFStringRef CCarbonWindow_AC::CopyTitle() const
{
	CFStringRef outString = NULL;
	ThrowIfOSErr_AC(CopyWindowTitleAsCFString(fWMgrWindow, &outString));
	return outString;
}

#endif // UNIVERSAL_INTERFACES_VERSION > 0x0332

//----------------------------------------------------------------------------------------
// Window Transitions
//----------------------------------------------------------------------------------------

#if TARGET_RT_MAC_MACHO

//----------------------------------------------------------------------------------------
// TransitionAndParent
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::TransitionAndParent(WindowRef parentWindow, WindowTransitionEffect effect, 
										   WindowTransitionAction action, const Rect& rect)
{
	ThrowIfOSErr_AC(TransitionWindowAndParent(fWMgrWindow, parentWindow, effect, action, &rect));
}

void CCarbonWindow_AC::TransitionAndParent(WindowRef parentWindow, WindowTransitionEffect effect, 
										   WindowTransitionAction action)
{
	ThrowIfOSErr_AC(TransitionWindowAndParent(fWMgrWindow, parentWindow, effect, action, NULL));
}

#endif // TARGET_RT_MAC_MACHO

//----------------------------------------------------------------------------------------
// Window Positioning
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// Grow
//----------------------------------------------------------------------------------------

long CCarbonWindow_AC::Grow(Point startPt)
{
	return GrowWindow(fWMgrWindow, startPt, NULL);
}

//----------------------------------------------------------------------------------------
// Drag
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::Drag(Point startPt)
{
	DragWindow(fWMgrWindow, startPt, NULL);
}

#if qCarbonEvents

//----------------------------------------------------------------------------------------
// GetGreatestAreaDevice
//----------------------------------------------------------------------------------------

GDHandle CCarbonWindow_AC::GetGreatestAreaDevice(WindowRegionCode inRegion, 
												 Rect* outGreatestDeviceRect) const
{
	GDHandle outGreatestDevice = NULL;
	RequiresCarbonEvents();
	ThrowIfOSErr_AC(GetWindowGreatestAreaDevice(fWMgrWindow, inRegion, &outGreatestDevice, 
												outGreatestDeviceRect));
	return outGreatestDevice;
}

//----------------------------------------------------------------------------------------
// ConstrainToScreen
//----------------------------------------------------------------------------------------

Rect CCarbonWindow_AC::ConstrainToScreen(WindowRegionCode inRegionCode, 
										 WindowConstrainOptions inOptions, 
										 const Rect& inScreenRect)
{
	Rect outStructure = {0, 0, 0, 0};
	RequiresCarbonEvents();
	ThrowIfOSErr_AC(ConstrainWindowToScreen(fWMgrWindow, inRegionCode, inOptions, 
											&inScreenRect, &outStructure));
	return outStructure;
}

Rect CCarbonWindow_AC::ConstrainToScreen(WindowRegionCode inRegionCode, 
										 WindowConstrainOptions inOptions)
{
	Rect outStructure = {0, 0, 0, 0};
	RequiresCarbonEvents();
	ThrowIfOSErr_AC(ConstrainWindowToScreen(fWMgrWindow, inRegionCode, inOptions, 
											NULL, &outStructure));
	return outStructure;
}

#endif // qCarbonEvents

//----------------------------------------------------------------------------------------
// Sheet support
//----------------------------------------------------------------------------------------

#if TARGET_RT_MAC_MACHO

//----------------------------------------------------------------------------------------
// ShowSheet
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::ShowSheet(WindowRef parentWindow)
{
	ThrowIfOSErr_AC(ShowSheetWindow(fWMgrWindow, parentWindow));
}

//----------------------------------------------------------------------------------------
// HideSheet
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::HideSheet()
{
	ThrowIfOSErr_AC(HideSheetWindow(fWMgrWindow));
}

//----------------------------------------------------------------------------------------
// GetSheetParent
//----------------------------------------------------------------------------------------

WindowRef CCarbonWindow_AC::GetSheetParent() const
{
	WindowRef outParentWindow = NULL;
	ThrowIfOSErr_AC(GetSheetWindowParent(fWMgrWindow, &outParentWindow));
	return outParentWindow;
}

#endif // TARGET_RT_MAC_MACHO

//----------------------------------------------------------------------------------------
// Window Properties
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// GetPropertyAttributes
//----------------------------------------------------------------------------------------

UInt32 CCarbonWindow_AC::GetPropertyAttributes(OSType propertyCreator, OSType propertyTag) const
{
	UInt32 attributes = 0;
	ThrowIfOSErr_AC(GetWindowPropertyAttributes(fWMgrWindow, propertyCreator, propertyTag, 
												&attributes));
	return attributes;
}

//----------------------------------------------------------------------------------------
// ChangePropertyAttributes
//----------------------------------------------------------------------------------------

void CCarbonWindow_AC::ChangePropertyAttributes(OSType propertyCreator, OSType propertyTag, 
												UInt32 attributesToSet, UInt32 attributesToClear)
{
	ThrowIfOSErr_AC(ChangeWindowPropertyAttributes(fWMgrWindow, propertyCreator, propertyTag, 
												   attributesToSet, attributesToClear));
}

#endif // qCarbon


//========================================================================================
// CWindow_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CWindow_AC::CWindow_AC(short windowID, void* wStorage, WindowRef behind)
	:	inherited_t(windowID, wStorage, behind)
{
}

CWindow_AC::CWindow_AC(void* wStorage, const Rect& boundsRect, ConstStr255Param title, 
					   bool visible, short procID, WindowRef behind, bool goAwayFlag, 
					   long refCon)
	:	inherited_t(wStorage, boundsRect, title, visible, procID, behind, 
					goAwayFlag, refCon)
{
}

#if qPowerPC

CWindow_AC::CWindow_AC(WindowClass windowClass, WindowAttributes attributes, 
					   const Rect& contentBounds)
	:	inherited_t(windowClass, attributes, contentBounds)
{
}

CWindow_AC::CWindow_AC(EFromResource tag, SInt16 resID)
	:	inherited_t(tag, resID)
{
}

CWindow_AC::CWindow_AC(EFromCollection tag, Collection collection)
	:	inherited_t(tag, collection)
{
}

#endif // qPowerPC

#if qCarbon

CWindow_AC::CWindow_AC(const WindowDefSpec& def, WindowClass windowClass, 
					   WindowAttributes attributes, const Rect& contentBounds)
	:	inherited_t(def, windowClass, attributes, contentBounds)
{
}

#endif // qCarbon


//========================================================================================
// CWindowIterator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CWindowIterator_AC::CWindowIterator_AC:
//----------------------------------------------------------------------------------------

CWindowIterator_AC::CWindowIterator_AC(bool itsForward)
	:	fIterateForward(itsForward)
// CWindowIterator_AC initializes this iterator according to the specified parameters.
//
// itsForward:	Specifies the direction in which iteration is to proceed; true
// 				indicates forward iteration.
//
// Call?		As needed.
// Override?	Seldom.
{
	First();
}

//----------------------------------------------------------------------------------------
// CWindowIterator_AC::First:
//----------------------------------------------------------------------------------------

WindowRef CWindowIterator_AC::First()
{
	return fCurrent = fIterateForward ? FirstWindow() : LastWindow();
}

//----------------------------------------------------------------------------------------
// CWindowIterator_AC::Next:
//----------------------------------------------------------------------------------------

WindowRef CWindowIterator_AC::Next()
{
	if (fCurrent)
		fCurrent = fIterateForward ? NextWindow(fCurrent) : PreviousWindow(fCurrent);

	return Current();
}

//----------------------------------------------------------------------------------------
// CWindowIterator_AC::FirstWindow:
//----------------------------------------------------------------------------------------

WindowRef CWindowIterator_AC::FirstWindow()
{
	WindowRef currentWindow = CWindow_AC::GetList();
// ••• Should there be an ACS version of gWorkPort?
//	if (currentWindow && (currentWindow == gWorkPort))
//		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CWindowIterator_AC::NextWindow:
//----------------------------------------------------------------------------------------

WindowRef CWindowIterator_AC::NextWindow(WindowRef aWindow)
{
	WindowRef currentWindow = GetNextWindow_AC(aWindow);

// ••• Should there be an ACS version of gWorkPort?
//	while (currentWindow && (currentWindow == gWorkPort))
//		// ignore the work window
//		currentWindow = GetNextWindow_AC(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CWindowIterator_AC::PreviousWindow:
//----------------------------------------------------------------------------------------

WindowRef CWindowIterator_AC::PreviousWindow(WindowRef aWindow)
{
	WindowRef currentWindow = FirstWindow();
	while (currentWindow && (NextWindow(currentWindow) != aWindow))
		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}

//----------------------------------------------------------------------------------------
// CWindowIterator_AC::LastWindow:
//----------------------------------------------------------------------------------------

WindowRef CWindowIterator_AC::LastWindow()
{
	WindowRef currentWindow = FirstWindow();
	while (currentWindow && NextWindow(currentWindow))
		currentWindow = NextWindow(currentWindow);

	return currentWindow;
}


//========================================================================================
// Global Functions
//========================================================================================

#if qCarbon
//----------------------------------------------------------------------------------------
// GetWindowZoomFlag
//----------------------------------------------------------------------------------------

bool GetWindowZoomFlag(WindowRef window)
// GetWindowZoomFlag is not available in Carbon, but we can check the equivalent
// window feature. 
{
	bool result = false;
	UInt32 features;
	OSStatus err = ::GetWindowFeatures(window, &features);
	if (err == noErr)
		result = features && kWindowCanZoom;	// •••  how to check this bit?
	return result;
}
#endif


//----------------------------------------------------------------------------------------
// End of CWindow_AC.cpp
