//----------------------------------------------------------------------------------------
// CProcess_AC.cpp
// Copyright © 1997-2001 by Apple Computer. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		05/02/01	GetProcessName shouldn't have to cast. 
		01/24/01	[W] Define tempName in GetProcessName.
		12/28/00	GetProcessName now returns a CString_AC.
		01/02/01	Update copyright.
		12/20/00	Add FindBySignature. 
		11/01/00	[PB] Include MacErrors instead of Errors. 
		09/20/00	[W] Can't call GetFrontProcess, GetNextProcess or SameProcess.
		07/31/00	[W] Added WinMain and static initialization of Windows-related
					application variables.
		02/22/00	[W] GetProcessInformation not available for GetInformation.
		11/18/99	Deleted GetModeGuardPageAware, as the "modeGuardPageAware" is no longer
					available in universal headers 3.3a3; additionally it was reported
					by Nick Kledzik that it never really did anything, anyway.
		03/24/99	Update copyright notice.
		03/10/99	[W] Added pragma unused to InteractWithUser.
		11/11/98	[Carbon] WakeUpProcess is not available
		10/26/98	Don't include QTMLMapNames.h anymore.
		10/06/98	Clean up includes. 
*/

#ifndef __CProcess_AC__
#include "CProcess_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __PROCESSES__
#include <Processes.h>
#endif

// Windows

#if qMSWindows
#include <stdarg.h>
#include <windef.h>
#include <winbase.h>
#endif

//========================================================================================
// CProcess_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CProcess_AC::IsFrontProcess: 
//----------------------------------------------------------------------------------------
bool CProcess_AC::IsFrontProcess()
{
	Boolean result = true;

#if !qMSWindows
	ProcessSerialNumber psn;
	ProcessSerialNumber applicationPSN;

	::ThrowIfOSErr_AC(::GetFrontProcess(&psn));
	applicationPSN = (*this);
	::ThrowIfOSErr_AC(::SameProcess(&psn, &applicationPSN, &result));
#else
	#pragma message ("NOTE: Need to implement IsFrontProcess in " __FILE__)
#endif

	return result;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::MakeFrontProcess: 
//----------------------------------------------------------------------------------------
void CProcess_AC::MakeFrontProcess()
{
#if !qMSWindows
	if (!IsFrontProcess())
		::ThrowIfOSErr_AC(::SetFrontProcess(this));
#else
	#pragma message ("NOTE: Need to implement MakeFrontProcess in " __FILE__)
#endif
}

//----------------------------------------------------------------------------------------
// CProcess_AC::WakeProcess: 
//----------------------------------------------------------------------------------------
void CProcess_AC::WakeProcess()
{
#if qCarbon
	// •••  WakeUpProcess is not available in Carbon - check back later
	#pragma warn ( "NOTE: WakeUpProcess is called by CProcess_AC::WakeProcess." __FILE__)
#elif !qMSWindows
	::ThrowIfOSErr_AC(::WakeUpProcess(this));
#else
	#pragma message ("NOTE: Need to implement WakeProcess in " __FILE__)
#endif
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetCurrent: 
//----------------------------------------------------------------------------------------
CProcess_AC CProcess_AC::GetCurrent()
{
	CProcess_AC process;
	::ThrowIfOSErr_AC(::MacGetCurrentProcess(&process));
	return process;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetFront
//----------------------------------------------------------------------------------------
CProcess_AC CProcess_AC::GetFront()
{
	CProcess_AC process;
#if !qMSWindows
	::ThrowIfOSErr_AC(::GetFrontProcess(&process));
#endif
	return process;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetNext
//----------------------------------------------------------------------------------------
CProcess_AC CProcess_AC::GetNext() const
{
	CProcess_AC process = *this;
#if !qMSWindows
	::ThrowIfOSErr_AC(::GetNextProcess(&process));
#endif
	return process;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::IsSameProcess
//----------------------------------------------------------------------------------------
bool CProcess_AC::IsSameProcess(const ProcessSerialNumber& psn2) const
{
	Boolean same = false;
#if !qMSWindows
	::ThrowIfOSErr_AC(::SameProcess(this, &psn2, &same));
#endif
	return same;
}

#if !qMSWindows
//----------------------------------------------------------------------------------------
// FindBySignature
//----------------------------------------------------------------------------------------

CProcess_AC CProcess_AC::FindBySignature(OSType sig)
{
	OSErr err;
	
	ProcessInfoRec info;
	CProcess_AC psn;
	do
	{
		err = GetNextProcess(&psn);
		if (err == noErr)
		{
			info.processInfoLength = sizeof(ProcessInfoRec);
			info.processName = NULL;
			info.processAppSpec = NULL;
			err = GetProcessInformation(&psn, &info);
		}
	}
	while ((err == noErr) && (info.processSignature != sig));

	if (err != noErr)
		psn.Clear();

	return psn;
}
#endif // !qMSWindows

//----------------------------------------------------------------------------------------
// CProcess_AC::GetInformation
//----------------------------------------------------------------------------------------
ProcessInfoRec CProcess_AC::GetInformation(StringPtr processName, FSSpecPtr processAppSpec) const
{
	ProcessInfoRec info;
	info.processInfoLength = sizeof(ProcessInfoRec);
	info.processName = processName;
	info.processAppSpec = processAppSpec;

#if !qMSWindows
	::ThrowIfOSErr_AC(GetProcessInformation(this, &info));
#else
	#pragma message("CProcess_AC::GetInformation: GetProcessInformation not implemented in Windows")
#endif

	return info;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessName: 
//----------------------------------------------------------------------------------------

CString_AC CProcess_AC::GetProcessName() const
{
	CString_AC processName;

#if !qMSWindows
	try
	{
		Str255 tempName;
		GetInformation(tempName);
		processName = tempName;
	}
	catch(CException_AC& theException)
	{
		DoCatchMessage_AC(theException);
#if qCoreDebug
		::ProgramBreak_AC("CProcess_AC::GetProcessName() failed!");
#endif
		// No need to fail completely, just return generic string.
		processName = "<Application>";

		// Don't ReSignal
	}
#else
	char tempName[256];
	STARTUPINFO		theStartupInfo;
	theStartupInfo.lpReserved = NULL;
	theStartupInfo.lpDesktop = NULL;
	theStartupInfo.lpTitle = tempName;
	GetStartupInfo(&theStartupInfo);
	processName = tempName;
#endif
	
	return processName;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessType
//----------------------------------------------------------------------------------------

unsigned long CProcess_AC::GetProcessType() const
{
	return GetInformation().processType;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessSignature
//----------------------------------------------------------------------------------------

OSType CProcess_AC::GetProcessSignature() const
{
	return GetInformation().processSignature;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessMode
//----------------------------------------------------------------------------------------

unsigned long CProcess_AC::GetProcessMode() const
{
	return GetInformation().processMode;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessLocation
//----------------------------------------------------------------------------------------

Ptr CProcess_AC::GetProcessLocation() const
{
	return GetInformation().processLocation;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessSize
//----------------------------------------------------------------------------------------

unsigned long CProcess_AC::GetProcessSize() const
{
	return GetInformation().processSize;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessFreeMem
//----------------------------------------------------------------------------------------

unsigned long CProcess_AC::GetProcessFreeMem() const
{
	return GetInformation().processFreeMem;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessLauncher
//----------------------------------------------------------------------------------------

CProcess_AC CProcess_AC::GetProcessLauncher() const
{
	return GetInformation().processLauncher;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessLaunchDate
//----------------------------------------------------------------------------------------

unsigned long CProcess_AC::GetProcessLaunchDate() const
{
	return GetInformation().processLaunchDate;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessActiveTime
//----------------------------------------------------------------------------------------

unsigned long CProcess_AC::GetProcessActiveTime() const
{
	return GetInformation().processActiveTime;
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessAppSpec
//----------------------------------------------------------------------------------------

void CProcess_AC::GetProcessAppSpec(FSSpecPtr processAppSpec) const
{
	GetInformation(NULL, processAppSpec);
}

//----------------------------------------------------------------------------------------
// CProcess_AC::GetProcessMode bits
//----------------------------------------------------------------------------------------

bool CProcess_AC::GetModeLaunchDontSwitch() const
{
	return (GetProcessMode() & modeLaunchDontSwitch) != 0;
}

bool CProcess_AC::GetModeDeskAccessory() const
{
	return (GetProcessMode() & modeDeskAccessory) != 0;
}

bool CProcess_AC::GetModeMultiLaunch() const
{
	return (GetProcessMode() & modeMultiLaunch) != 0;
}

bool CProcess_AC::GetModeNeedSuspendResume() const
{
	return (GetProcessMode() & modeNeedSuspendResume) != 0;
}

bool CProcess_AC::GetModeCanBackground() const
{
	return (GetProcessMode() & modeCanBackground) != 0;
}

bool CProcess_AC::GetModeDoesActivateOnFGSwitch() const
{
	return (GetProcessMode() & modeDoesActivateOnFGSwitch) != 0;
}

bool CProcess_AC::GetModeOnlyBackground() const
{
	return (GetProcessMode() & modeOnlyBackground) != 0;
}

bool CProcess_AC::GetModeGetFrontClicks() const
{
	return (GetProcessMode() & modeGetFrontClicks) != 0;
}

bool CProcess_AC::GetModeGetAppDiedMsg() const
{
	return (GetProcessMode() & modeGetAppDiedMsg) != 0;
}

bool CProcess_AC::GetMode32BitCompatible() const
{
	return (GetProcessMode() & mode32BitCompatible) != 0;
}

bool CProcess_AC::GetModeHighLevelEventAware() const
{
	return (GetProcessMode() & modeHighLevelEventAware) != 0;
}

bool CProcess_AC::GetModeLocalAndRemoteHLEvents() const
{
	return (GetProcessMode() & modeLocalAndRemoteHLEvents) != 0;
}

bool CProcess_AC::GetModeStationeryAware() const
{
	return (GetProcessMode() & modeStationeryAware) != 0;
}

bool CProcess_AC::GetModeUseTextEditServices() const
{
	return (GetProcessMode() & modeUseTextEditServices) != 0;
}

bool CProcess_AC::GetModeDisplayManagerAware() const
{
	return (GetProcessMode() & modeDisplayManagerAware) != 0;
}

//========================================================================================
// CApplication_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// Static global variables
//----------------------------------------------------------------------------------------

CApplication_AC* CApplication_AC::fgProcess;

#if qMSWindows
char*		CApplication_AC::sfCommandLine	= NULL;
HINSTANCE	CApplication_AC::sfInstance		= NULL;
int			CApplication_AC::sfShowCommand	= 0;
#endif


//----------------------------------------------------------------------------------------
// CApplication_AC constructor
//----------------------------------------------------------------------------------------
CApplication_AC::CApplication_AC()
	:	CProcess_AC(GetCurrent())
#if qMSWindows
		,
		fFrameWindow(NULL),
		fChildClientWindow(NULL),
		fAccelerators(NULL)
#endif
{
	fgProcess = this;

#if qMSWindows
	// Get string from resource with application name.
	LoadString(sfInstance, kAppName, (LPSTR)fAppName, sizeof(fAppName));
	LoadString(sfInstance, kDocName, (LPSTR)fDocName, sizeof(fDocName));
#endif
}

//----------------------------------------------------------------------------------------
// CApplication_AC destructor
//----------------------------------------------------------------------------------------
CApplication_AC::~CApplication_AC()
{
	if (this == fgProcess)
		fgProcess = NULL;
}

//----------------------------------------------------------------------------------------
// CApplication_AC::InteractWithUser
//----------------------------------------------------------------------------------------
OSErr CApplication_AC::InteractWithUser()
{
#if !qMSWindows
	return AEInteractWithUser(kAEDefaultTimeout, NULL, NULL);
#else
	return true;
#endif
}

//----------------------------------------------------------------------------------------
// CApplication_AC::InteractWithUser
//----------------------------------------------------------------------------------------
OSErr CApplication_AC::InteractWithUser(long timeOutInTicks,
										NMRecPtr nmReqPtr,
										AEIdleUPP idleProc)
{
#if qMSWindows
	#pragma unused (timeOutInTicks, nmReqPtr, idleProc)
	return false;
#else
	return AEInteractWithUser(timeOutInTicks, nmReqPtr, idleProc);
#endif
}

//----------------------------------------------------------------------------------------
// CApplication_AC::DoInteractWithUser - static
//----------------------------------------------------------------------------------------
OSErr CApplication_AC::DoInteractWithUser()
{
	return fgProcess ? fgProcess->InteractWithUser() : errAENoUserInteraction;
}

//----------------------------------------------------------------------------------------
// WinMain
//----------------------------------------------------------------------------------------
#if qMSWindows
int PASCAL WinMain(	HINSTANCE	hInstance,
					HINSTANCE	hPrevInstance,
					LPSTR		lpCmdLine,
					int			nCmdShow)

{
	SetLastError(0);

	CApplication_AC::sfCommandLine = lpCmdLine;
	CApplication_AC::sfInstance = hInstance;
	CApplication_AC::sfShowCommand = nCmdShow;
	
	main();

	return 0;
}
#endif


//----------------------------------------------------------------------------------------
// End of CProcess_AC.cpp
