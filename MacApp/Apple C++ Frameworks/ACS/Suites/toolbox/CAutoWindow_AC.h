// CAutoWindow_AC.h
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 

/*
	Change History
		03/01/01	Don't include Toolbox_AC. 
		01/02/01	Update copyright.
		03/24/99	Update copyright notice.
*/

#ifndef __CAutoWindow_AC__
#define __CAutoWindow_AC__

// ACS

#ifndef __Types_AC__
#include "Types_AC.h"
#endif

// Toolbox

#ifndef __MACWINDOWS__
#include <MacWindows.h>
#endif

//========================================================================================
// CLASS CAutoCloseWindow_AC
//========================================================================================

class CAutoCloseWindow_AC
// CAutoCloseWindow_AC is a stack-based object that owns a window, and
// closes it upon destruction. Somebody else is responsible for disposing
// of the window storage. 
{
public:
	CAutoCloseWindow_AC(WindowPtr window = NULL);
		// Assumes ownership of window. Will close window upon destruction of the AutoWindow.

	CAutoCloseWindow_AC(const CAutoCloseWindow_AC &toCopy);
		// The result of this will be a transfer of ownership from toCopy
		// to this AutoWindow, i.e. toCopy will become NULL.
		
	~CAutoCloseWindow_AC();
		// This will close fWindow if not NULL.
		
	WindowPtr get() const;
		// Get the window.
			
	WindowPtr operator ->() const;
		// Operate on the window
		
	operator WindowPtr () const;
		// Convert to the window
		
	void operator = (WindowPtr window);
		// Assumes ownership of window after delete fWindow if fWindow is not
		// NULL. Will close window upon destruction of the AutoWindow.
	
	CAutoCloseWindow_AC &operator = (const CAutoCloseWindow_AC &toCopy );
		// The result of this will be a transfer of ownership from toCopy
		// to this AutoWindow, i.e. toCopy will become NULL. Also, fWindow will 
		// be closed if not NULL. 
	
	bool operator == (const CAutoCloseWindow_AC &w) const;
		// Compare value of fWindow to w.fWindow.
		
	bool operator != (const CAutoCloseWindow_AC &w) const;
		// Compare value of fWindow to w.fWindow.
		
	bool operator == (const WindowPtr w) const;
		// Compare value of fWindow to w
	
	bool operator != (const WindowPtr w) const;
		// Compare value of fWindow to w
		
	WindowPtr release() const;
		// Returns a pointer to the window and sets fWindow to NULL.
		// Does not close the window.
		
	void reset();
		// Sets the pointer to NULL after deleting the window if its not NULL.

	bool IsNULL() const;
		// Test for NULL. Use this instead of MyPtr == NULL or MyPtr != NULL, 
		// i.e. use MyPtr.IsNULL.

private:
	WindowPtr	fWindow;
};

//----------------------------------------------------------------------------------------
//	Inline Implementation
//----------------------------------------------------------------------------------------

inline CAutoCloseWindow_AC::CAutoCloseWindow_AC(WindowPtr window) 
	: fWindow(window)
{ }

inline CAutoCloseWindow_AC::CAutoCloseWindow_AC(const CAutoCloseWindow_AC &toCopy) 
	: fWindow(toCopy.release())
{ }

inline CAutoCloseWindow_AC::~CAutoCloseWindow_AC() 
{
	reset();
}

inline WindowPtr CAutoCloseWindow_AC::get() const 
{
	return fWindow;
}

inline WindowPtr CAutoCloseWindow_AC::operator ->() const
{ 
	::AssertNotNULL_AC(fWindow);
	return fWindow;
}

inline CAutoCloseWindow_AC::operator WindowPtr () const
{
	return fWindow;
}
		
inline void CAutoCloseWindow_AC::operator = ( WindowPtr window) 
{ 
	if (fWindow != window)
	{
		reset();
		fWindow = window;
	}
}

inline CAutoCloseWindow_AC &CAutoCloseWindow_AC::operator = (const CAutoCloseWindow_AC &window )
{ 
	if (this != &window)
	{
		if (*this != window)
			reset();
	
		fWindow = window.release(); 
	}
	return *this; 
}

inline bool CAutoCloseWindow_AC::operator == (const CAutoCloseWindow_AC &w) const 
{
	return fWindow == w.fWindow;
}

inline bool CAutoCloseWindow_AC::operator != (const CAutoCloseWindow_AC &w) const 
{
	return fWindow != w.fWindow;
}

inline bool CAutoCloseWindow_AC::operator == (const WindowPtr w) const 
{
	return fWindow == w;
}

inline bool CAutoCloseWindow_AC::operator != (const WindowPtr w) const 
{
	return fWindow != w;
}

inline WindowPtr CAutoCloseWindow_AC::release() const
{ 	
	WindowPtr old = fWindow;
	const_cast<CAutoCloseWindow_AC*>(this)->fWindow = NULL;
	return old;
}

inline void CAutoCloseWindow_AC::reset()
{ 
	if (fWindow)
	{
		MacCloseWindow(fWindow);
		fWindow = NULL;
	}
}

inline bool CAutoCloseWindow_AC::IsNULL() const
{
	return fWindow == NULL;
}


#endif // __CAutoWindow_AC__
