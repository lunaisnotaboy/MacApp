//----------------------------------------------------------------------------------------
// WindowUtils_AC.cpp
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		02/14/01	Don't include Windows_AC. 
					Moved simpler functions inline. 
		01/02/01	Update copyright.
		11/14/00	Simplified some functions.  [W] Rewrote FindWindow_AC.  Include
					CProcess.h.
		03/24/99	Update copyright notice.
		02/19/99	NO CHANGE.
		12/07/98	ProgramBreak cleanup.
		11/05/98	CloseWindow is gone in CarbonSeed110398 - call DisposeWindow instead.
		11/05/98	Fixed Carbon code in MoveWindow_AC and FindWindow_AC;
					Removed extraneous EXPORT_AC;
					Added CloseWindow_AC implementation.
		10/29/98	Added FindWindow_AC, MoveWindow_AC.
		10/23/98	Carbonized; added GetWindowGrafPtr_AC, GetWindowCGrafPtr_AC, GetWindowFromPort_AC
		10/06/98	Clean up includes. 
*/

#ifndef __WindowUtils_AC__
#include "WindowUtils_AC.h"
#endif

// ACS

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#if qMSWindows
	#ifndef __CProcess_AC__
	#include "CProcess_AC.h"
	#endif
#endif

// Toolbox

#ifndef __LOWMEM__
#include <LowMem.h>
#endif


//========================================================================================
// GLOBAL FUNCTIONS
//========================================================================================

//----------------------------------------------------------------------------------------
// IsWindowInWindowList_AC
//----------------------------------------------------------------------------------------

bool IsWindowInWindowList_AC(const WindowRef testWindow)
{
	bool found = false;

	// Use the low mem accessor instead of FrontWindow
	// because we need to look at hidden windows. 
#if !qCarbon
	WindowPeek w = reinterpret_cast<WindowPeek>(LMGetWindowList());
#else
	WindowPtr w = ::GetWindowList();
#endif
	while (w)
	{
		if (reinterpret_cast<WindowRef>(w) == testWindow)
		{
			found = true;
			break;
		}
#if !qCarbon
		w = w->nextWindow;
#else
		w = ::GetNextWindow(w);
#endif
	}

	return found;
}

//----------------------------------------------------------------------------------------
// ValidateWindow_AC
//----------------------------------------------------------------------------------------

bool ValidateWindow_AC(const WindowRef testWindow)
{
	bool valid = testWindow && IsWindowInWindowList_AC(testWindow);
#if qCoreDebug
	if (!valid)
	{
		if (!testWindow)
			ProgramReport_AC("ValidateWindow_AC: Window is NULL\n");
		else if (!IsWindowInWindowList_AC(testWindow))
			ProgramReport_AC("ValidateWindow_AC: Window is not in the window list\n");
		else
			valid = true;
	}
#endif // qCoreDebug
	return valid;
}

#if qMSWindows
//----------------------------------------------------------------------------------------
// FindWindow_AC
//----------------------------------------------------------------------------------------
short FindWindow_AC(Point thePoint, WindowPtr* theWindow)
{
	// Under Windows MacFindWindow will not always find the correct windows window.  The
	// assumption here is that Windows handles the cases where the mouse click is not in
	// the content area of the window, so it will always be an inContent return code.
	// The Window itself will be the top most HWND that has a GrafPtr associated with it
	POINT		point;

	point.x = thePoint.h;
	point.y = thePoint.v;
	MapWindowPoints(CApplication_AC::fgProcess->fChildClientWindow, HWND_DESKTOP, &point, 1);

	HWND		window = WindowFromPoint(point);
	HWND		parent = GetParent(window);
	GrafPtr		port = NULL;

	if (parent != NULL)
		port = GetHWNDPort(parent);
	while ((parent != NULL) && (port != NULL))
	{
		window = parent;
		parent = GetParent(window);
		if (parent != NULL)
			port = GetHWNDPort(parent);
	}
	*theWindow = GetHWNDPort(window);
	return inContent;
}
#endif // qMSWindows


//----------------------------------------------------------------------------------------
// End of WindowUtils_AC.cpp
