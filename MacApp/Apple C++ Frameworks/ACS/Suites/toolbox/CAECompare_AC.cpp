//----------------------------------------------------------------------------------------
// CAECompare_AC.cpp
// Copyright © 1999-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/19/01	Include CPascalString_AC.h.
		01/02/01	Update copyright.
		12/12/00	Change CTempDesc_AC initialization in CompareAEList.
		11/01/00	[PB] Don't include SegLoad. 
		03/24/99	Update copyright notice.
		02/02/99	[C] AEDesc.dataHandle is opaque and GetDataAsHandle must be
							used instead.
		01/11/99	Initial version. 
*/

#ifndef __CAECompare_AC__
#include "CAECompare_AC.h"
#endif

//// qAppleEventAware indicates if the build includes AppleEvent support.
//#if qAppleEventAware

// ACS

#ifndef __CAEDesc_AC__
#include "CAEDesc_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CHandle_AC__
#include "CHandle_AC.h"
#endif

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

// Toolbox

#ifndef __AEREGISTRY__
#include <AERegistry.h>
#endif

#ifndef __PROCESSES__
#include <Processes.h>
#endif

#ifndef __RESOURCES__
#include <Resources.h>
#endif

//#ifndef __SEGLOAD__
//#include <SegLoad.h>
//#endif

// ANSI

//========================================================================================
// CAECompare_AC
//========================================================================================

CAECompare_AC* CAECompare_AC::fList;

CAECompare_AC gDefaultCompare(false);	// The default comparer always goes at the end. 

//----------------------------------------------------------------------------------------
// CAECompare_AC constructor
//----------------------------------------------------------------------------------------

CAECompare_AC::CAECompare_AC(bool atBeginning) :
	fNext(NULL)
{
	Insert(atBeginning);
}

//----------------------------------------------------------------------------------------
// CAECompare_AC destructor
//----------------------------------------------------------------------------------------

CAECompare_AC::~CAECompare_AC()
{
	Remove();
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::Insert
//----------------------------------------------------------------------------------------

void CAECompare_AC::Insert(bool atBeginning)
{
	if (atBeginning || !fList)
	{
		fNext = fList;
		fList = this;
	}
	else
	{
		CAECompare_AC* previous = NULL;
		CAECompare_AC* current = fList;
		while (current)
		{
			previous = current;
			current = current->fNext;
		}
		fNext = NULL;
		previous->fNext = this;
	}
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::Remove
//----------------------------------------------------------------------------------------

void CAECompare_AC::Remove()
{
	CAECompare_AC* previous = NULL;
	CAECompare_AC* current = fList;
	
	while (current && (current != this))
	{
		previous = current;
		current = current->fNext;
	}
	
	if (current)
	{
		if (previous)
			previous->fNext = fNext;
		else
			fList = fNext;
	}
	
	fNext = NULL;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::CompareDesc
//----------------------------------------------------------------------------------------

bool CAECompare_AC::CompareDesc(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, DescType compareHow)
{
	return fList ? fList->Compare(desc, otherDesc, compareHow) : false;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::Compare
//----------------------------------------------------------------------------------------

bool CAECompare_AC::Compare(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, 
							  DescType compareHow) const
{
	bool theResult = false;

	switch (desc.descriptorType)
	{
		case typeAEList:
			// Compare all the elements in the list
			theResult = CompareAEList(desc, otherDesc, compareHow);
			break;

		case typeChar:
			theResult = CompareChar(desc, otherDesc, compareHow);
			break;

		// Compare rectangles
		case typeQDRectangle:
			theResult = CompareRect(desc, otherDesc, compareHow);
			break;

		// Compare colors
		case typeRGBColor:
			theResult = CompareRGBColor(desc, otherDesc, compareHow);
			break;

		case typeLongDateTime:
			theResult = CompareDateTime(desc, otherDesc, compareHow);
			break;

		// Handle all the types we can convert to longs and then compare
		case typeType:
		case typeEnumerated:
		case typeBoolean:
		case typeLongInteger:
		case typeShortInteger:
			theResult = CompareLong(desc, otherDesc, compareHow);
			break;

		default:
			if (fNext)
				theResult = fNext->Compare(desc, otherDesc, compareHow);
			else
			{
				// Check for the same handle content
				theResult = CompareWildCard(desc, otherDesc, compareHow);
			}
			break;
	}

	return theResult;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::CompareAEList
//----------------------------------------------------------------------------------------

bool CAECompare_AC::CompareAEList(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, DescType compareHow)
{
	bool theResult = false;

	// Compare all the elements in the list
	long items1 = desc.CountListItems();
	long items2 = otherDesc.CountListItems();
	if (((compareHow == kAEEquals) && (items1 == items2)) ||
		(((compareHow == kAEBeginsWith) || (compareHow == kAEEndsWith)) && (items1 >= items2)))
	{
		theResult = true;		// empty lists are equal
		long numToCheck = items1;
		if ((compareHow == kAEBeginsWith) || (compareHow == kAEEndsWith))
			numToCheck = items2;
		long list1Indx = 1;
		if (compareHow == kAEEndsWith)
			list1Indx = (items1 - items2) + 1;
		for (long i = 1; i <= numToCheck; ++i)
		{
			CTempDesc_AC list1Item(desc.GetNthItem(list1Indx++, typeWildCard));
			CTempDesc_AC list2Item(otherDesc.GetNthItem(i, typeWildCard));
			theResult = theResult && list1Item.CompareDesc(list2Item, kAEEquals);
		}
	}

	return theResult;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::CompareChar
//----------------------------------------------------------------------------------------

bool CAECompare_AC::CompareChar(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, DescType compareHow)
{
	bool theResult = false;
#if qCarbon
	short	size1 = static_cast<short>(::AEGetDescDataSize(desc));
	short	size2 = static_cast<short>(::AEGetDescDataSize(otherDesc));
	
	CTempHandle_AC charsHdl1(desc.GetDataAsHandle());
	CTempHandle_AC charsHdl2(otherDesc.GetDataAsHandle());
	{
		// Extra block to insure handle is unlocked before it is disposed.
		CTempHandleLock_AC tempHandleLock(charsHdl1);
		CTempHandleLock_AC tempHandleLock2(charsHdl2);
#else
	Handle charsHdl1 = desc.dataHandle;
	Handle charsHdl2 = otherDesc.dataHandle;

	{
		CTempHandleLock_AC tempHandleLock(charsHdl1);
		CTempHandleLock_AC tempHandleLock2(charsHdl2);
	
		short size1 = static_cast<short>(desc.GetDataSize());
		short size2 = static_cast<short>(otherDesc.GetDataSize());
#endif
		short magIDResult = CPascalStr_AC::CompareText_AC(*charsHdl1, *charsHdl2, size1, size2);
		switch (compareHow)
		{
			case kAEGreaterThan:
				theResult = magIDResult == 1;
				break;
			case kAEGreaterThanEquals:
				theResult = magIDResult != -1;
				break;
			case kAEEquals:
				theResult = magIDResult == 0;
				break;
			case kAELessThan:
				theResult = magIDResult == -1;
				break;
			case kAELessThanEquals:
				theResult = magIDResult != 1;
				break;
			case kAEBeginsWith:
				if (size1 >= size2)
					theResult = !CPascalStr_AC::CompareText_AC(*charsHdl1, *charsHdl2, size2, size2);
				break;
			case kAEEndsWith:
				{
					long theOffset = size1 - size2;
					if (theOffset >= 0)
						theResult = !CPascalStr_AC::CompareText_AC(*charsHdl1 + theOffset, *charsHdl2, size2, size2);
					break;
				}
			case kAEContains:
				if (size1 >= size2)
					theResult = Munger(charsHdl1, 0, *charsHdl2, size2, NULL, 0) >= 0;
				break;
		}
	}
	return theResult;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::CompareRect
//----------------------------------------------------------------------------------------

bool CAECompare_AC::CompareRect(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, DescType compareHow)
{
	bool theResult = false;

	// Compare rectangles
	CRect_AC rect1 = desc.GetRect();
	CRect_AC rect2 = otherDesc.GetRect();
	if (compareHow == kAEEquals)
		theResult = rect1 == rect2;
	else if (compareHow == kAEContains)
		theResult = rect1.Contains(rect2);

	return theResult;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::CompareRGBColor
//----------------------------------------------------------------------------------------

bool CAECompare_AC::CompareRGBColor(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, DescType compareHow)
{
	bool theResult = false;

	// Compare colors
	if (compareHow == kAEEquals)
	{
		CRGBColor_AC myPropColor = desc.GetRGBColor();
		CRGBColor_AC compareColor = otherDesc.GetRGBColor();
		theResult = myPropColor == compareColor;
	}

	return theResult;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::CompareDateTime
//----------------------------------------------------------------------------------------

bool CAECompare_AC::CompareDateTime(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, DescType compareHow)
{
	bool theResult = false;

	unsigned long num1 = static_cast<unsigned long>(desc.GetDateTime());
	unsigned long num2 = static_cast<unsigned long>(otherDesc.GetDateTime());
	switch (compareHow)
	{
		case kAEGreaterThan:
			theResult = num1 > num2;
			break;
		case kAEGreaterThanEquals:
			theResult = num1 >= num2;
			break;
		case kAEEquals:
			theResult = num1 == num2;
			break;
		case kAELessThan:
			theResult = num1 < num2;
			break;
		case kAELessThanEquals:
			theResult = num1 <= num2;
			break;
	}

	return theResult;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::CompareLong
//----------------------------------------------------------------------------------------

bool CAECompare_AC::CompareLong(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, DescType compareHow)
{
	bool theResult = false;

	// Handle all the types we can convert to longs and then compare
	long num1 = 0;
	long num2 = 0;

	switch (desc.descriptorType)
	{
		// There are no coercion handlers for some of these types so we'll get them by
		// the descriptor type then cast the results to longs.
		case typeEnumerated:
			{
				num1 = static_cast<long>(desc.GetEnum());
				num2 = static_cast<long>(otherDesc.GetEnum());
				break;
			}
		case typeType:
			{
				num1 = static_cast<long>(desc.GetType());
				num2 = static_cast<long>(otherDesc.GetType());
				break;
			}
		case typeBoolean:
			{
				num1 = static_cast<long>(desc.GetBoolean());
				num2 = static_cast<long>(otherDesc.GetBoolean());
				break;
			}
		default:
			{
				num1 = desc.GetLong();
				num2 = otherDesc.GetLong();
			}
	}

	switch (compareHow)
	{
		case kAEGreaterThan:
			theResult = num1 > num2;
			break;
		case kAEGreaterThanEquals:
			theResult = num1 >= num2;
			break;
		case kAEEquals:
			theResult = num1 == num2;
			break;
		case kAELessThan:
			theResult = num1 < num2;
			break;
		case kAELessThanEquals:
			theResult = num1 <= num2;
			break;
	}

	return theResult;
}

//----------------------------------------------------------------------------------------
// CAECompare_AC::CompareWildCard: 
//----------------------------------------------------------------------------------------

bool CAECompare_AC::CompareWildCard(const CAEDesc_AC& desc, const CAEDesc_AC& otherDesc, DescType compareHow)
{
	bool theResult = false;

	// Check for the same handle content
#if qCarbon
	Size			size1 = ::AEGetDescDataSize(desc);
	Size			size2 = ::AEGetDescDataSize(otherDesc);
	CTempHandle_AC	data1(desc.GetDataAsHandle());
	CTempHandle_AC	data2(otherDesc.GetDataAsHandle());
#else
	long size1 = desc.GetDataSize();
	long size2 = otherDesc.GetDataSize();
	Handle data1 = desc.dataHandle;
	Handle data2 = otherDesc.dataHandle;
#endif

	theResult = ((compareHow == kAEEquals) &&
				 (size1 == size2) &&
				 (EqualBlocks_AC(*data1, *data2, static_cast<short>(size1))));
	return theResult;
}

//#endif // qAppleEventAware

//----------------------------------------------------------------------------------------
// End of CAECompare_AC.cpp
