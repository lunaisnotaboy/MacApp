//----------------------------------------------------------------------------------------
// CToolboxPopup_AC.cpp
// Copyright � 1998-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/06/00	Add a version of GetBestBounds that returns the baseline offset. 
		10/25/99	PRAGMA_ALIGN_SUPPORTED now PRAGMA_STRUCT_ALIGN.
		10/06/99	Switch for CToolboxPopup_AC::GetDataSize had same code; move
					Carbon-specfic information into CToolboxPopup_AC::GetPopupDataSize.
					Do the same for CToolboxPopup_AC::GetData and GetPopupData.
		03/24/99	Update copyright notice.
		10/23/98	Carbonize; add 2 methods for Carbon: GetPopupData, GetPopupDataSize
		10/06/98	Clean up includes. 
*/

#ifndef __CToolboxPopup_AC__
#include "CToolboxPopup_AC.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CTempGrafPort_AC__
#include "CTempGrafPort_AC.h"
#endif

#ifndef __CTempRegion_AC__
#include "CTempRegion_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

// Toolbox

#ifndef __MACWINDOWS__
#include <MacWindows.h>
#endif

//========================================================================================
// CLASS CToolboxPopup_AC
//========================================================================================

#if !qCarbon
// PopupPrivateData is not defined in Carbon, so we must do this a different way.

// The following data structure is a private data structure used by the popup CDEF. It
// lives as a privHdl off the control handle's contrlData field. The first two fields of
// the private data structure are "public" but the rest are private.
#if PRAGMA_STRUCT_ALIGN
#pragma options align=mac68k
#endif

struct PopupReallyPrivateData : public PopupPrivateData
{
	short mLastMenuID;							// last menu id selected (System 7+ only)
	short mLastItem;							// last item selected (System 7+ only)
};

#if PRAGMA_STRUCT_ALIGN
#pragma options align=reset
#endif

typedef PopupReallyPrivateData **PopupReallyPrivateDataHandle;

#endif	// non-Carbon stuff

//----------------------------------------------------------------------------------------
// CToolboxPopup_AC
//----------------------------------------------------------------------------------------

CToolboxPopup_AC::CToolboxPopup_AC(ControlRef theControl) :
	CToolboxControl_AC(theControl)
{
}

//----------------------------------------------------------------------------------------
// CToolboxPopup_AC
//----------------------------------------------------------------------------------------

CToolboxPopup_AC::CToolboxPopup_AC(SInt16 resourceID, WindowRef owningWindow) :
	CToolboxControl_AC(resourceID, owningWindow)
{
}
	
//----------------------------------------------------------------------------------------
// CToolboxPopup_AC
//----------------------------------------------------------------------------------------

CToolboxPopup_AC::CToolboxPopup_AC(WindowRef theWindow, SInt16 controlType, 
								const CRect_AC& boundsRect, 
								const CStr255_AC& itsTitle, 
								bool isVisible, bool isActive, 
								short itsMenuStyle,
								short itsMenuID,
								short itsItemOffset,				
								ResType useAddResMenuResType,
								SInt16 itsCurrentItem,
								MControlHandler_AC* actionHandler) :
	CToolboxControl_AC(NULL) // initialize fControl & fBitsToShift
{
	// set the port appropriately
	CTempGrafPort_AC tempPort((GrafPtr) GetWindowPort(theWindow));

	// Note the convolution with useAddResMenuResType, this is due to how the Popup CDEF
	// will initially interpret the userData parameter.
	CreateControlRef(theWindow, controlType, boundsRect, itsTitle, isVisible, isActive,
						itsMenuStyle, itsMenuID, itsItemOffset, 
						useAddResMenuResType);

	// Need to signal failure if the CDEF's private storage couldn't be created -- this is
	// most likely due to a missing MENU or CMNU resource with fMenuID.
#if !qCarbon
	// Will always return NULL in Carbon
	if (GetPrivateData() == NULL)
		::ThrowError_AC(minErr);
#endif

	::SetControlReference(fControl, reinterpret_cast<long>(actionHandler));	// Set refCon here, it has a special value at
													// NewControl time - the ResType for the case
													// in which the popup's variation code has
													// popupUseAddResMenu.

	SetValue(itsCurrentItem);
	SetVisibility(isVisible);
}

//----------------------------------------------------------------------------------------
// CToolboxPopup_AC
//----------------------------------------------------------------------------------------

CToolboxPopup_AC::~CToolboxPopup_AC()
{
}

//----------------------------------------------------------------------------------------
// CToolboxPopup_AC::GetData
//----------------------------------------------------------------------------------------

Size CToolboxPopup_AC::GetData(ControlPartCode inPart, ResType inTagName,
							 	Size inBufferSize, Ptr inBuffer)
{
	Size returnValue = 0;
	switch (inTagName)
	{
		case kControlBevelButtonLastMenuTag:
		case kControlBevelButtonMenuValueTag:
			// Since we can't get at PopupPrivateData in Carbon, call our special Carbon function
			returnValue = GetPopupData(inPart, inTagName, inBufferSize, inBuffer);
			break;
		default: 
			/* ignore */;
	}
	return returnValue;
}

//----------------------------------------------------------------------------------------
// CToolboxPopup_AC::GetDataSize
//----------------------------------------------------------------------------------------

Size CToolboxPopup_AC::GetDataSize(ControlPartCode inPart, ResType inTagName)
{
	Size returnValue = 0;
	switch (inTagName)
	{
		case kControlBevelButtonLastMenuTag:
		case kControlBevelButtonMenuValueTag:
			returnValue = GetPopupDataSize(inPart, inTagName);
			break;			
		default: 
			/* ignore */;
	}
	return returnValue;
}

//----------------------------------------------------------------------------------------
// CToolboxPopup_AC
//----------------------------------------------------------------------------------------

void CToolboxPopup_AC::GetBestBounds(Rect& outRect, SInt16& outBaseLineOffset)
{
	// ���  - MacApp only uses this algorithm for popups.  
	// Should this live in CToolboxControl_AC?  Is this now encapsulated in 
	// Appearance's GetBestControlRect (Controls.h)?

	outBaseLineOffset = 0;

#if !qCarbon
// ���  No access to contrlDefProc in Carbon; figure this out later
	if (fControl)
	{
		Handle contrlDefProcHandle = (*fControl)->contrlDefProc;		
		if (contrlDefProcHandle)
		{
			if (!*contrlDefProcHandle)
			{
				::MacLoadResource(contrlDefProcHandle);
				::ThrowIfResError_AC();
			}
			CTempHandleLock_AC lock(contrlDefProcHandle);
			
			ControlDefUPP proc = reinterpret_cast<ControlDefUPP> (StripLong_AC(*contrlDefProcHandle));
			short varCode =
#if !qMSWindows
							::GetControlVariant(fControl);
#else
							0;	// ��� What should we do for Windows?
#endif
			ControlDefProcMessage message = GetMMUMode() ? calcCntlRgn : calcCRgns;
			CTempRegion_AC region;
			CallControlDefProc(proc, varCode, fControl, message, long(RgnHandle(region)));
			outRect = (*region)->rgnBBox;
		}
	}
	else
#endif	// non-Carbon code
		outRect = CRect_AC();
}

//----------------------------------------------------------------------------------------
// CToolboxPopup_AC::GetPopupData
//----------------------------------------------------------------------------------------
Size CToolboxPopup_AC::GetPopupData(ControlPartCode inPart, ResType inTagName,
							 		Size inBufferSize, Ptr inBuffer)
{
	Size returnValue = 0;
#if !qCarbon
			if (AppearanceMgrVersion_AC() >= 0x0101)
			{
				returnValue = CToolboxControl_AC::GetData(inPart, inTagName, inBufferSize, inBuffer);
			}
			else if (GetPrivateData() && inBuffer != NULL && inBufferSize == sizeof(SInt16))
			{
				*((SInt16*) inBuffer) = (*reinterpret_cast<PopupReallyPrivateDataHandle>(GetPrivateData()))->mLastMenuID;
				returnValue = sizeof(SInt16);
			}
#else
	switch (inTagName)
	{
		case kControlBevelButtonLastMenuTag:
		case kControlBevelButtonMenuValueTag:
			returnValue = GetPopupDataSize(inPart, inTagName);
			if (returnValue != 0)
			{	// Check returnValue against inBufferSize?
				if (::GetControlData(fControl, inPart, inTagName, inBufferSize, inBuffer, &returnValue) != noErr)
					returnValue = 0;
			}
			break;

		default: 
			/* ignore */;
	}
#endif	// Carbon-only code
	return returnValue;
}

//----------------------------------------------------------------------------------------
// CToolboxPopup_AC::GetPopupDataSize
//----------------------------------------------------------------------------------------
Size CToolboxPopup_AC::GetPopupDataSize(ControlPartCode inPart, ResType inTagName)
{
	Size returnValue = 0;
#if !qCarbon
	if (AppearanceMgrVersion_AC() >= 0x0101)
		returnValue = CToolboxControl_AC::GetDataSize(inPart, inTagName);
	else
		returnValue = sizeof(SInt16);
#else

	switch (inTagName)
	{
		case kControlBevelButtonLastMenuTag:
		case kControlBevelButtonMenuValueTag:
			if (::GetControlDataSize(fControl, inPart, inTagName, &returnValue) != noErr)
				returnValue = 0;
			break;
		
		default: 
			/* ignore */;
	}
#endif
	return returnValue;
}

//----------------------------------------------------------------------------------------
// End of CToolboxPopup_AC.cpp
