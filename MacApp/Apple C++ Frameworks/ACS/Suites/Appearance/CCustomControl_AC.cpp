//----------------------------------------------------------------------------------------
// CCustomControl_AC.cpp 
// Copyright © 1991-2001 by Apple Computer, Inc. All rights reserved.
// Portions Copyright © 1996 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/04/00	Conditional on qEmulateStandardControls
		09/22/00	Improved graphics device iterator. 
		06/14/00	Removed region code.
		03/24/99	Update copyright notice.
*/

#ifndef __CCustomControl_AC__
#include "CCustomControl_AC.h"
#endif

// ACS

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

//========================================================================================
// GLOBALS 
//========================================================================================

bool MControlBackground_AC::fgUseSpecialBackgroundColors = false;	// toggled by tab panel installer
CRGBColor_AC MControlBackground_AC::fgEnabledBackgroundColor;
CRGBColor_AC MControlBackground_AC::fgDisabledBackgroundColor;


#if qEmulateStandardControls

//========================================================================================
// CLASS CCustomControl_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

CCustomControl_AC::CCustomControl_AC(const CRect_AC& boundsRect, 
									 bool isActive) :
	fBounds(boundsRect),
	fActive(isActive),
	fVisible(true)
{
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

CCustomControl_AC::~CCustomControl_AC()
{
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

CRect_AC CCustomControl_AC::GetBounds() const
{
	return fBounds;
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

void CCustomControl_AC::SetBounds(const CRect_AC& bounds)
{
	fBounds = bounds;
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

ControlPartCode CCustomControl_AC::GetDefaultPartCode() const
{
	return kControlButtonPart;
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

ControlPartCode CCustomControl_AC::TestMouse(const CPoint_AC& mouseLocation) const
{
	return fBounds.Contains(mouseLocation) ? GetDefaultPartCode() : kControlNoPart;
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

ControlPartCode CCustomControl_AC::TrackMouse(const CPoint_AC& mouseLocation, SInt16 /*modifiers*/)
{
	if (! fActive || ! fVisible)
		return kControlNoPart;
	
	return TrackPart(mouseLocation, TestMouse(mouseLocation));
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

ControlPartCode	CCustomControl_AC::TrackPart(const CPoint_AC& /*mouseLocation*/, 
								ControlPartCode partHit)
{
	// Process mouse tracking, return partHit if tracking
	// eventually "did something". Return false if
	// tracking had no ultimate effect, e.g. mouse
	// up outside a push button.
	bool		wasIn = false;
	bool		isIn;
	bool		isButtonDown = true;	// ensure at least one time through
	CPoint_AC	newMouseLocation;
	
	while (isButtonDown)
	{
		::GetMouse(&newMouseLocation);	// gives local coordinates
		
		isIn = TestMouse(newMouseLocation) == partHit;
		
		if (isIn != wasIn)
			SetPartHilite(partHit, isIn);
		
		wasIn = isIn;

		isButtonDown = ::StillDown();
	}
	
	if (isIn)	// if finished IN, restore normal appearance
		SetPartHilite(partHit, kNotHilited);
	
	return isIn ? partHit : kControlNoPart;
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

void CCustomControl_AC::HandleControlAction(ControlPartCode partHit)
{
	MControlHandler_AC* handler = GetActionHandler();
	if (handler)
		handler->DoControlAction(partHit);
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

bool CCustomControl_AC::IsActive() const
{ 
	return fActive; 
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

void CCustomControl_AC::SetActive(bool isActive)
{
	fActive = isActive;
	if (fVisible)
		DrawControl();
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

bool CCustomControl_AC::IsVisible() const
{
	return fVisible;
}

//----------------------------------------------------------------------------------------
// CCustomControl_AC
//----------------------------------------------------------------------------------------

void CCustomControl_AC::Show(bool doShow)
{
	fVisible = doShow;
	if (fVisible)
		DrawControl();
}
		
//----------------------------------------------------------------------------------------
// CControl_AC
//----------------------------------------------------------------------------------------

bool CCustomControl_AC::SetVisibility(bool beVisible)
{
	bool wasVisible = fVisible;
	fVisible = beVisible;
	return wasVisible;
}

//========================================================================================
// CLASS CCustomButton_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CCustomButton_AC
//----------------------------------------------------------------------------------------

CCustomButton_AC::CCustomButton_AC(const CRect_AC& boundsRect, 
											bool isActive,
											const CStr255_AC& itsTitle,
											const CTextStyle_AC& titleStyle) :
	CCustomControl_AC(boundsRect, isActive),
	fTitle(itsTitle),
	fTitleStyle(titleStyle)
{
}

//----------------------------------------------------------------------------------------
// CCustomButton_AC
//----------------------------------------------------------------------------------------
											
CCustomButton_AC::~CCustomButton_AC()
{
}
	
//----------------------------------------------------------------------------------------
// CCustomButton_AC
//----------------------------------------------------------------------------------------

void CCustomButton_AC::DrawControl()
{
	DrawButton(kNotHilited);
}
	
//----------------------------------------------------------------------------------------
// CCustomButton_AC
//----------------------------------------------------------------------------------------

CStr255_AC CCustomButton_AC::GetTitle() const
{
	return fTitle;
}

//----------------------------------------------------------------------------------------
// CCustomButton_AC
//----------------------------------------------------------------------------------------

void CCustomButton_AC::SetTitle(const CStr255_AC& newTitle)
{
	fTitle = newTitle;
	if (fVisible)
		DrawControl();
}

//----------------------------------------------------------------------------------------
// CCustomButton_AC
//----------------------------------------------------------------------------------------

void CCustomButton_AC::SetPartHilite(ControlPartCode part, bool isHilited)
{
	// N.b., to properly emulate HiliteControl, we should only respond to hiliting the 
	// kControlButtonPart (not GetDefaultPartCode), or to turning all hiliting off,
	// but our custom controls properly return the control part, so....
	if (fVisible)
		if (part == GetDefaultPartCode() || !isHilited)
			DrawButton(isHilited);
}

//----------------------------------------------------------------------------------------
// CCustomButton_AC
//----------------------------------------------------------------------------------------

void CCustomButton_AC::DrawButton(bool pressed)
{
	CTempDrawingEnvironment_AC	env;

	// Draw the button in the appropriate state.

	for (CGDIterator_AC iter; iter; ++iter)
	{
		bool deep = iter->IsDeep();
		if (!fActive)
			DrawButtonDisabled(deep);
		else if (pressed)
			DrawButtonPressed(deep);
		else
			DrawButtonNormal(deep);
	}
}

//----------------------------------------------------------------------------------------
// CCustomButton_AC::SetFontStyle
//----------------------------------------------------------------------------------------

void CCustomButton_AC::SetFontStyle(const CControlTextStyle_AC& textStyle)
{
	// Set the QuickDraw text style for the labels.

	fTitleStyle = CTextStyle_AC(textStyle);

	if (fVisible)
		DrawControl();
}

//----------------------------------------------------------------------------------------
// CCustomButton_AC::GetFontStyle
//----------------------------------------------------------------------------------------

CControlTextStyle_AC CCustomButton_AC::GetFontStyle()
{
	return CControlTextStyle_AC(fTitleStyle);
}

#endif // qEmulateStandardControls


//========================================================================================
// CLASS MControlBackground_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// MControlBackground_AC
//----------------------------------------------------------------------------------------

MControlBackground_AC::MControlBackground_AC(bool installIfNotCustom) :
	fEnabledBackgroundColor(kRGBColorRamp[r2]),
	fDisabledBackgroundColor(kRGBColorRamp[r2])
{
	InstallBackgroundColors(installIfNotCustom);
}

//----------------------------------------------------------------------------------------
// MControlBackground_AC
//----------------------------------------------------------------------------------------

MControlBackground_AC::~MControlBackground_AC()
{
}

//----------------------------------------------------------------------------------------
// MControlBackground_AC
//----------------------------------------------------------------------------------------

void MControlBackground_AC::InstallBackgroundColors(bool installIfNotCustom)
{
	CRGBColor_AC	enabledColor;
	CRGBColor_AC	disabledColor;

	if (DetermineBackgroundColors(enabledColor, disabledColor, installIfNotCustom))
		SetBackgroundColors(enabledColor, disabledColor);
}

//----------------------------------------------------------------------------------------
// MControlBackground_AC
//----------------------------------------------------------------------------------------

void MControlBackground_AC::SetBackgroundColors(const CRGBColor_AC& enabledColor, const CRGBColor_AC& disabledColor)
{
	// Set colors to be used when erasing background.
	// Most views don't need this. Default is AGA ramp r2.
	// CStaticText_AC and CDisclosureTriangle_AC need to
	// erase their background, so if your background is
	// not r2 (white, for example), call this to set it.
	// Also, objects contained in tab panel views need
	// r1 when enabled, and r2 when disabled, so that's
	// an even wackier case; the adapter classes handle
	// it for you.

	fEnabledBackgroundColor = enabledColor;
	fDisabledBackgroundColor = disabledColor;
}

//----------------------------------------------------------------------------------------
// MControlBackground_AC
//----------------------------------------------------------------------------------------

void MControlBackground_AC::ApplyBackgroundColor(bool isEnabled)
{
	// Use the proper background color and apply it as
	// the current foreground color suitable for a
	// subsequent PaintRect or similar call.

	if (isEnabled)
		fEnabledBackgroundColor.SetForeColor();
	else
		fDisabledBackgroundColor.SetForeColor();
}

//----------------------------------------------------------------------------------------
// Variable-color background support
//
// Tab panels provide us a more complicated background color situation
// than other situations. While the normal AGA background is gray ramp
// value r2, the tab panels are lighter, namely r1. However, when a tab
// panel is dimmed, it becomes r2. Thus the panel subpanes can't just
// blindly use the window background color, and if the tab panel becomes
// dimmed they can't just blindly use r1 either.
//
// So what we do is maintain static color values that are picked up by
// any adapter classes that need to erase their background. There are
// separate color values for enabled and disabled states. When a panel
// view hierarchy is installed into a tab panel pane, the tab panel class
// temporarily sets these color values so that any subpanes of the panel
// will pick them up as they are instantiated.
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// MControlBackground_AC
//----------------------------------------------------------------------------------------

bool MControlBackground_AC::DetermineBackgroundColors(CRGBColor_AC& enabledColor, CRGBColor_AC& disabledColor, bool installIfNotCustom)
{
	bool	wereColorsSet = false;

	if (fgUseSpecialBackgroundColors)
	{
		enabledColor = fgEnabledBackgroundColor;
		disabledColor = fgDisabledBackgroundColor;
		wereColorsSet = true;
	}
	else if (installIfNotCustom)
	{
		// The calling view must have focused and set the port bg color.
		enabledColor.GetBackColor();
		disabledColor = enabledColor;
		wereColorsSet = true;
	}

	return wereColorsSet;
}
 
//----------------------------------------------------------------------------------------
// MControlBackground_AC
//----------------------------------------------------------------------------------------

void MControlBackground_AC::TurnOnCustomBackgroundColors(const CRGBColor_AC& enabledColor, const CRGBColor_AC& disabledColor)
{
	fgUseSpecialBackgroundColors = true;
	fgEnabledBackgroundColor = enabledColor;
	fgDisabledBackgroundColor = disabledColor;
}

//----------------------------------------------------------------------------------------
// MControlBackground_AC
//----------------------------------------------------------------------------------------

void MControlBackground_AC::TurnOffCustomBackgroundColors()
{
	fgUseSpecialBackgroundColors = false;
}


//----------------------------------------------------------------------------------------
// End of CCustomControl_AC.cpp 