//----------------------------------------------------------------------------------------
// CRadioButton_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/04/00	Conditional on qEmulateStandardControls
		09/21/00	[W] Added instantiation of CAutoPtr_AC<CSimpleOffscreenImage_AC>.
		09/19/00	CGDIterator not used. 
		03/24/99	Update copyright notice.
		10/28/98	[W] 'OUT' conflicts with Windows.  Use 'rOUT' instead.
		10/06/98	Clean up includes. 
*/

#ifndef __CRadioButton_AC__
#include "CRadioButton_AC.h"
#endif

#if qEmulateStandardControls

// ACS

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef __CRegion_AC__
#include "CRegion_AC.h"
#endif

#ifndef __Debug_AC__
#include "Debug_AC.h"
#endif


//========================================================================================
// CRadioButton_AC
//========================================================================================

bool CRadioButton_AC::fgImagesAllocated = false;

#if _MSC_VER
template class EXPORT_AC CAutoPtr_AC<CSimpleOffscreenImage_AC>;
#endif

// Each radio button drawing state has an offscreen image.
CAutoPtr_AC<CSimpleOffscreenImage_AC>	CRadioButton_AC::fgOffscreenRadioImages[kNumRadioImages];

// These are the color ramp indexes that are used to build the offscreen images.
SInt8				CRadioButton_AC::kRadioImageValues[kNumRadioImages][kRadioImageHeight][kRadioImageWidth] =
	{
		{	// kRadioNormalOff
		{ rOUT, rOUT, rOUT,  r5, r11,  rB,  rB, r11,  r5, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,   rB, r10,  r2,  r2,  r2,  r4, r11,   rB, rOUT, rOUT },
		{ rOUT,   rB,   r4,  r2,  r1,  rW,  rW,  rW,  r2,   r7,   rB, rOUT },
		{   r5,  r10,   r2,  r1,  rW,  rW,  r1,  r1,  r2,   r4,  r11,   r5 },
		{  r11,   r2,   r1,  rW,  rW,  r1,  r1,  r2,  r2,   r4,   r7,  r11 },
		{   rB,   r2,   rW,  rW,  r1,  r1,  r2,  r2,  r4,   r4,   r7,   rB },
		{   rB,   r2,   rW,  r1,  r1,  r2,  r2,  r4,  r4,   r5,   r7,   rB },
		{  r11,   r4,   rW,  r1,  r2,  r2,  r4,  r4,  r5,   r5,   r7,  r11 },
		{   r5,  r10,   r2,  r2,  r2,  r4,  r4,  r5,  r5,   r7,  r11,   r5 },
		{ rOUT,   rB,   r7,  r4,  r4,  r4,  r5,  r5,  r7,   r7,   rB, rOUT },
		{ rOUT, rOUT,   rB, r10,  r7,  r7,  r7,  r7, r11,   rB, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r5, r11,  rB,  rB, r11,  r5, rOUT, rOUT, rOUT },
		},

		{	// kRadioNormalOn
		{ rOUT, rOUT, rOUT,  r5, r12,  rB,  rB, r12,  r5, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,  r12,  rB, r11, r10, r10, r10, r11,   rB, rOUT, rOUT },
		{ rOUT,  r12,  r11, r10,  r8,  r8,  r8,  r7,  r7,   r6,   rB, rOUT },
		{   r5,   rB,  r10,  r8,  rB,  rB,  rB,  rB,  r6,   r6,  r11,   r5 },
		{  r12,  r11,   r8,  rB,  rB,  rB,  rB,  rB,  rB,   r6,   r4,  r11 },
		{   rB,  r10,   r8,  rB,  rB,  rB,  rB,  rB,  rB,   r4,   r4,   rB },
		{   rB,  r10,   r8,  rB,  rB,  rB,  rB,  rB,  rB,   r4,   r2,   rB },
		{  r12,  r10,   r7,  rB,  rB,  rB,  rB,  rB,  rB,   r2,   rW,  r11 },
		{   r5,  r12,   r7,  r6,  rB,  rB,  rB,  rB,  r2,   rW,  r11,   r5 },
		{ rOUT,  r12,   r6,  r6,  r6,  r4,  r4,  r2,  rW,   rW,   rB, rOUT },
		{ rOUT, rOUT,  r12, r11,  r4,  r4,  r2,  rW, r11,   rB, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r5, r11,  rB,  rB, r11,  r5, rOUT, rOUT, rOUT },
		},

		{	// kRadioNormalMixed
		{ rOUT, rOUT, rOUT,  r5, r11,  rB,  rB, r11,  r5, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,   rB, r10,  r2,  r2,  r2,  r4, r11,   rB, rOUT, rOUT },
		{ rOUT,   rB,   r4,  r2,  r1,  rW,  rW,  rW,  r2,   r7,   rB, rOUT },
		{   r5,  r10,   r2,  r1,  rW,  rW,  r1,  r1,  r2,   r4,  r11,   r5 },
		{  r11,   r2,   r1,  rW,  rW,  r1,  r1,  r2,  r2,   r4,   r7,  r11 },
		{   rB,   r2,   rW,  rB,  rB,  rB,  rB,  rB,  rB,   r4,   r7,   rB },
		{   rB,   r2,   rW,  rB,  rB,  rB,  rB,  rB,  rB,   r5,   r7,   rB },
		{  r11,   r4,   rW,  r1,  r2,  r2,  r4,  r4,  r5,   r5,   r7,  r11 },
		{   r5,  r10,   r2,  r2,  r2,  r4,  r4,  r5,  r5,   r7,  r11,   r5 },
		{ rOUT,   rB,   r7,  r4,  r4,  r4,  r5,  r5,  r7,   r7,   rB, rOUT },
		{ rOUT, rOUT,   rB, r10,  r7,  r7,  r7,  r7, r11,   rB, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r5, r11,  rB,  rB, r11,  r5, rOUT, rOUT, rOUT },
		},

		{	// kRadioPressedOff
		{ rOUT, rOUT, rOUT,  r5, r12,  rB,  rB, r12,  r5, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,  r12,  rB, r11, r11, r11, r11, r11,   rB, rOUT, rOUT },
		{ rOUT,  r12,  r11, r11, r10, r10,  r9,  r9,  r9,   r8,   rB, rOUT },
		{   r5,   rB,  r11, r10, r10,  r9,  r9,  r8,  r8,   r8,  r11,   r5 },
		{  r12,  r11,  r10, r10,  r9,  r9,  r8,  r8,  r8,   r7,   r6,  r11 },
		{   rB,  r11,  r10,  r9,  r9,  r8,  r8,  r8,  r7,   r7,   r6,   rB },
		{   rB,  r11,   r9,  r9,  r8,  r8,  r8,  r7,  r7,   r6,   r6,   rB },
		{  r12,  r11,   r9,  r8,  r8,  r8,  r7,  r7,  r6,   r6,   r4,  r11 },
		{   r5,  r12,   r9,  r8,  r8,  r7,  r7,  r6,  r6,   r4,  r10,   r5 },
		{ rOUT,  r11,   r8,  r8,  r7,  r7,  r6,  r6,  r4,   r4,   rB, rOUT },
		{ rOUT, rOUT,  r12, r11,  r6,  r6,  r6,  r4, r10,   rB, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r5, r11,  rB,  rB, r11,  r5, rOUT, rOUT, rOUT },
		},

		{	// kRadioPressedOn
		{ rOUT, rOUT, rOUT,  r5, r12,  rB,  rB, r12,  r5, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,  r12,  rB, r11, r11, r11, r11, r11,   rB, rOUT, rOUT },
		{ rOUT,  r12,  r11, r11, r10, r10,  r9,  r9,  r9,   r8,   rB, rOUT },
		{   r5,   rB,  r11, r10,  rB,  rB,  rB,  rB,  r8,   r8,  r11,   r5 },
		{  r12,  r11,  r10,  rB,  rB,  rB,  rB,  rB,  rB,   r7,   r6,  r11 },
		{   rB,  r11,  r10,  rB,  rB,  rB,  rB,  rB,  rB,   r7,   r6,   rB },
		{   rB,  r11,   r9,  rB,  rB,  rB,  rB,  rB,  rB,   r6,   r6,   rB },
		{  r12,  r11,   r9,  rB,  rB,  rB,  rB,  rB,  rB,   r6,   r4,  r11 },
		{   r5,  r12,   r9,  r8,  rB,  rB,  rB,  rB,  r6,   r4,  r10,   r5 },
		{ rOUT,  r11,   r8,  r8,  r7,  r7,  r6,  r6,  r4,   r4,   rB, rOUT },
		{ rOUT, rOUT,  r12, r11,  r6,  r6,  r6,  r4, r10,   rB, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r5, r11,  rB,  rB, r11,  r5, rOUT, rOUT, rOUT },
		},

		{	// kRadioPressedMixed
		{ rOUT, rOUT, rOUT,  r5, r12,  rB,  rB, r12,  r5, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,  r12,  rB, r11, r11, r11, r11, r11,   rB, rOUT, rOUT },
		{ rOUT,  r12,  r11, r11, r10, r10,  r9,  r9,  r9,   r8,   rB, rOUT },
		{   r5,   rB,  r11, r10, r10,  r9,  r9,  r8,  r8,   r8,  r11,   r5 },
		{  r12,  r11,  r10, r10,  r9,  r9,  r8,  r8,  r8,   r7,   r6,  r11 },
		{   rB,  r11,  r10,  rB,  rB,  rB,  rB,  rB,  rB,   r7,   r6,   rB },
		{   rB,  r11,   r9,  rB,  rB,  rB,  rB,  rB,  rB,   r6,   r6,   rB },
		{  r12,  r11,   r9,  r8,  r8,  r8,  r7,  r7,  r6,   r6,   r4,  r11 },
		{   r5,  r12,   r9,  r8,  r8,  r7,  r7,  r6,  r6,   r4,  r10,   r5 },
		{ rOUT,  r11,   r8,  r8,  r7,  r7,  r6,  r6,  r4,   r4,   rB, rOUT },
		{ rOUT, rOUT,  r12, r11,  r6,  r6,  r6,  r4, r10,   rB, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r5, r11,  rB,  rB, r11,  r5, rOUT, rOUT, rOUT },
		},

		{	// kRadioDisabledOff
		{ rOUT, rOUT, rOUT,  r4,  r7,  r7,  r7,  r7,  r4, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,   r7,  r7,  r3,  r2,  r2,  r3,  r7,   r7, rOUT, rOUT },
		{ rOUT,   r7,   r3,  r2,  r2,  r2,  r2,  r2,  r2,   r3,   r7, rOUT },
		{   r4,   r7,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r7,   r4 },
		{   r7,   r3,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r3,   r7 },
		{   r7,   r2,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r2,   r7 },
		{   r7,   r2,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r2,   r7 },
		{   r7,   r3,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r3,   r7 },
		{   r4,   r7,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r7,   r4 },
		{ rOUT,   r7,   r3,  r2,  r2,  r2,  r2,  r2,  r2,   r3,   r7, rOUT },
		{ rOUT, rOUT,   r7,  r7,  r3,  r2,  r2,  r3,  r7,   r7, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r4,  r7,  r7,  r7,  r7,  r4, rOUT, rOUT, rOUT },
		},

		{	// kRadioDisabledOn
		{ rOUT, rOUT, rOUT,  r4,  r7,  r7,  r7,  r7,  r4, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,   r7,  r7,  r4,  r4,  r4,  r4,  r7,   r7, rOUT, rOUT },
		{ rOUT,   r7,   r5,  r4,  r4,  r4,  r4,  r4,  r4,   r5,   r7, rOUT },
		{   r4,   r7,   r4,  r4,  r8,  r8,  r8,  r8,  r4,   r4,   r7,   r4 },
		{   r7,   r4,   r4,  r8,  r8,  r8,  r8,  r8,  r8,   r4,   r4,   r7 },
		{   r7,   r4,   r4,  r8,  r8,  r8,  r8,  r8,  r8,   r4,   r4,   r7 },
		{   r7,   r4,   r4,  r8,  r8,  r8,  r8,  r8,  r8,   r4,   r4,   r7 },
		{   r7,   r4,   r4,  r8,  r8,  r8,  r8,  r8,  r8,   r4,   r4,   r7 },
		{   r4,   r7,   r4,  r4,  r8,  r8,  r8,  r8,  r4,   r4,   r7,   r4 },
		{ rOUT,   r7,   r5,  r4,  r4,  r4,  r4,  r4,  r4,   r5,   r7, rOUT },
		{ rOUT, rOUT,   r7,  r7,  r4,  r4,  r4,  r4,  r7,   r7, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r4,  r7,  r7,  r7,  r7,  r4, rOUT, rOUT, rOUT },
		},

		{	// kRadioDisabledMixed
		{ rOUT, rOUT, rOUT,  r4,  r7,  r7,  r7,  r7,  r4, rOUT, rOUT, rOUT },
		{ rOUT, rOUT,   r7,  r7,  r3,  r2,  r2,  r3,  r7,   r7, rOUT, rOUT },
		{ rOUT,   r7,   r3,  r2,  r2,  r2,  r2,  r2,  r2,   r3,   r7, rOUT },
		{   r4,   r7,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r7,   r4 },
		{   r7,   r3,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r3,   r7 },
		{   r7,   r2,   r2,  r8,  r8,  r8,  r8,  r8,  r8,   r2,   r2,   r7 },
		{   r7,   r2,   r2,  r8,  r8,  r8,  r8,  r8,  r8,   r2,   r2,   r7 },
		{   r7,   r3,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r3,   r7 },
		{   r4,   r7,   r2,  r2,  r2,  r2,  r2,  r2,  r2,   r2,   r7,   r4 },
		{ rOUT,   r7,   r3,  r2,  r2,  r2,  r2,  r2,  r2,   r3,   r7, rOUT },
		{ rOUT, rOUT,   r7,  r7,  r3,  r2,  r2,  r3,  r7,   r7, rOUT, rOUT },
		{ rOUT, rOUT, rOUT,  r4,  r7,  r7,  r7,  r7,  r4, rOUT, rOUT, rOUT },
		}

	};


//----------------------------------------------------------------------------------------
// CRadioButton_AC::CRadioButton_AC
//----------------------------------------------------------------------------------------

CRadioButton_AC::CRadioButton_AC(const CRect_AC& boundsRect, bool isActive,
											const CStr255_AC& itsTitle,
											const CTextStyle_AC& titleStyle,
											SInt16 itsValue,
											UInt32 groupIDPart1, UInt32 groupIDPart2, 
											bool automaticState) : 
	CCustomButton_AC(boundsRect, isActive, itsTitle, titleStyle), 
	MExclusiveObject_AC(groupIDPart1, groupIDPart2),
	fValue(itsValue),
	fAutomaticState(automaticState)
{
	// Construct with specified button title.
	if (! fgImagesAllocated)
		AllocateRadioImages();
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::~CRadioButton_AC
//----------------------------------------------------------------------------------------

CRadioButton_AC::~CRadioButton_AC()
{
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::TrackMouse
//----------------------------------------------------------------------------------------

ControlPartCode	CRadioButton_AC::TrackMouse(const CPoint_AC& mouseLocation, SInt16 modifiers)
{
	// If inherited tracking succeeded and we are set to
	// automatically change our state, toggle it.

	bool wasItHit = CCustomButton_AC::TrackMouse(mouseLocation, modifiers) != kControlNoPart;

	if (wasItHit && fAutomaticState)
	{
		SetValue(kControlRadioButtonCheckedValue);
	}

	return wasItHit ? GetDefaultPartCode() : kControlNoPart;
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::GetDefaultPartCode
//----------------------------------------------------------------------------------------

ControlPartCode CRadioButton_AC::GetDefaultPartCode() const
{
	return kControlRadioButtonPart;
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::GetValue
//----------------------------------------------------------------------------------------

SInt32 CRadioButton_AC::GetValue() const
{
	// Return current state.

	return fValue;
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::SetValue
//----------------------------------------------------------------------------------------

void CRadioButton_AC::SetValue(SInt32 newValue)
{
	// Set current state

	if (newValue == kControlRadioButtonCheckedValue)
		CGroupsContainer_AC::Instance()->HitGroupMember(this);

	if (newValue != fValue)
	{
		fValue = newValue;
		
		if (fVisible)
		{
			DrawControl();
		}
	}
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::SetGroupID
//----------------------------------------------------------------------------------------

void CRadioButton_AC::SetGroupID(UInt32 groupIDPart1, UInt32 groupIDPart2)
{
	MExclusiveObject_AC::SetGroupID(groupIDPart1, groupIDPart2);

	// If we are being installed into a group, we should turn automatic
	// mode on.
	
	if ((groupIDPart1 != kNoGroupID) && (groupIDPart2 != kNoGroupID))
		fAutomaticState = true;
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::TurnOff
//----------------------------------------------------------------------------------------

void CRadioButton_AC::TurnOff()
{
	// Turn off the radio button, presumably in response
	// to another button in the group being turned on.

	this->SetValue(kControlRadioButtonUncheckedValue);
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::DrawButtonNormal
//----------------------------------------------------------------------------------------

void CRadioButton_AC::DrawButtonNormal(bool deep)
{
	CRect_AC	r(GetBounds());

	r.Offset(2, 2);	// visually match the system CDEF

	// Draw the button in enabled/unpressed state.

	if (deep)
	{
		if (fValue == kControlRadioButtonMixedValue)
			this->CopyImage(kRadioNormalMixed);
		else if (fValue == kControlRadioButtonCheckedValue)
			this->CopyImage(kRadioNormalOn);
		else
			this->CopyImage(kRadioNormalOff);
	}
	else
	{
		r.right = r.left + kRadioImageWidth;
		r.bottom = r.top + kRadioImageHeight;

		// Paint white over previous junk, if any.
		kRGBColorRamp[rW].SetForeColor();
		::PaintRect(&r);
		// Paint frame.
		kRGBColorRamp[rB].SetForeColor();
		::FrameOval(&r);

		// Draw dot or dash.
		if (fValue == kControlRadioButtonCheckedValue)
		{
			r.Inset(3, 3);
			::PaintRoundRect(&r, 4, 4);
		}
		else if (fValue == kControlRadioButtonMixedValue)
		{
			::PenSize(1, 2);
			::MoveTo(r.left + 3, r.top + 5);
			::Line(5, 0);
		}
		
		::PenNormal();
	}

	// Draw the title.
	r = GetBounds();

	r.Offset(2, 2);	// visually match the system CDEF

	r.left += (kRadioImageWidth + 4);
	r.bottom = r.top + kRadioImageHeight;
	AGAStringOut(fTitle, r, truncMiddle, teJustLeft, kNormalOutput, deep, fTitleStyle);
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::DrawButtonPressed
//----------------------------------------------------------------------------------------

void CRadioButton_AC::DrawButtonPressed(bool deep)
{
	CRect_AC	r(GetBounds());

	r.Offset(2, 2);	// visually match the system CDEF

	// Draw the button in enabled/pressed state.

	if (deep)
	{
		if (fValue == kControlRadioButtonMixedValue)
			this->CopyImage(kRadioPressedMixed);
		else if (fValue == kControlRadioButtonCheckedValue)
			this->CopyImage(kRadioPressedOn);
		else
			this->CopyImage(kRadioPressedOff);
	}
	else
	{
		r.right = r.left + kRadioImageWidth;
		r.bottom = r.top + kRadioImageHeight;

		// Paint white over previous junk, if any.
		kRGBColorRamp[rW].SetForeColor();
		::PaintRect(&r);
		// Paint frame.
		kRGBColorRamp[rB].SetForeColor();
		::PenSize(2, 2);
		::FrameOval(&r);

		// Draw dot or dash.
		if (fValue == kControlRadioButtonCheckedValue)
		{
			r.Inset(3, 3);
			::PaintRoundRect(&r, 4, 4);
		}
		else if (fValue == kControlRadioButtonMixedValue)
		{
			::PenSize(1, 2);
			::MoveTo(r.left + 3, r.top + 5);
			::Line(5, 0);
		}
		
		::PenNormal();
	}

	// Draw the title.
	r = GetBounds();

	r.Offset(2, 2);	// visually match the system CDEF

	r.left += (kRadioImageWidth + 4);
	r.bottom = r.top + kRadioImageHeight;
	AGAStringOut(fTitle, r, truncMiddle, teJustLeft, kNormalOutput, deep, fTitleStyle);
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::DrawButtonDisabled
//----------------------------------------------------------------------------------------

void CRadioButton_AC::DrawButtonDisabled(bool deep)
{
	CRect_AC	r(GetBounds());

	r.Offset(2, 2);	// visually match the system CDEF

	// Draw the button in disabled/unpressed state.

	if (deep)
	{
		if (fValue == kControlRadioButtonMixedValue)
			this->CopyImage(kRadioDisabledMixed);
		else if (fValue == kControlRadioButtonCheckedValue)
			this->CopyImage(kRadioDisabledOn);
		else
			this->CopyImage(kRadioDisabledOff);
	}
	else
	{
		r.right = r.left + kRadioImageWidth;
		r.bottom = r.top + kRadioImageHeight;

		// Paint white over previous junk, if any.
		kRGBColorRamp[rW].SetForeColor();
		::PaintRect(&r);

		// Paint frame.
		PenPatGray();
		kRGBColorRamp[rB].SetForeColor();
		::FrameOval(&r);

		// Draw check or dash.
		if (fValue == kControlRadioButtonCheckedValue)
		{
			r.Inset(3, 3);
			::PaintRoundRect(&r, 4, 4);
		}
		else if (fValue == kControlRadioButtonMixedValue)
		{
			::PenSize(1, 2);
			::MoveTo(r.left + 3, r.top + 5);
			::Line(5, 0);
		}
		
		::PenNormal();
	}

	// Draw the title.
	r = GetBounds();

	r.Offset(2, 2);	// visually match the system CDEF

	r.left += (kRadioImageWidth + 4);
	r.bottom = r.top + kRadioImageHeight;
	AGAStringOut(fTitle, r, truncMiddle, teJustLeft, kDisabledOutput, deep, fTitleStyle);
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::CopyImage
//----------------------------------------------------------------------------------------

void CRadioButton_AC::CopyImage(UInt32 index)
{
	// Blast the specified offscreen image into the
	// radio button's button area. We offset by (2, 2)
	// to match the positioning of the system CDEF.

	fgOffscreenRadioImages[index]->DrawImage(GetBounds().left + 2, GetBounds().top + 2);
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::AllocateRadioImages
//----------------------------------------------------------------------------------------

void CRadioButton_AC::AllocateRadioImages()
{
	// Allocate the offscreen image for each radio button state.

	CPoint_AC	imageSize(kRadioImageWidth, kRadioImageHeight);
	
	// A simple round rect defines the radio image clipping region.

	RgnHandle radioImageClippingRegion = CRegion_AC::MakeNewRgn();

	CRect_AC	imageClippingRect(0, 0, kRadioImageWidth, kRadioImageHeight);

	::OpenRgn();
	::FrameRoundRect(&imageClippingRect, 11, 11);
	//::FrameOval(&imageClippingRect);	ugly AGA 7/96 specs use just the chunky circle -- we'll stick with earlier specs
	::CloseRgn(radioImageClippingRegion);

	for (UInt32 imageIndex = 0; imageIndex < kNumRadioImages; ++imageIndex)
	{
		fgOffscreenRadioImages[imageIndex] = TH_new CSimpleOffscreenImage_AC;
		
		fgOffscreenRadioImages[imageIndex]->CreateImageData(
					imageSize,
					&kRadioImageValues[imageIndex][0][0],
					radioImageClippingRegion, 
					kRGBColorRamp[rB]);
	}
			
	::DisposeRgn(radioImageClippingRegion);
		
	fgImagesAllocated = true;
}

//----------------------------------------------------------------------------------------
// CRadioButton_AC::DisposeRadioImages
//----------------------------------------------------------------------------------------

void CRadioButton_AC::DisposeRadioImages()
{
	for (UInt32 imageIndex = 0; imageIndex < kNumRadioImages; ++imageIndex)
		if (!fgOffscreenRadioImages[imageIndex].IsNULL())
			fgOffscreenRadioImages[imageIndex].reset();
}


#endif // qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of CRadioButton_AC.cpp
