//----------------------------------------------------------------------------------------
// CUpDownControl_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/04/00	Conditional on qEmulateStandardControls
		09/22/00	Improved graphics device iterator. 
		03/24/99	Update copyright notice.
*/

#ifndef __CUpDownControl_AC__
#include "CUpDownControl_AC.h"
#endif

#if qEmulateStandardControls

// Appearance

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

// ACS

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

//========================================================================================
// CUpDownControl_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::CUpDownControl_AC
//----------------------------------------------------------------------------------------

CUpDownControl_AC::CUpDownControl_AC(const CRect_AC& bounds, bool isActive, MControlHandler_AC* actionHandler) : 
	CCustomControl_AC(bounds, isActive),
	fActionHandler(actionHandler)
{
}

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::~CUpDownControl_AC
//----------------------------------------------------------------------------------------

CUpDownControl_AC::~CUpDownControl_AC()
{
}

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::SetActionHandler
//----------------------------------------------------------------------------------------

void CUpDownControl_AC::SetActionHandler(MControlHandler_AC* actionHandler)
{
	fActionHandler = actionHandler;
}

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::GetActionHandler
//----------------------------------------------------------------------------------------

MControlHandler_AC* CUpDownControl_AC::GetActionHandler()
{
	return fActionHandler;
}

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::DrawControl
//----------------------------------------------------------------------------------------

void CUpDownControl_AC::DrawControl()
{
	// Draw the arrows in normal unpressed state.

	this->DrawButton(kControlNoPart);
}

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::DrawButton
//----------------------------------------------------------------------------------------

void CUpDownControl_AC::DrawButton(ControlPartCode pressedPart)
{
	CTempDrawingEnvironment_AC	env;

	// Draw the arrows in the specified press state. The
	// state may indicate that either or no arrow is pressed.

	enum { Frame, Fill, TL, BR, Arrow, kNumArrowColors };

	UInt8	colorIndexes[kNumArrowColors];
	
	bool			drawEnabled = fActive;

	for (CGDIterator_AC iter; iter; ++iter)
	{
		bool deep = iter->IsDeep();

		CRect_AC	r(GetBounds());
		
		r.right = r.left + kLittleArrowWidth;
		r.bottom = r.top + kLittleArrowHeight;
		
		for (UInt32 i = 0; i < 2; ++i)
		{
			if (deep)
			{
				if (drawEnabled)
				{
					if (((pressedPart == kControlUpButtonPart) && (i == 0)) ||
						((pressedPart == kControlDownButtonPart) && (i == 1)))
					{
						colorIndexes[Frame] = rB;
						colorIndexes[Fill] = r8;
						colorIndexes[TL] = r10;
						colorIndexes[BR] = r6;
						colorIndexes[Arrow] = rW;
					}
					else if (((pressedPart != kControlUpButtonPart) && (i == 0)) ||
						((pressedPart != kControlDownButtonPart) && (i == 1)))
					{
						colorIndexes[Frame] = rB;
						colorIndexes[Fill] = r2;
						colorIndexes[TL] = rW;
						colorIndexes[BR] = r5;
						colorIndexes[Arrow] = rB;
					}
				}
				else	// disabled
				{
					colorIndexes[Frame] = r7;
					colorIndexes[Fill] = r2;
					colorIndexes[TL] = r2;
					colorIndexes[BR] = r2;
					colorIndexes[Arrow] = r7;
				}
				
				// These (1-i) and i uses here are to round off the top corners
				// of the top frame (i=0) and round off the bottom corners of
				// the bottom frame (i=1).
				kRGBColorRamp[colorIndexes[Frame]].SetForeColor();
				::MoveTo(r.left + (1-i), r.top);
				::MacLineTo(r.right - 1 - (1-i), r.top);
				::Move(1-i, 1-i);
				::MacLineTo(r.right -1, r.bottom - 1 - i);
				::Move(-i, i);
				::MacLineTo(r.left + i, r.bottom - 1);
				::Move(-i, -i);
				::MacLineTo(r.left, r.top + (1-i));
				
				r.Inset(1, 1);
				kRGBColorRamp[colorIndexes[Fill]].SetForeColor();
				::PaintRect(&r);
				r.Inset(-1, -1);
				
				kRGBColorRamp[colorIndexes[TL]].SetForeColor();
				::MoveTo(r.left + 1, r.bottom - 3);
				::MacLineTo(r.left + 1, r.top + 1);
				::MacLineTo(r.right - 3, r.top + 1);
				
				kRGBColorRamp[colorIndexes[BR]].SetForeColor();
				::MoveTo(r.left + 2, r.bottom - 2);
				::MacLineTo(r.right - 2, r.bottom - 2);
				::MacLineTo(r.right - 2, r.top + 2);
				
				kRGBColorRamp[colorIndexes[Arrow]].SetForeColor();
			}
			else	// 1-bit
			{
				if (((pressedPart == kControlUpButtonPart) && (i == 0)) ||
					((pressedPart == kControlDownButtonPart) && (i == 1)))
				{
					kRGBColorRamp[rB].SetForeColor();
					r.Inset(1, 1);
					::PaintRect(&r);
					r.Inset(-1, -1);
					kRGBColorRamp[rW].SetForeColor();
					}
				else
				{
					kRGBColorRamp[rW].SetForeColor();
					::PaintRect(&r);
					kRGBColorRamp[rB].SetForeColor();

					::MoveTo(r.left + (1-i), r.top);
					::MacLineTo(r.right - 1 - (1-i), r.top);
					::Move(1-i, 1-i);
					::MacLineTo(r.right -1, r.bottom - 1 - i);
					::Move(-i, i);
					::MacLineTo(r.left + i, r.bottom - 1);
					::Move(-i, -i);
					::MacLineTo(r.left, r.top + (1-i));
				}
			}

			::MoveTo(r.left + 3, r.top + 7 - (i*3));
			::Line(6, 0);
			::Move(-1, -1 + (2*i));
			::Line(-4, 0);
			::Move(1, -1 + (2*i));
			::Line(2, 0);
			::Move(-1, -1 + (2*i));
			::Line(0, 0);
			
			r.Offset(0, kLittleArrowHeight - 1);
		}

		if ((! drawEnabled) && ! deep)
		{
			kRGBColorRamp[rB].SetForeColor();
			PenPatGray();
			::PenMode(patBic);
			::PaintRect(GetBounds());

			::PenNormal();
		}
	}
}

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::TrackPart
//----------------------------------------------------------------------------------------

ControlPartCode CUpDownControl_AC::TrackPart(const CPoint_AC& /*mouseLocation*/, ControlPartCode partHit)
{
	// Track the mouse in the specified arrow. Little arrows always
	// return true because the tracking is always successful.

	bool		wasIn = false;
	bool		isIn = true;
	bool		isButtonDown = true;	// ensure at least one time through
	CPoint_AC	newMouseLocation;
	UInt32		accelerationDelay = 18;	// will divide by 2 each time
	
	while (isButtonDown)
	{
		if (isIn)
			HandleControlAction(partHit);

		::GetMouse(&newMouseLocation);	// gives local coordinates
		
		isIn = (this->TestMouse(newMouseLocation) == partHit);
		
		if (isIn != wasIn)
			this->SetPartHilite(partHit, isIn);
		
		wasIn = isIn;
		
		if (isButtonDown && (accelerationDelay != 0))
		{
			DelayFutureWhileStillDown_AC(accelerationDelay);
			accelerationDelay = accelerationDelay >> 1;	// divide by 2
		}

		isButtonDown = ::StillDown();
	}
	
	if (isIn)	// if finished IN, restore normal appearance
		this->DrawButton(kControlNoPart);
	
	return partHit;
}

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::TestMouse
//----------------------------------------------------------------------------------------

ControlPartCode CUpDownControl_AC::TestMouse(const CPoint_AC& mouseLocation) const
{
	// Return the part value where the mouse would hit.

	if ((mouseLocation.h >= GetBounds().left + kLittleArrowWidth) ||
		(mouseLocation.h < GetBounds().left) ||
		(mouseLocation.v >= GetBounds().top + kLittleArrowTotalHeight) ||
		(mouseLocation.v < GetBounds().top))
		return kControlNoPart;
	else if (mouseLocation.v < GetBounds().top + kLittleArrowHeight)
		return kControlUpButtonPart;
	else
		return kControlDownButtonPart;
}

//----------------------------------------------------------------------------------------
// CUpDownControl_AC::SetPartHilite
//----------------------------------------------------------------------------------------

void CUpDownControl_AC::SetPartHilite(ControlPartCode part, bool isHilited)
{
	DrawButton(isHilited ? part : kControlNoPart);
}


#endif // qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of CUpDownControl_AC.cpp
