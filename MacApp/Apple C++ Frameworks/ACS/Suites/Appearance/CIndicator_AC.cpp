//----------------------------------------------------------------------------------------
// CIndicator_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
// Portions Copyright © 1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/04/00	Conditional on qEmulateStandardControls
		03/24/99	Update copyright notice.
*/

#ifndef __CIndicator_AC__
#include "CIndicator_AC.h"
#endif

#if qEmulateStandardControls

//========================================================================================
// CIndicator_AC
//========================================================================================

CIndicator_AC::CIndicator_AC(const CRect_AC& bounds, bool isActive,
							 SInt32 minimum, SInt32 maximum, SInt32 initialValue, 
							 SInt32 viewSize, bool liveTracking, bool proportional, 
							 MControlHandler_AC* actionHandler)
	: CCustomControl_AC(bounds, isActive),
	fMinimum(minimum),
	fMaximum(maximum),
	fValue(initialValue),
	fViewSize(viewSize),
	fGhostValue(fValue),
	fLiveTracking(liveTracking),
	fIsProportional(proportional),
	fIsHorizontal((bounds.right - bounds.left) > (bounds.bottom - bounds.top)),
	fIsPressed(false),
	fActionHandler(actionHandler)
{
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

CIndicator_AC::~CIndicator_AC()
{
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetActionHandler(MControlHandler_AC* actionHandler)
{
	fActionHandler = actionHandler;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

MControlHandler_AC* CIndicator_AC::GetActionHandler()
{
	return fActionHandler;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetAttributes(bool isHorizontal, bool liveTracking, bool isProportional)
{
	// Set options as specified.

	fIsHorizontal = isHorizontal;
	fLiveTracking = liveTracking;
	fIsProportional = isProportional;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetLiveTracking(bool liveTracking)
{
	// Turn live tracking on or off.

	fLiveTracking = liveTracking;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::DrawControl()
{
	// Call component drawing functions. These are all overridden
	// by subclasses.

	DrawBackground();
	DrawIndicatorTrack();
	DrawTrackEnds();
	DrawIndicator();
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

ControlPartCode CIndicator_AC::TrackPart(const CPoint_AC& mouseLocation, ControlPartCode partHit)
{
	// Track the mouse in the specified part and return the part code.
	if (partHit != kControlIndicatorPart)
		return kControlNoPart;

	SInt32		originalValue = fValue;
	CPoint_AC	oldPoint = mouseLocation;
	CPoint_AC	newPoint = mouseLocation;
	SInt32		oldValue = originalValue;
	SInt32		newValue = originalValue;
	bool		isButtonDown = true;	// ensure at least one time through
	
	fGhostValue = fValue;
	fIsPressed = true;
	DrawIndicator();	// will draw it pressed
	
	while (isButtonDown)
	{
		::GetMouse(&newPoint);	// gives local coordinates
		
		if (IsValidIndicatorTrackMouse(newPoint) &&
			! ::EqualPt(newPoint, oldPoint))
		{
			newValue = GetValueFromMouseDelta(oldValue, mouseLocation, newPoint);
		
			if (fLiveTracking)
			{
				SInt32	oldValue = fValue;

				SetRawValue(newValue);	// will draw new indicator
				
				if (fValue != oldValue)
					HandleControlAction(partHit);
			}
			else
				SetGhostValue(newValue);
			
			oldPoint = newPoint;
		}
		
		isButtonDown = ::StillDown();
	}
	
	fIsPressed = false;
	
	if (fLiveTracking)
		DrawIndicator();	// unpressed
	else
	{
		RemoveGhost(newValue);
		DrawIndicator();	// unpressed

		if (newValue != fValue)	// don't notify if no change
		{
			SetRawValue(newValue);	// will draw new indicator
			HandleControlAction(partHit);
		}
	}
	
	return (fValue != originalValue) ? partHit : kControlNoPart;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

SInt32 CIndicator_AC::GetValue() const
{
	// Return the current indicator value.

	return fValue;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetGhostValue(SInt32 newValue)
{
	// Set the ghost indicator value, and optionally redraw it
	// at its new position.

	if (newValue > fMaximum)
		newValue = fMaximum;
	else if (newValue < fMinimum)
		newValue = fMinimum;

	if (newValue != fGhostValue)
	{
		RemoveGhost(newValue);

		fGhostValue = newValue;
		
		DrawGhost();
	}
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetValue(SInt32 newValue)
{
	SetRawValue(newValue);
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetRawValue(SInt32 newValue)
{
	// Set the indicator value, and optionally redraw it
	// at its new position.

	if (newValue > fMaximum)
		newValue = fMaximum;
	else if (newValue < fMinimum)
		newValue = fMinimum;

	if (newValue != fValue)
	{
		if (fVisible)
			RemoveIndicator(newValue);

		fValue = newValue;
		
		if (fVisible)
			DrawIndicator();
	}
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

SInt32 CIndicator_AC::GetMinimum() const
{
	return fMinimum;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

SInt32 CIndicator_AC::GetMaximum() const
{
	return fMaximum;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetMinimum(SInt32 newMinimum)
{
	// Set the min/max range, and optionally redraw.

	if (newMinimum != fMinimum)
	{
		if (fVisible)
			RemoveIndicator(fValue);

		fMinimum = newMinimum;
		
		fValue = MaxSInt32(fMinimum, MinSInt32(fValue, fMaximum));

		if (fVisible)
			DrawIndicator();
	}
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetMaximum(SInt32 newMaximum)
{
	// Set the min/max range, and optionally redraw.

	if (newMaximum != fMaximum)
	{
		if (fVisible)
			RemoveIndicator(fValue);

		fMaximum = newMaximum;
		
		fValue = MaxSInt32(fMinimum, MinSInt32(fValue, fMaximum));

		if (fVisible)
			DrawIndicator();
	}
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

SInt32 CIndicator_AC::GetViewSize() const
{
	// Return the current indicator page size.

	return fViewSize;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::SetViewSize(SInt32 newViewSize)
{
	// Set the indicator page size. Redraw is not
	// necessary if the indicator is not proportional.

	if (newViewSize != fViewSize)
	{
		if (fVisible)
			RemoveIndicator(fValue);

		fViewSize = newViewSize;
		fIsProportional = true; // ••• was settable, now triggered by a call to SetViewSize.
		
		if (fVisible)
			DrawIndicator();
	}
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

bool CIndicator_AC::IsValidIndicatorTrackMouse(const CPoint_AC& mouseLocation)
{
	// Usually overridden. Return true if the specified mouse
	// position should be considered "in" for tracking purposes
	// after the initial hit has succeeded. Return false if the
	// specified mouse position is too far away from the control
	// to use it for the next momentary tracking position.

	return fBounds.Contains(mouseLocation);
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

SInt32 CIndicator_AC::GetValueFromMouseDelta(SInt32 originalValue, const CPoint_AC& /*originalMouseLocation*/, const CPoint_AC& /*newMouseLocation*/)
{
	// Must be overridden. Return the indicator value that should be
	// applied assuming the supplied starting value and mouse hit point,
	// and the supplied current mouse tracking location.
	return originalValue;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::DrawBackground()
{
	// Override to paint the background area so that the
	// indicator drawn at its old position will be wiped out.
	// Clipping will be already set up to avoid excess flicker.
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::DrawIndicatorTrack()
{
	// Override to draw the empty indicator track. Must include
	// all possible indicator coverage.
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::DrawTrackEnds()
{
	// Override to draw the track ends outside the possible
	// indicator coverage if not drawn in DrawIndicatorTrack.
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::DrawIndicator()
{
	// Override to draw the indicator at its current value/state.
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::RemoveIndicator(SInt32 /*newValue*/)
{
	// Override to draw/erase whatever is needed to remove the
	// current indicator in preparation for being drawn at
	// the specified new value. The new value is supplied so
	// that erasing can be kept to a minimal area.
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::DrawGhost()
{
	// Override to draw the indicator in ghost mode at
	// the current ghost value.
}

//----------------------------------------------------------------------------------------
// CIndicator_AC
//----------------------------------------------------------------------------------------

void CIndicator_AC::RemoveGhost(SInt32 /*newValue*/)
{
	// Override to draw/erase whatever is needed to remove the
	// ghost indicator in preparation for being drawn at
	// the specified new value. The new value is supplied so
	// that erasing can be kept to a minimal area.
}

//----------------------------------------------------------------------------------------
//
//----------------------------------------------------------------------------------------

SInt32 CIndicator_AC::GetIndicatorInset() const
{
	return kIndicatorPixelInset;
}

//----------------------------------------------------------------------------------------
//
//----------------------------------------------------------------------------------------

SInt32 CIndicator_AC::GetIndicatorGapSize() const
{
	return kArrowSize;
}

//----------------------------------------------------------------------------------------
// CIndicator_AC::GetIndicatorPixelEnds
//----------------------------------------------------------------------------------------

void CIndicator_AC::GetIndicatorPixelEnds(SInt32& startPt, SInt32& stopPt) const
{
	// Return the start and end pixel locations of the indicator
	// track traveled by the center point of the indicator.

	SInt32	dontCare;
	SInt32	range = GetIndicatorPixelRange(dontCare);
	CRect_AC r(GetBounds());
	
	if (IsHorizontal())
		startPt = ((r.left + r.right) / 2) - (range / 2) - 1;
	else
		startPt = ((r.top + r.bottom) / 2) - (range / 2) - 1;

	stopPt = startPt + range;	// avoid rounding of 1/2 pixel twice
}

//----------------------------------------------------------------------------------------
// CIndicator_AC::GetIndicatorPixelRange
//----------------------------------------------------------------------------------------

SInt32 CIndicator_AC::GetIndicatorPixelRange(SInt32& proportionalIndicatorPixels) const
{
	// Return the pixel range that the center point of the indicator
	// can travel along the track, and also return the amount of
	// range reduction that is caused by proportional indicator growth.
	// Non-proportional indicators use the full track range, minus
	// the size of the indicator itself.

	SInt32	range;
	SInt32	indicatorInset = GetIndicatorInset();
	
	proportionalIndicatorPixels = 0;
	CRect_AC r(GetBounds());
	
	if (IsHorizontal())
		range = r.right - r.left - (2 * (GetIndicatorGapSize() + indicatorInset)) + 1;
	else
		range = r.bottom - r.top - (2 * (GetIndicatorGapSize() + indicatorInset)) + 1;

	if (IsProportional())
	{
		SInt32	pagePixels;
		
		pagePixels =
			(range * (((float) GetViewSize()) / ((float) (fMaximum - fMinimum))));
		
		if (pagePixels > 0)
		{
			range -= pagePixels;
			proportionalIndicatorPixels = pagePixels;
		}
	}
	
	return range;
}

//----------------------------------------------------------------------------------------
//
//----------------------------------------------------------------------------------------

void CIndicator_AC::GetIndicatorSpan(SInt32 value, SInt32& startPt, SInt32& valuePt, SInt32& stopPt) const
{
	// Return the pixel locations of the indicator's ends and value.

	SInt32	proportionalIndicatorPixels;
	SInt32	trackStart;
	SInt32	trackStop;
	SInt32	trackRange = GetIndicatorPixelRange(proportionalIndicatorPixels);
	SInt32	indicatorInset = GetIndicatorInset();
	
	GetIndicatorPixelEnds(trackStart, trackStop);
	
	valuePt = trackStart +
		(trackRange * (((float) (value - fMinimum)) / ((float) (fMaximum - fMinimum))));

	startPt = valuePt - indicatorInset - (proportionalIndicatorPixels / 2);
	stopPt = startPt + (2 * indicatorInset) + proportionalIndicatorPixels + 1;
}

#endif // qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of CIndicator_AC.cpp
