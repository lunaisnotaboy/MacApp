//----------------------------------------------------------------------------------------
// CStaticText_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/04/00	Conditional on qEmulateStandardControls
		09/22/00	Improved graphics device iterator. 
		06/14/00	Eliminate unnecessary GetRegionCode calls.
		03/24/99	Update copyright notice.
*/

#ifndef __CStaticText_AC__
#include "CStaticText_AC.h"
#endif

#if qEmulateStandardControls

// Appearance

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

// ACS

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

// Toolbox


//========================================================================================
// CStaticText_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CStaticText_AC::CStaticText_AC
//----------------------------------------------------------------------------------------

CStaticText_AC::CStaticText_AC(const CRect_AC& bounds, const CTextStyle_AC& textStyle, SInt32 justification, bool autoWrap, bool eraseFirst, const CStr255_AC& title) : 
	CCustomControl_AC(bounds),
	fJustification(justification),
	fTitle(title),
	fTextStyle(textStyle),
	fAutoWrap(autoWrap),
	fEraseFirst(eraseFirst)
{
	// Construct with supplied string.
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::CStaticText_AC
//----------------------------------------------------------------------------------------

CStaticText_AC::CStaticText_AC(const CRect_AC& bounds, const CTextStyle_AC& textStyle, SInt32 justification, bool autoWrap, bool eraseFirst, SInt16 stringListResourceID, SInt16 stringIndex) : 
	CCustomControl_AC(bounds),
	fJustification(justification),
	fTextStyle(textStyle),
	fAutoWrap(autoWrap),
	fEraseFirst(eraseFirst),
	fTitle(stringListResourceID, stringIndex) // Construct by getting string from specified resource.
{
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::~CStaticText_AC
//----------------------------------------------------------------------------------------

CStaticText_AC::~CStaticText_AC()
{
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::DrawControl
//----------------------------------------------------------------------------------------

void CStaticText_AC::DrawControl()
{
	// Paint over possible obsolete text, draw current text.

	for (CGDIterator_AC iter; iter; ++iter)
	{
		CRGBColor_AC teBackgroundColor;
		teBackgroundColor.GetBackColor();

		AGATextBox(&fTitle[1], fTitle.Length(), GetBounds(), fJustification, fAutoWrap, 
				   IsActive() ? kUseCurrentColor : kDisabledOutput, 
				   iter->IsDeep(), fTextStyle, teBackgroundColor, fEraseFirst);
	}
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::GetTitle
//----------------------------------------------------------------------------------------

CStr255_AC CStaticText_AC::GetTitle() const
{
	return fTitle;
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::SetTitle
//----------------------------------------------------------------------------------------

void CStaticText_AC::SetTitle(const CStr255_AC& title)
{
	fTitle = title;
	
	if (fVisible)
		DrawControl();
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::SetFontStyle
//----------------------------------------------------------------------------------------

void CStaticText_AC::SetFontStyle(const CControlTextStyle_AC& textStyle)
{
	fTextStyle = CControlTextStyle_AC(textStyle);
	fJustification = textStyle.just;
	
	if (fVisible)
		this->DrawControl();
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::GetFontStyle
//----------------------------------------------------------------------------------------

CControlTextStyle_AC CStaticText_AC::GetFontStyle()
{
	return CControlTextStyle_AC(fTextStyle);
}

#if qBackwardCompatible

//----------------------------------------------------------------------------------------
// CStaticText_AC::GetTextStyle
//----------------------------------------------------------------------------------------

CTextStyle_AC CStaticText_AC::GetTextStyle() const
{
	return fTextStyle;
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::SetTextStyle
//----------------------------------------------------------------------------------------

void CStaticText_AC::SetTextStyle(const CTextStyle_AC& textStyle)
{
	fTextStyle = textStyle;
	
	if (fVisible)
		this->DrawControl();
}

//----------------------------------------------------------------------------------------
// CStaticText_AC::SetJustification
//----------------------------------------------------------------------------------------

void CStaticText_AC::SetJustification(SInt32 justification)
{
	fJustification = justification;
	
	if (fVisible)
		DrawControl();
}

#endif // qBackwardCompatible

//----------------------------------------------------------------------------------------
// CStaticText_AC::SetAutoWrap
//----------------------------------------------------------------------------------------

void CStaticText_AC::SetAutoWrap(bool autoWrap)
{
	// Change text, redraw if specified.

	fAutoWrap = autoWrap;
	
	if (fVisible)
		DrawControl();
}


#endif // qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of CStaticText_AC.cpp
