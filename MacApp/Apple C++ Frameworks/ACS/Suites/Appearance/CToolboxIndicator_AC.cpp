//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC.cpp 
// Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/06/00	Move SetViewSize and GetViewSize to CToolboxControl_AC. 
		03/03/00	Fetch current value in SetMaximum before setting max since
					SetBitsToShift could alter the current value.
		08/17/99	Appearance 1.1 calls are PPC only. 
		07/27/99	Removed qAllegro test in GetValue, SetValue, GetMinimum, SetMinimum, GetMaximum,
					SetMaximum, GetViewSize and SetViewSize.
		03/24/99	Update copyright notice.
		03/02/99	[2306509] Pass itsValue, itsMin and itsMax in CreateIndicatorRef to
					CreateControlRef get the number of ticks to work.
		11/13/98	[2279281] Use qAllegro in place of qPowerPC && (UNIVERSAL_INTERFACES_VERSION >= 0x0320).
		10/06/98	Clean up includes. 
*/

#ifndef __CToolboxIndicator_AC__
#include "CToolboxIndicator_AC.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif


//========================================================================================
// CLASS CToolboxIndicator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

CToolboxIndicator_AC::CToolboxIndicator_AC(ControlRef theControl) :
	CToolboxControl_AC(theControl),
	fBitsToShift(0)
{
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

CToolboxIndicator_AC::CToolboxIndicator_AC(SInt16 resourceID, WindowRef owningWindow) :
	CToolboxControl_AC(NULL),
	fBitsToShift(0)
{
	CreateControlRef(resourceID, owningWindow);
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

CToolboxIndicator_AC::CToolboxIndicator_AC(WindowRef theWindow, SInt16 controlType, 
		const CRect_AC& boundsRect, 
		const CStr255_AC& itsTitle, 
		bool isVisible, bool isActive, 
		SInt32 itsValue, SInt32 itsMin, SInt32 itsMax, 
		SInt32 itsViewSize,
		MControlHandler_AC* actionHandler) :
	CToolboxControl_AC(NULL),
	fBitsToShift(0)
{
	CreateIndicatorRef(theWindow, controlType, boundsRect, itsTitle, isVisible, isActive, 
						itsValue, itsMin, itsMax,
						itsViewSize, 
						reinterpret_cast<long> (actionHandler));
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

CToolboxIndicator_AC::~CToolboxIndicator_AC()
{
}


//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

void CToolboxIndicator_AC::CreateIndicatorRef(WindowRef theWindow, SInt16 controlType, 
		const CRect_AC& boundsRect, 
		const CStr255_AC& itsTitle, 
		bool isVisible, bool isActive, 
		SInt32 itsValue, SInt32 itsMin, SInt32 itsMax,
		SInt32 itsViewSize, 
		long refCon)
{
	CreateControlRef(theWindow, controlType, boundsRect, itsTitle, false, isActive, itsValue, itsMin, itsMax, refCon);
	SetValues(itsValue, itsMin, itsMax);
	SetViewSize(itsViewSize);
	SetVisibility(isVisible);
}	

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

SInt32 CToolboxIndicator_AC::GetValue() const
{
	SInt32 itsValue = 0;
	if (fControl)
	{
#if qPowerPC
		if (AppearanceMgrVersion_AC() >= 0x110)
			itsValue = ::GetControl32BitValue(fControl);
		else
#endif
			itsValue = ShortToLong(::GetControlValue(fControl));
	}
	return itsValue;
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

void CToolboxIndicator_AC::SetValue(SInt32 newValue)
{
	if (fControl)
	{
		newValue = MinMax_AC(GetMinimum(), newValue, GetMaximum());

#if qPowerPC
		if (AppearanceMgrVersion_AC() >= 0x110)
			::SetControl32BitValue(fControl, newValue);
		else
#endif
			::SetControlValue(fControl, LongToShort(newValue));
	}
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

SInt32 CToolboxIndicator_AC::GetMinimum() const
{
	SInt32 itsMinimum = 0;
	if (fControl)
	{
#if qPowerPC
		if (AppearanceMgrVersion_AC() >= 0x110)
			itsMinimum = ::GetControl32BitMinimum(fControl);
		else
#endif
			itsMinimum = ShortToLong(::GetControlMinimum(fControl));
	}
	return itsMinimum;
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

void CToolboxIndicator_AC::SetMinimum(SInt32 newMin)
{
	if (fControl)
	{
#if qPowerPC
		if (AppearanceMgrVersion_AC() >= 0x110)
			::SetControl32BitMinimum(fControl, newMin);
		else
#endif
			::SetControlMinimum(fControl, LongToShort(newMin));

		// ??? Does the Control Manager do this for us?
		if (GetMinimum() > GetValue()) 
		{
			SetValue(GetMinimum());
		}
	}
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

SInt32 CToolboxIndicator_AC::GetMaximum() const
{
	SInt32 itsMaximum = 0;
	if (fControl)
	{
#if qPowerPC
		if (AppearanceMgrVersion_AC() >= 0x110)
			itsMaximum = ::GetControl32BitMaximum(fControl);
		else
#endif
			itsMaximum = ShortToLong(::GetControlMaximum(fControl));
	}
	return itsMaximum;
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

void CToolboxIndicator_AC::SetMaximum(SInt32 newMax)
{
	if (fControl)
	{
		SInt32 oldValue = GetValue(); // Get it now as SetBitsToShift() may change it

#if qPowerPC && (UNIVERSAL_INTERFACES_VERSION >= 0x0320)
		if (AppearanceMgrVersion_AC() >= 0x110)
		{
			::SetControl32BitMaximum(fControl, newMax);
			
			// ??? Does the Control Manager do this for us?
			if (GetMaximum() < oldValue) 
				SetValue(GetMaximum());
		}
		else
#endif
		{
			::SetControlMaximum(fControl, SetBitsToShift(newMax));
			SetValue(oldValue);
		}
	}
}

//----------------------------------------------------------------------------------------
// CToolboxIndicator_AC
//----------------------------------------------------------------------------------------

SInt16 CToolboxIndicator_AC::SetBitsToShift(SInt32 longValue)
{
	fBitsToShift = 0;
	while (longValue > SHRT_MAX)
	{
		longValue = ((longValue) >> 1);
		++fBitsToShift;
	}
	return longValue;
}


//----------------------------------------------------------------------------------------
// End of CToolboxIndicator_AC.cpp 
