//----------------------------------------------------------------------------------------
// CChasingArrows_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
//----------------------------------------------------------------------------------------

/*
	Change History
		11/04/00	Conditional on qEmulateStandardControls
		01/02/01	Update copyright.
		09/22/00	Improved graphics device iterator. 
		03/24/99	Update copyright notice.
		11/13/98	Use TickCount instead of LMGetTicks
*/

#ifndef __CChasingArrows_AC__
#include "CChasingArrows_AC.h"
#endif

#if qEmulateStandardControls

// Appearance

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

// ACS

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

// ToolBox

#ifndef __ICONS__
#include <Icons.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif


//========================================================================================
// CChasingArrows_AC
// This class implements chasing arrows.
//========================================================================================

//----------------------------------------------------------------------------------------
// CChasingArrows_AC::CChasingArrows_AC
//----------------------------------------------------------------------------------------

CChasingArrows_AC::CChasingArrows_AC(const CRect_AC& bounds, bool isActive) : 
	CCustomControl_AC(bounds, isActive),
	fAnimationIndex(0),
	fLastAnimationTime(0),
	fAnimating(false)
{
}

//----------------------------------------------------------------------------------------
// CChasingArrows_AC::CChasingArrows_AC
//----------------------------------------------------------------------------------------

CChasingArrows_AC::~CChasingArrows_AC()
{
}

//----------------------------------------------------------------------------------------
// CChasingArrows_AC::CChasingArrows_AC
//----------------------------------------------------------------------------------------

void CChasingArrows_AC::DrawControl()
{
	if (fAnimating)
		DrawAnimationStep();
	else
		EraseBackground();
}

//----------------------------------------------------------------------------------------
// CChasingArrows_AC::CChasingArrows_AC
//----------------------------------------------------------------------------------------

void CChasingArrows_AC::EndAnimation()
{
	fAnimating = false;
}

//----------------------------------------------------------------------------------------
// CChasingArrows_AC::CChasingArrows_AC
//----------------------------------------------------------------------------------------

void CChasingArrows_AC::Animate()
{
	// Draw the next animation step.

	EraseBackground();

	fAnimationIndex = (fAnimationIndex + 1) % kNumAnimationSteps;
	
	DrawAnimationStep();
}

//----------------------------------------------------------------------------------------
// CChasingArrows_AC::CChasingArrows_AC
//----------------------------------------------------------------------------------------

void CChasingArrows_AC::Idle()
{
	// Draw the next animation step if enough time has elapsed since the
	// last animation step.
	
	SInt32	now = ::TickCount();
	
	if (now > fLastAnimationTime + kAnimationDelay)
	{
		fLastAnimationTime = now;
		Animate();
	}
}

//----------------------------------------------------------------------------------------
// CChasingArrows_AC::EraseBackground
//----------------------------------------------------------------------------------------

void CChasingArrows_AC::EraseBackground()
{
	//CTempDrawingEnvironment_AC env;

	CRGBColor_AC backColor;
	backColor.GetBackColor();	
	CTempForeColor_AC tempForeColor(backColor);

	for (CGDIterator_AC iter; iter; ++iter)
	{
		//if (iter->IsDeep())
		//	ApplyBackgroundColor();
		//else
		//	kRGBColorRamp[rW].SetForeColor();

		(void) ::PlotIconID(&fBounds, atNone, ttNone, kChasingArrowsEraseBase + fAnimationIndex);
	}
}

//----------------------------------------------------------------------------------------
// CChasingArrows_AC::DrawAnimationStep
//----------------------------------------------------------------------------------------

void CChasingArrows_AC::DrawAnimationStep()
{
	CTempDrawingEnvironment_AC env;

	fAnimating = true;

	for (CGDIterator_AC iter; iter; ++iter)
	{
		AGASetThemePen(kThemeChasingArrowsBrush, iter->Depth(), iter->IsColor());

		(void) ::PlotIconID(&fBounds, atNone, ttNone, kChasingArrowsIconBase + fAnimationIndex);
	}
}


#endif // qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of CChasingArrows_AC.cpp
