//----------------------------------------------------------------------------------------
// CIconButton_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/04/00	Conditional on qEmulateStandardControls
		06/01/00	Add menuID to CPopup_AC ctor call.
		03/24/99	Update copyright notice.
*/

#ifndef __CIconButton_AC__
#include "CIconButton_AC.h"
#endif

#if qEmulateStandardControls

// ACS

#ifndef __AGA_AC__
#include "AGA_AC.h"
#endif

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif


//========================================================================================
// MIcon_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// MIcon_AC::MIcon_AC
//----------------------------------------------------------------------------------------


MIcon_AC::MIcon_AC(SInt16 offIconID, SInt16 onIconID, ButtonFrameType frameType, ControlContentType imageType) :
	fOffIconID(offIconID),
	fOnIconID(onIconID),
	fFrameType(frameType),
	fImageType(imageType)
{
	// Construct with specified icon IDs.
}

//----------------------------------------------------------------------------------------
// MIcon_AC::~MIcon_AC
//----------------------------------------------------------------------------------------

MIcon_AC::~MIcon_AC()
{
}

//----------------------------------------------------------------------------------------
// MIcon_AC::SetIconIDs
//----------------------------------------------------------------------------------------

void MIcon_AC::SetIconIDs(SInt16 offIconID, SInt16 onIconID)
{
	// Set icon IDs as specified.

	fOffIconID = offIconID;
	fOnIconID = onIconID;
}

//----------------------------------------------------------------------------------------
// MIcon_AC::SetFrameType
//----------------------------------------------------------------------------------------

void MIcon_AC::SetFrameType(ButtonFrameType frameType)
{
	// Set button frame type as specified.

	fFrameType = frameType;
}

//----------------------------------------------------------------------------------------
// MIcon_AC::SetImageType
//----------------------------------------------------------------------------------------

void MIcon_AC::SetImageType(ControlContentType imageType)
{
	// Set buttom image type as specified.

	fImageType = imageType;
}

//----------------------------------------------------------------------------------------
// MIcon_AC::DrawIconButton
//----------------------------------------------------------------------------------------

void MIcon_AC::DrawIconButton(const CRect_AC& bounds,
										bool isOn,
										bool isPressed,
										bool isActive,
										bool deep)
{
	// Draw the icon button in the appropriate state.

	CRect_AC	r(bounds);
	
	//
	// Draw the blank button with the appropriate frame type.
	//
	
	AGADrawBevelButtonAtDepth(deep, bounds, fFrameType, isOn, isPressed, isActive);

	//
	// Determine the target area into which the image must
	// be drawn.
	//

	CPoint_AC		imageSize;
	CPoint_AC		imageCenter;
	SInt16			imageResourceID = isOn ? fOnIconID : fOffIconID;
	PicHandle		pictureHandle;
	CIconHandle		colorIconHandle;
	
	imageCenter.h = r.left + ((r.right - r.left) / 2);
	imageCenter.v = r.top + ((r.bottom - r.top) / 2);

	switch (fImageType)
	{
		case kControlContentPictRes:
			pictureHandle = GetPictureImage(imageSize, imageResourceID);
			break;

		case kControlContentCIconRes:
			colorIconHandle = GetColorIconImage(imageSize, imageResourceID);
			break;

		case kControlContentIconSuiteRes:
			imageSize = MIcon_AC::GetIconSuiteImageSize(r.right - r.left);
			break;
			
		default:
			// ??? all the types we support?
			break;
	}
	
	r.left = imageCenter.h - (imageSize.h / 2);
	r.right = r.left + imageSize.h;
	r.top = imageCenter.v - (imageSize.v / 2);
	r.bottom = r.top + imageSize.v;

	//
	// Draw the image onto the blank button.
	//

	IconTransformType	aTransform = isPressed ? ttSelected : (isActive ? ttNone : ttDisabled);

	if (imageResourceID != kNoIconID)
	{
		kRGBColorRamp[rB].SetForeColor();

		switch (fImageType)
		{
			case kControlContentPictRes:
				if (pictureHandle != NULL)
				{
					::DrawPicture(pictureHandle, &r);
					// The PicHandle is not explicitly released. Just let it get purged as needed.
				}
				break;

			case kControlContentCIconRes:
				if (colorIconHandle != NULL)
				{
					(void) ::PlotCIconHandle(&r, atNone, aTransform, colorIconHandle);
					::DisposeCIcon(colorIconHandle);
				}
				break;

			case kControlContentIconSuiteRes:

				(void) ::PlotIconID(&r, atNone, aTransform, imageResourceID);
				break;

			default:
				break;
		}
	}
}

//----------------------------------------------------------------------------------------
// MIcon_AC::GetPictureImage
//----------------------------------------------------------------------------------------

PicHandle MIcon_AC::GetPictureImage(CPoint_AC& imageSize, SInt16 pictureResourceID)
{
	PicHandle	pictureHandle = ::GetPicture(pictureResourceID);
					
	if (pictureHandle != NULL)
	{
		CRect_AC	frame((**pictureHandle).picFrame);

		imageSize.Set(frame.right - frame.left, frame.bottom - frame.top);
	}

	return pictureHandle;
}

//----------------------------------------------------------------------------------------
// MIcon_AC::GetColorIconImage
//----------------------------------------------------------------------------------------

CIconHandle MIcon_AC::GetColorIconImage(CPoint_AC& imageSize, SInt16 cicnResourceID)
{
	CIconHandle	colorIconHandle = ::GetCIcon(cicnResourceID);
					
	if (colorIconHandle != NULL)
	{
		CRect_AC	frame((**colorIconHandle).iconBMap.bounds);

		imageSize.Set(frame.right - frame.left, frame.bottom - frame.top);
	}

	return colorIconHandle;
}

//----------------------------------------------------------------------------------------
// MIcon_AC::GetIconSuiteImageSize
//----------------------------------------------------------------------------------------

CPoint_AC MIcon_AC::GetIconSuiteImageSize(SInt16 buttonWidth)
{
	CPoint_AC imageSize;
	if (buttonWidth > 39)
		imageSize.Set(32, 32);		// 32x32 icl#
	else if (buttonWidth > 21)
		imageSize.Set(16, 16);		// 16x16 ics#
	else
		imageSize.Set(16, 12);		// 16x12 icm#

	return imageSize;
}

//----------------------------------------------------------------------------------------
// MIcon_AC::SetButtonData
//----------------------------------------------------------------------------------------

void MIcon_AC::SetButtonData(ResType inTagName,
								 	Size inSize, Ptr inData)
{
	switch (inTagName)
	{
		case kControlBevelButtonContentTag:
			if (inSize == sizeof(ControlButtonContentInfo))
			{
				ControlButtonContentInfo* info = (ControlButtonContentInfo*) inData;
				switch (info->contentType)
				{
					case kControlContentIconSuiteRes:
					case kControlContentCIconRes:
					case kControlContentPictRes:
						SetIconIDs(info->u.resID, info->u.resID);
						break;
					default:
						break;
				}
			}
			break;
			
		default:
			break;
	}
}

//========================================================================================
// CIconButton_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CIconButton_AC::CIconButton_AC
//----------------------------------------------------------------------------------------

CIconButton_AC::CIconButton_AC(const CRect_AC& bounds, bool isActive, SInt16 iconID, ButtonFrameType frameType, ControlContentType imageType)
: CButton_AC(bounds, isActive), 
  MIcon_AC(iconID, iconID, frameType, imageType)
{
	// Just call through to mixed in constructors.
}

//----------------------------------------------------------------------------------------
// CIconButton_AC::~CIconButton_AC
//----------------------------------------------------------------------------------------

CIconButton_AC::~CIconButton_AC()
{
}

//----------------------------------------------------------------------------------------
// CIconButton_AC::SetData
//----------------------------------------------------------------------------------------

void CIconButton_AC::SetData(ControlPartCode /*inPart*/, ResType inTagName,
								 	Size inSize, Ptr inData)
{
	MIcon_AC::SetButtonData(inTagName, inSize, inData);
}

//----------------------------------------------------------------------------------------
// CIconButton_AC::DrawButtonNormal
//----------------------------------------------------------------------------------------

void CIconButton_AC::DrawButtonNormal(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), false, kNotHilited, kActive, deep);
}

//----------------------------------------------------------------------------------------
// CIconButton_AC::DrawButtonPressed
//----------------------------------------------------------------------------------------

void CIconButton_AC::DrawButtonPressed(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), false, kHilited, kActive, deep);
}

//----------------------------------------------------------------------------------------
// CIconButton_AC::DrawButtonDisabled
//----------------------------------------------------------------------------------------

void CIconButton_AC::DrawButtonDisabled(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), false, kNotHilited, kInactive, deep);
}

//========================================================================================
// CIconCheckBox_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CIconCheckBox_AC::CIconCheckBox_AC
//----------------------------------------------------------------------------------------

CIconCheckBox_AC::CIconCheckBox_AC(const CRect_AC& bounds, bool isActive, 
									bool automaticState, 
									SInt16 itsValue,
									SInt16 offIconID, SInt16 onIconID, 
									ButtonFrameType frameType, ControlContentType imageType)
: CCheckBox_AC(bounds, isActive, kEmptyString_AC, CTextStyle_AC::kSystemStyle, itsValue, automaticState), 
  MIcon_AC(offIconID, onIconID, frameType, imageType)
{
	// Just call through to mixed in constructors.
}

//----------------------------------------------------------------------------------------
// CIconCheckBox_AC::~CIconCheckBox_AC
//----------------------------------------------------------------------------------------

CIconCheckBox_AC::~CIconCheckBox_AC()
{
}

//----------------------------------------------------------------------------------------
// CIconCheckBox_AC::SetData
//----------------------------------------------------------------------------------------

void CIconCheckBox_AC::SetData(ControlPartCode /*inPart*/, ResType inTagName,
								 	Size inSize, Ptr inData)
{
	MIcon_AC::SetButtonData(inTagName, inSize, inData);
}

//----------------------------------------------------------------------------------------
// CIconCheckBox_AC::DrawButtonNormal
//----------------------------------------------------------------------------------------

void CIconCheckBox_AC::DrawButtonNormal(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), fValue != kControlCheckBoxUncheckedValue, kNotHilited, kActive, deep);
}

//----------------------------------------------------------------------------------------
// CIconCheckBox_AC::DrawButtonPressed
//----------------------------------------------------------------------------------------

void CIconCheckBox_AC::DrawButtonPressed(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), fValue != kControlCheckBoxUncheckedValue, kHilited, kActive, deep);
}

//----------------------------------------------------------------------------------------
// CIconCheckBox_AC::DrawButtonDisabled
//----------------------------------------------------------------------------------------

void CIconCheckBox_AC::DrawButtonDisabled(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), fValue != kControlCheckBoxUncheckedValue, kNotHilited, kInactive, deep);
}

//========================================================================================
// CIconRadioButton_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CIconRadioButton_AC::CIconRadioButton_AC
//----------------------------------------------------------------------------------------

CIconRadioButton_AC::CIconRadioButton_AC(const CRect_AC& bounds, bool isActive,
										 UInt32 groupIDPart1, UInt32 groupIDPart2, 
										 bool automaticState, 
										 SInt16 itsValue,
										 SInt16 offIconID, SInt16 onIconID, 
										 ButtonFrameType frameType, ControlContentType imageType)
: CRadioButton_AC(bounds, isActive, kEmptyString_AC, CTextStyle_AC::kSystemStyle, itsValue, groupIDPart1, groupIDPart2, automaticState), 
  MIcon_AC(offIconID, onIconID, frameType, imageType)
{
	// Just call through to mixed in constructors.
}

//----------------------------------------------------------------------------------------
// CIconRadioButton_AC::~CIconRadioButton_AC
//----------------------------------------------------------------------------------------

CIconRadioButton_AC::~CIconRadioButton_AC()
{
}

//----------------------------------------------------------------------------------------
// CIconRadioButton_AC::SetData
//----------------------------------------------------------------------------------------

void CIconRadioButton_AC::SetData(ControlPartCode /*inPart*/, ResType inTagName,
								 	Size inSize, Ptr inData)
{
	MIcon_AC::SetButtonData(inTagName, inSize, inData);
}

//----------------------------------------------------------------------------------------
// CIconRadioButton_AC::DrawButtonNormal
//----------------------------------------------------------------------------------------

void CIconRadioButton_AC::DrawButtonNormal(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), fValue != kControlCheckBoxUncheckedValue, kNotHilited, kActive, deep);
}

//----------------------------------------------------------------------------------------
// CIconRadioButton_AC::DrawButtonPressed
//----------------------------------------------------------------------------------------

void CIconRadioButton_AC::DrawButtonPressed(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), fValue != kControlCheckBoxUncheckedValue, kHilited, kActive, deep);
}

//----------------------------------------------------------------------------------------
// CIconRadioButton_AC::DrawButtonDisabled
//----------------------------------------------------------------------------------------

void CIconRadioButton_AC::DrawButtonDisabled(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), fValue != kControlCheckBoxUncheckedValue, kNotHilited, kInactive, deep);
}

//========================================================================================
// CIconPopup_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CIconPopup_AC::CIconPopup_AC
//----------------------------------------------------------------------------------------

CIconPopup_AC::CIconPopup_AC(const CRect_AC& bounds, bool isActive, MenuRef itsMenuRef, 
					const CTextStyle_AC& itsTextStyle, 
					DisposalKind menuRefDisposalKind, RefHandling refHandling, 
					SInt16 offIconID, SInt16 onIconID, 
					SInt16 itsCurrentItem,
					ButtonFrameType frameType, ControlContentType imageType)
: CPopup_AC(bounds, isActive, kEmptyString_AC, CTextStyle_AC::kSystemStyle, 0, teJustLeft,
			itsTextStyle, kFixedWidth, itsCurrentItem, 0, itsMenuRef, menuRefDisposalKind, refHandling), 
  MIcon_AC(offIconID, onIconID, frameType, imageType)
{
	// Just call through to mixed in constructors.
}

//----------------------------------------------------------------------------------------
// CIconPopup_AC::~CIconPopup_AC
//----------------------------------------------------------------------------------------

CIconPopup_AC::~CIconPopup_AC()
{
}

//----------------------------------------------------------------------------------------
// CIconPopup_AC::SetData
//----------------------------------------------------------------------------------------

void CIconPopup_AC::SetData(ControlPartCode inPart, ResType inTagName,
								 	Size inSize, Ptr inData)
{
	// Give both base classes a crack at setting data.
	CPopup_AC::SetData(inPart, inTagName, inSize, inData);
	MIcon_AC::SetButtonData(inTagName, inSize, inData);
}

//----------------------------------------------------------------------------------------
// CIconPopup_AC::DrawButtonNormal
//----------------------------------------------------------------------------------------

void CIconPopup_AC::DrawButtonNormal(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), false, kNotHilited, kActive, deep);
	DrawMiniArrow(deep);
}

//----------------------------------------------------------------------------------------
// CIconPopup_AC::DrawButtonPressed
//----------------------------------------------------------------------------------------

void CIconPopup_AC::DrawButtonPressed(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), false, kHilited, kActive, deep);
	DrawMiniArrow(deep);
}

//----------------------------------------------------------------------------------------
// CIconPopup_AC::DrawButtonDisabled
//----------------------------------------------------------------------------------------

void CIconPopup_AC::DrawButtonDisabled(bool deep)
{
	// Call icon button parent class with appropriate parameters.

	MIcon_AC::DrawIconButton(GetBounds(), false, kNotHilited, kInactive, deep);
	DrawMiniArrow(deep);
}

//----------------------------------------------------------------------------------------
// CIconPopup_AC::DrawMiniArrow
//----------------------------------------------------------------------------------------

void CIconPopup_AC::DrawMiniArrow(bool /*deep*/)
{
	// Add arrow.  Arrow size is 5x3 pixels near the bottom right corner:
	//
	//											     X
	//										XXXXX    X
	//										 XXX     X
	//										  X      X
	//											     X
	//											     X
	//											     X
	//									XXXXXXXXXXXXX
	
	CPoint_AC arrowPt(GetBounds()[botRight]);
	arrowPt.v -= 7;
	arrowPt.h -= 9;
	
	if (IsActive())
		kRGBColorRamp[rB].SetForeColor();
	else
		kRGBColorRamp[r5].SetForeColor();
	
	::MoveTo(arrowPt.h, arrowPt.v);
	::MacLineTo(arrowPt.h + 4, arrowPt.v);
	::Move(-1, 1);
	::MacLineTo(arrowPt.h + 1, arrowPt.v + 1);
	::Move(1, 1);
	::Line(0, 0);
}


#endif // qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of CIconButton_AC.cpp
