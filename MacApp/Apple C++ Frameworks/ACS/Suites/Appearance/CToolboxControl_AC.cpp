//----------------------------------------------------------------------------------------
// CToolboxControl_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/07/01	Comment out pragma messages for Carbon. 
		04/07/01	[PB] Unused variable 'OSErr anErr'. 
		03/01/01	Don't include Windows_AC. 
		01/11/01	SetControlFontStyle requires Appearance. 
		01/02/01	Update copyright.
		12/21/00	Use DEFINE_API for implementing callbacks. 
		12/12/00	Added SetFontStyle.
		11/27/00	Have to conditionalize that cast in SendMessage based on
					UNIVERSAL_INTERFACES_VERSION.
		11/27/00	Cast inParam to void* in SendMessage.
		11/14/00	[W] TrackMouse returns kControlNoPart.  SetActionHandler does
					nothing.  GetActionHandler returns null.
		11/09/00	[PB] Suppress GCC warnings about unused return variables. 
					CFString title functions require the 3.3.5 interfaces. 
					So do Set/GetCommandID. 
					Need to include CFBase to get CFStringRef. 
		11/09/00	ControlColorProc is not available before the 3.3.5 interfaces. 
		11/08/00	Don’t call ValidateControl_AC in GetHandler unless qCoreDebug.
		11/06/00	Organize CControl_AC methods so they match <Controls.h>. 
					Add a CToolboxControl_AC constructor and CreateControlRef
					method for creating a custom control (Carbon only). 
					Add a version of GetBestBounds that returns the baseline offset. 
					Add SetColorHandler and SetColorProc, SetKeyFilterHandler, 
					SetKeyFilter and GetKeyFilter, SetAction and GetAction, 
					SetReference and GetReference, GetRegion. 
					Add HandleSetCursor. 
					Add CFStringRef versions of CopyTitle and SetTitle. 
					Move SetViewSize and GetViewSize here from CToolboxIndicator_AC. 
					Add SetID, GetID, SetCommandID, and GetCommandID (Carbon only). 
					Add GetProperty, GetPropertySize, SetProperty, RemoveProperty,
					GetPropertyAttributes and ChangePropertyAttributes. 
					Make InstallColor and ChangeColorTable available for Classic Mac only. 
					Add SendMessage and GetRootControl, AutoEmbed, GetParent,
					CountChildren, GetIndexedChild and SetSupervisor. 
					Add GetKeyboardFocus and ClearKeyboardFocus. 
					Make SetData, GetData and GetDataSize public. 
					Add HandleDragTracking, HandleDragReceive, SetDragTrackingEnabled 
					and IsDragTrackingEnabled. 
					Allow BeInPort, SetWindowRef, RemoveFromWindowControlList, and 
					AddToWindowControlList only if not on Carbon. 
					Add Carbon case to DrawControl that doesn't need to check for
					the Appearance Manager and doesn't try to move the control to
					a different port. 
					Add GetHandler, ToolboxControlKeyFilter and ToolboxControlColor. 
		10/03/00	Make it easier to see return values when debugging. 
					In SetVisibility, don't change the control state if it's already visible. 
		09/21/00	[W] Can’t call GetNewControl in CreateControlRef.
		09/20/00	Disable hack in CToolboxControl_AC::DrawControl. 
		09/18/00	Catch all exceptions in ToolboxControlAction. 
		09/13/00	Carbon: CToolboxControl_AC::DrawControl: Carbon seems to draw beyond
					the current clip region in all directions, especially vertically for
					buttons.  The fix widens the current clip region for all controls.
		09/01/00	Stripped dead code.  Use pragma message instead of warning.
		08/15/00	Add a convenience macro for generating temp UPP classes. 
		07/31/00	[W] GetVariant now always returns 0.
		07/06/00	Added EmbedControl and CanEmbed.  Cosmetic cleanup.
		01/13/00	itsNewControlOwner is unused in SetWindowRef.
		12/08/99	CToolboxControl_AC::Idle(): Change using IdleControl to SendControlMessage
					with an idle message, as this works both with Carbon and non-Carbon enivronments.
		10/13/99	Carbon: SetControlColor not in Carbon (CToolboxControl_AC::InstallColor).
		10/07/99	Use TemplateTempUPP_AC instead of TmplTmpRtnDescrptr.
		10/06/99	Add '::' to IsControlHilited.
		09/23/99	Carbon: change #warning to #pragma message
		09/22/99	Carbon:Convert TmplTmpRtnDescrptr to TmplTmpOpaqueRtnDescrptr.
		09/20/99	Carbon:GetControlColorTable, SetControlOwner, SetWindowControlList no longer in Carbon?
		08/17/99	Appearance 1.1 calls are PPC only. 
		07/27/99	Removed qAllegro test in SetupBackground.
		07/22/99	[C] Do not treat a control as a handle in various functions.  Cleaned
					out some control list management in Idle.
		04/15/99	Change #warning to #pragma message.
		03/24/99	Update copyright notice.
		03/10/99	[W] Added pragma unused in AssureRootControl.
		12/16/98	[W] Can't make Appearance calls in DrawControl, TrackMouse,
					SetKeyboardFocus, HandleKeyDown, SetActive, IsVisible, SetVisibility,
					SetupBackground, InstallColor, GetFeatures, SetData, GetData, GetDataSize,
					IsActive and AssureRootControl.  Can't call IdleControls in Idle.
		11/13/98	[2279281] Use qAllegro in place of qPowerPC && (UNIVERSAL_INTERFACES_VERSION >= 0x0320).
		11/06/98	Fix non-ARM compliant cast in RemoveFromWindowControlList and AddToWindowControlList.
		10/28/98	[W] Fix up ChangeColorTable.
		10/23/98	Carbonized
		10/06/98	Clean up includes. 
*/

#ifndef __CToolboxControl_AC__
#include "CToolboxControl_AC.h"
#endif

// ACS

#ifndef __AppearanceUtils_AC__
#include "AppearanceUtils_AC.h"
#endif

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __ImagingUtils_AC__
#include "ImagingUtils_AC.h"
#endif

#ifndef __TemplateUPP_AC__
#include "TemplateUPP_AC.h"
#endif

#ifndef __Utils_AC__
#include "Utils_AC.h"
#endif

#ifndef __WindowUtils_AC__
#include "WindowUtils_AC.h"
#endif

// Toolbox

#ifndef __APPEARANCE__
#include <Appearance.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#ifndef __MACWINDOWS__
#include <MacWindows.h>
#endif


//========================================================================================
// GLOBALS 
//========================================================================================

#if !qMSWindows
CTempControlActionUPP CToolboxControl_AC::ToolboxControlActionUPP(ToolboxControlAction);
#endif

const ControlActionUPP CToolboxControl_AC::DefaultControlActionUPP = ControlActionUPP(-1);
const ControlActionUPP CToolboxControl_AC::NULLControlActionUPP = ControlActionUPP(NULL);

//----------------------------------------------------------------------------------------
// WarnIf32BitValue
//----------------------------------------------------------------------------------------

#if qCoreDebug
static void WarnIf32BitValue(SInt32 itsValue)
// Offers a warning that the control should derive from CToolboxIndicator so that 
// 32-bit values can be properly handled.
{
	if (itsValue > SHRT_MAX)
		ProgramBreak_AC("Attempting to set 32-bit value. Subclass from CToolboxIndicator_AC to avoid casting to 16 bits.");
}
#else
inline void WarnIf32BitValue(SInt32 /*itsValue*/) {}
#endif

#if qCoreDebug
//----------------------------------------------------------------------------------------
// ValidateControl_AC
//----------------------------------------------------------------------------------------

bool ValidateControl_AC(const ControlRef control)
{
	bool valid = true;

	//	Check the handle itself
	if (!VerboseIsHandle_AC((Handle)control))
		valid = false;
	//	Validate the fields of this control.
	//	NOTE: This code will be dangerous in the future with 32 bit control values
	//	and opaque ControlRefs.

	//	the next control in the Window's control list
#if !qCarbon
	if ((*control)->nextControl
		&& !VerboseIsHandle_AC((Handle)(*control)->nextControl))
		valid = false;
#elif 0
	// The following does not work for Carbon.
	ControlHandle nextControl = ::GetNextControl(control);
	if (nextControl
		&& !VerboseIsHandle_AC((Handle)nextControl))
		valid = false;
#endif

	//	Validate the window containing the control.
#if !qCarbon
	if (!ValidateWindow_AC((*control)->contrlOwner))
#else
	if (!ValidateWindow_AC(::GetControlOwner(control)))
#endif
		valid = false;

	//	Validate the control's data.
#if 0
	// ••• Sliders seem to have null data here.
	if (!VerboseIsHandle_AC((*control)->contrlData))
		valid = false;
#endif

	return valid;
}
#endif // qCodeDebug


//========================================================================================
// CToolboxControl_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CToolboxControl_AC::CToolboxControl_AC(ControlRef theControl)
	:	fControl(theControl)
{
}

#if qCarbon
//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CToolboxControl_AC::CToolboxControl_AC(WindowRef owningWindow,
									   const CRect_AC& contBounds,
									   const CControlDefSpec_AC& def,
									   Collection initData)
	:	fControl(NULL)
{
	CreateControlRef(owningWindow, contBounds, def, initData);
}
#endif

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CToolboxControl_AC::CToolboxControl_AC(WindowRef owningWindow,
									   SInt16 controlType, 
									   const CRect_AC& boundsRect, 
									   const CStr255_AC& itsTitle, 
									   bool isVisible,
									   bool isActive, 
									   SInt16 itsValue,
									   SInt16 itsMin,
									   SInt16 itsMax, 
									   MControlHandler_AC* actionHandler)
	:	fControl(NULL)
{
	CreateControlRef(owningWindow, controlType, boundsRect, itsTitle, isVisible, isActive, 
					 itsValue, itsMin, itsMax, reinterpret_cast<long>(actionHandler));
}

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

CToolboxControl_AC::CToolboxControl_AC(SInt16 resourceID, WindowRef owningWindow)
	:	fControl(NULL)
{
	CreateControlRef(resourceID, owningWindow);
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

CToolboxControl_AC::~CToolboxControl_AC()
{
	DeleteControlRef();
}

#if qCarbon
//----------------------------------------------------------------------------------------
// CreateControlRef
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::CreateControlRef(WindowRef owningWindow,
										  const CRect_AC& contBounds,
										  const ControlDefSpec& def,
										  Collection initData)
{
	::Assertion_AC(owningWindow != NULL, "In Create, the owningWindow is NULL.");
	ValidateWindow_AC(owningWindow);

	if (!fControl)
	{
		AssureRootControl(owningWindow);	
		::ThrowIfOSErr_AC(CreateCustomControl(owningWindow, &contBounds, &def, initData, &fControl));
		::ThrowIfNULL_AC(fControl);
	}
}	
#endif

//----------------------------------------------------------------------------------------
// CreateControlRef
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::CreateControlRef(SInt16 resourceID, WindowRef owningWindow)
{
#if !_MSC_VER
	::Assertion_AC(owningWindow != NULL, "In CreateControlRef, the WindowRef parameter is NULL.");
	ValidateWindow_AC(owningWindow);

	if (!fControl)
	{
		AssureRootControl(owningWindow);
		fControl = ::GetNewControl(resourceID, owningWindow);
		::ThrowIfNULL_AC(fControl);
	}
#else
	#pragma message ("CToolboxControl_AC::CreateControlRef: Implementation needed.")
#endif
}

//----------------------------------------------------------------------------------------
// CreateControlRef
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::CreateControlRef(WindowRef owningWindow,
										  SInt16 controlType, 
										  const CRect_AC& boundsRect, 
										  const CStr255_AC& itsTitle, 
										  bool isVisible,
										  bool isActive, 
										  SInt16 itsValue,
										  SInt16 itsMin,
										  SInt16 itsMax, 
										  long refCon)
{
	::Assertion_AC(owningWindow != NULL, "In CreateControlRef, the WindowRef parameter is NULL.");
	ValidateWindow_AC(owningWindow);

	if (!fControl)
	{
		AssureRootControl(owningWindow);
		fControl = ::NewControl(owningWindow, boundsRect, itsTitle, isVisible, 
								itsValue, itsMin, itsMax, controlType, refCon);
		::ThrowIfNULL_AC(fControl);
		SetActive(isActive);
	}
}

//----------------------------------------------------------------------------------------
// DeleteControlRef
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::DeleteControlRef()
{
	if (fControl)
	{
		SetVisibility(false);               // This ensures that HideControl, which
                                            // will be called by SizeControl, doesn't
                                            // do anything. HideControl seems to have
                                            // some problems with large (~> 14000x14000) controls.
		SetSize(CPoint_AC::kZeroPt);		// Prevent CMgr from erasing the control!
		ValidateControlRef();
		::DisposeControl(fControl);
		fControl = NULL;
	}
}

//----------------------------------------------------------------------------------------
// IsPartHilited
//----------------------------------------------------------------------------------------

bool CToolboxControl_AC::IsPartHilited(ControlPartCode part) const
{
	bool isHilited = false;
	ValidateControlRef();
	if (fControl)
	{
#if qCarbon
		#pragma unused (part)
		// •••  No access to contrlHilite in Carbon; hopefully this does the same thing...
		isHilited = ::IsControlHilited(fControl);
#else
		isHilited = (*fControl)->contrlHilite == part;
#endif
	}
	return isHilited;
}

//----------------------------------------------------------------------------------------
// SetPartHilite
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetPartHilite(ControlPartCode part, bool isHilited)
{
	if (fControl)
	{
		ValidateControlRef();
		::HiliteControl(fControl, isHilited ? part : kControlNoPart);
	}
}

//----------------------------------------------------------------------------------------
// Show
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::Show(bool doShow)
{
	ValidateControlRef();
	if (fControl)
	{
		if (doShow)
			::ShowControl(fControl);
		else
			::HideControl(fControl);
	}
}
	
//----------------------------------------------------------------------------------------
// IsActive
//----------------------------------------------------------------------------------------

bool CToolboxControl_AC::IsActive() const
{
	bool isActive = false;
	if (fControl)
	{
		ValidateControlRef();
#if qMSWindows
		isActive = ((*fControl)->contrlHilite != kControlInactivePart);
#else		
		if (::HasAppearanceMgr_AC())
			isActive = ::IsControlActive(fControl);
#if !qCarbon
// Carbon always has Appearance Mgr
		else
			isActive = ((*fControl)->contrlHilite != kControlInactivePart);
#endif
#endif
	}

	return isActive;
}

//----------------------------------------------------------------------------------------
// SetActive
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetActive(bool isActive)
{
	if (fControl && isActive != IsActive())
	{
		ValidateControlRef();
#if !qMSWindows
		if (::HasAppearanceMgr_AC())
		{
			if (isActive)
				(void) ::ActivateControl(fControl);
			else
				(void) ::DeactivateControl(fControl);
		}
		else
#endif
			::HiliteControl(fControl, isActive ? 0 : kControlInactivePart);
	}
}

//----------------------------------------------------------------------------------------
// IsVisible
//----------------------------------------------------------------------------------------

bool CToolboxControl_AC::IsVisible() const
{
	bool isVisible = false;
	ValidateControlRef();

	if (fControl)

#if qMSWindows
		isVisible = (*fControl)->contrlVis == kVisible;
#else
		if (::HasAppearanceMgr_AC())
			isVisible = ::IsControlVisible(fControl);
#if !qCarbon
// Carbon always has Appearance Mgr
		else
			isVisible = (*fControl)->contrlVis == kVisible;
#endif
#endif	
	return isVisible;
}

//----------------------------------------------------------------------------------------
// SetVisibility
//----------------------------------------------------------------------------------------

bool CToolboxControl_AC::SetVisibility(bool beVisible)
{
	bool wasVisible = IsVisible();

	if (fControl && (wasVisible != beVisible))
	{
		ValidateControlRef();
#if qMSWindows
		(*fControl)->contrlVis = beVisible ? kVisible : kNotVisible;
#else
#if !qCarbon
// Carbon always has Appearance Mgr
		if (!::HasAppearanceMgr_AC())
			(*fControl)->contrlVis = beVisible ? kVisible : kNotVisible;
		else
#endif
			::SetControlVisibility(fControl, beVisible, false /* do not redraw */);
#endif
	}
	return wasVisible;
}

//----------------------------------------------------------------------------------------
// DrawControl
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::DrawControl()
{
	if (fControl)
	{
		PenNormal();
		ValidateControlRef();
#if qCarbon
		::DrawControlInCurrentPort(fControl);
#else
#if !qMSWindows
		if (::HasAppearanceMgr_AC())
		{
			::DrawControlInCurrentPort(fControl);
		}
		else
#endif
		{
			WindowRef savedOwner = GetWindowRef();
			SetWindowRef(GetWindowFromPort_AC(GetGrafPtr_AC()));
			::Draw1Control(fControl);
			SetWindowRef(savedOwner);
		}
#endif // qCarbon
	}
}

//----------------------------------------------------------------------------------------
// GetBestBounds
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::GetBestBounds(Rect& outRect, SInt16& outBaseLineOffset)
{
	ValidateControlRef();
	outRect = CRect_AC();
	outBaseLineOffset = 0;
	if (HasAppearanceMgr_AC())
		ThrowIfOSErr_AC( GetBestControlRect(fControl, &outRect, &outBaseLineOffset) );
}

//----------------------------------------------------------------------------------------
// SetupBackground
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetupBackground(SInt16 pixelDepth, bool isColor)
{
	ValidateControlRef();
#if qMSWindows
	#pragma unused (pixelDepth, isColor)
#else
	if (fControl && ::HasAppearanceMgr_AC())
	{
		ThrowIfOSErr_AC(::SetUpControlBackground(fControl, pixelDepth, isColor));
#if qPowerPC
		if (AppearanceMgrVersion_AC() >= 0x110)
			ThrowIfOSErr_AC(::SetUpControlTextColor(fControl, pixelDepth, isColor));
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// SetColorHandler
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetColorHandler(MControlHandler_AC* actionHandler)
{
#if UNIVERSAL_INTERFACES_VERSION >= 0x0335
	static CTempControlColorUPP pControlColorUPP;
	if (!pControlColorUPP)
		pControlColorUPP = ToolboxControlColor;

	SetReference(reinterpret_cast<long>(actionHandler));
	SetColorProc(pControlColorUPP);
#else
#pragma unused (actionHandler)
#endif
}

#if UNIVERSAL_INTERFACES_VERSION >= 0x0335
//----------------------------------------------------------------------------------------
// SetColorProc
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetColorProc(ControlColorUPP inProc)
{
	ValidateControlRef();
	ThrowIfOSErr_AC(SetControlColorProc(fControl, inProc) );
}
#endif

//----------------------------------------------------------------------------------------
// CToolboxControl_AC::SetFontStyle
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetFontStyle(const CControlTextStyle_AC& textStyle)
// SetFontStyle sets the Appearance control's text style.  Note that all aspects of the
// style are applied to the control by default.  If you want to only apply certain aspects
// of the style then be sure to set the proper flags in textStyle prior to making
// this call. 
//
// textStyle:	A CControlTextStyle_AC that contains the text style that is to
//				be used for the control.  All aspects of the style are applied.
//
// Call?		As needed.
// Override?	Rarely.  You can override this if you want to control the flags that
//				are allowed to be set for your specific kind of control.
{
#if qAppearance
	if (::HasAppearanceMgr_AC())
	{
		OSErr anErr = ::SetControlFontStyle(fControl, &textStyle);
#if qProjectBuilder
		(void) anErr;
#endif
	}
#else
#pragma unused (textStyle)
#endif
}

//----------------------------------------------------------------------------------------
// TrackMouse
//----------------------------------------------------------------------------------------

ControlPartCode	CToolboxControl_AC::TrackMouse(const CPoint_AC& mouseLocation, SInt16 modifiers)
// Indicators, such as scroll bars, have special requirements for the actionProc.
// This comment is from Universal Headers 3.0 Controls.h:
// HasAppearanceMgr
//	When using the TrackControl() call when tracking an indicator, the actionProc parameter
//	(type ControlActionUPP) should be replaced by a parameter of type DragGrayRgnUPP
//	(see Quickdraw.h).
//	
//	If, however, you are using the live feedback variants of scroll bars or sliders, you
//	can pass a ControlActionUPP in when tracking the indicator as well. This functionality
//	is available in Appearance 1.0 or later.
{
#if !qMSWindows
	ControlActionUPP action;

	switch (TestMouse(mouseLocation))
	{
		// Scroll bar parts:
		case kControlUpButtonPart:
		case kControlDownButtonPart:
		case kControlPageUpPart:
		case kControlPageDownPart:
			action = ToolboxControlActionUPP;		// Explicitly use callback 
			break;
			
		// Thumb/indicator part:
		case kControlIndicatorPart:		
			if (GetFeatures() & kControlSupportsLiveFeedback)
				action = ToolboxControlActionUPP; 	// Explicitly use callback	
			else
				action = NULLControlActionUPP; 		// perform ghosting
			break;
			
		default:
			action = DefaultControlActionUPP;		// Use whatever has been supplied via SetActionHandler
	}
	
	ValidateControlRef();
	ControlPartCode partHit = kControlNoPart;
#if qMSWindows
	#pragma unused (modifiers)
#else
	if (::HasAppearanceMgr_AC())
		partHit = ::HandleControlClick(fControl, mouseLocation, modifiers, action);
	else
#endif
		partHit = ::TrackControl(fControl, mouseLocation, action);
	
	return partHit;
#else
	#pragma unused (mouseLocation, modifiers)
	return kControlNoPart;
#endif
}

//----------------------------------------------------------------------------------------
// TestMouse
//----------------------------------------------------------------------------------------

ControlPartCode CToolboxControl_AC::TestMouse(const CPoint_AC& mouseLocation) const
{
	ControlPartCode partHit = kControlNoPart;
	ValidateControlRef();
	if (fControl)
	{
#if qMSWindows
		#pragma unused (mouseLocation)
		#pragma message ("CToolboxControl_AC::TestMouse: We MUST implement the equivalent of TestControl!")
#else
		partHit = ::TestControl(fControl, mouseLocation);
#endif
	}
	return partHit;
}

//----------------------------------------------------------------------------------------
// HandleKeyDown
//----------------------------------------------------------------------------------------

SInt16 CToolboxControl_AC::HandleKeyDown(SInt16 inKeyCode, SInt16 inCharCode, SInt16 inModifiers)
{
	SInt16 partHit = kControlNoPart;
	ValidateControlRef();
	if (fControl)
	{
#if qMSWindows
		#pragma unused (inKeyCode, inCharCode, inModifiers)
#else
		if (::HasAppearanceMgr_AC())
			partHit = ::HandleControlKey(fControl, inKeyCode, inCharCode, inModifiers);
#endif
	}
	return partHit;
}

//----------------------------------------------------------------------------------------
// SetKeyFilterHandler
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetKeyFilterHandler(MControlHandler_AC* actionHandler)
{
	static CTempControlKeyFilterUPP pControlKeyFilterUPP;
	if (!pControlKeyFilterUPP)
		pControlKeyFilterUPP = ToolboxControlKeyFilter;

	SetReference(reinterpret_cast<long>(actionHandler));
	SetKeyFilter(pControlKeyFilterUPP);
}

//----------------------------------------------------------------------------------------
// SetKeyFilter
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetKeyFilter(ControlKeyFilterUPP keyFilterProc)
{
	ValidateControlRef();
	SetData(kControlNoPart, kControlKeyFilterTag, sizeof(keyFilterProc), 
			reinterpret_cast<Ptr>(&keyFilterProc));
}

//----------------------------------------------------------------------------------------
// GetKeyFilter
//----------------------------------------------------------------------------------------

ControlKeyFilterUPP CToolboxControl_AC::GetKeyFilter()
{
	ValidateControlRef();
	ControlKeyFilterUPP keyFilterProc = NULL;
	GetData(kControlNoPart, kControlKeyFilterTag, sizeof(keyFilterProc), 
			reinterpret_cast<Ptr>(&keyFilterProc));
	return keyFilterProc;
}

//----------------------------------------------------------------------------------------
// Idle
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::Idle()
{
#if qMSWindows
	#pragma message ("CToolboxControl_AC::Idle: IdleControls not supported in Windows.")
#else
	if (fControl)
	{
		ValidateControlRef();
		
		// The old method:
		// The Appearance Manager IdleControls() call handles all controls in a Window
		// and draws as needed. MacApp, however, needs to focus each view before drawing.
		//
		// To avoid idling other controls in the Window, we adjust the
		// linked list of ControlHandles maintained by the WindowRecord.
		// We save the existing control list, set them so that this control
		// is the only one in the list, call IdleControls(), then restore
		// the original control list.
		//
		// The new method:
		// In Carbon, the window list can't be manipulated.  However, SendControlMessage
		// CAN be used to idle a single control.  This message can be used for non-Carbon
		// code, too.  Eventhough this method shouldn't be called unless this control can be
		// idled, it doesn't hurt to double-check with a call to GetControlFeatures.
		//
		UInt32 outFeatures;
		if (::GetControlFeatures(fControl, &outFeatures) == noErr && outFeatures&kControlWantsIdle)
			::SendControlMessage(fControl, kControlMsgIdle, 0);
	}
#endif
}

//----------------------------------------------------------------------------------------
// GetBounds
//----------------------------------------------------------------------------------------

CRect_AC CToolboxControl_AC::GetBounds() const
{
	CRect_AC contrlRect;
	ValidateControlRef();
	if (fControl)
	{
#if !qCarbon
		contrlRect = (*fControl)->contrlRect;
#else
		::GetControlBounds(fControl, &contrlRect);
#endif
	}
	return contrlRect;
}

//----------------------------------------------------------------------------------------
// SetBounds
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetBounds(const CRect_AC& bounds)
{
	if (fControl)
	{
		ValidateControlRef();
		
		CRect_AC oldBounds(GetBounds());
		if (bounds[topLeft] != oldBounds[topLeft])
			::MoveControl(fControl, bounds.left, bounds.top);

		CPoint_AC newSize(bounds.GetSize());
		if (newSize != oldBounds.GetSize())
			::SizeControl(fControl, newSize.h, newSize.v);
	}
}

//----------------------------------------------------------------------------------------
// GetTitle
//----------------------------------------------------------------------------------------

CStr255_AC CToolboxControl_AC::GetTitle() const
{
	CStr255_AC title;
	if (fControl)
	{
		ValidateControlRef();
		::GetControlTitle(fControl, title);
	}

	return title;
}

//----------------------------------------------------------------------------------------
// SetTitle
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetTitle(const CStr255_AC& newTitle)
{
	if (fControl)
	{
		ValidateControlRef();
		::SetControlTitle(fControl, newTitle);
	}
}	

#if qCarbon && (UNIVERSAL_INTERFACES_VERSION >= 0x0335)

//----------------------------------------------------------------------------------------
// CopyTitle
//----------------------------------------------------------------------------------------

CFStringRef CToolboxControl_AC::CopyTitle() const
{
	CFStringRef outString = NULL;
	if (fControl)
	{
		ValidateControlRef();
		ThrowIfOSErr_AC( CopyControlTitleAsCFString(fControl, &outString) );
	}

	return outString;
}

//----------------------------------------------------------------------------------------
// SetTitle
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetTitle(CFStringRef inString)
{
	if (fControl)
	{
		ValidateControlRef();
		ThrowIfOSErr_AC( SetControlTitleWithCFString(fControl, inString) );
	}
}	

#endif // qCarbon

//----------------------------------------------------------------------------------------
// GetValue
//----------------------------------------------------------------------------------------

SInt32 CToolboxControl_AC::GetValue() const
{
	ValidateControlRef();
	SInt32 value = fControl ? ::GetControlValue(fControl) : 0;
	return value;
}

//----------------------------------------------------------------------------------------
// SetValue
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetValue(SInt32 newValue)
{
	if (fControl)
	{
		ValidateControlRef();
		WarnIf32BitValue(newValue);
		
		newValue = MinMax_AC(GetMinimum(), newValue, GetMaximum());

		::SetControlValue(fControl, static_cast<short>(newValue));
	}
}

//----------------------------------------------------------------------------------------
// GetMinimum
//----------------------------------------------------------------------------------------

SInt32 CToolboxControl_AC::GetMinimum() const
{
	ValidateControlRef();
	SInt32 minimum = fControl ? ::GetControlMinimum(fControl) : 0;
	return minimum;
}

//----------------------------------------------------------------------------------------
// SetMinimum
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetMinimum(SInt32 newMin)
{
	if (fControl)
	{
		ValidateControlRef();
		WarnIf32BitValue(newMin);
		
		::SetControlMinimum(fControl, static_cast<short>(newMin));

		// ??? Does the Control Manager do this for us?
		if (GetMinimum() > GetValue()) 
		{
			SetValue(GetMinimum());
		}
	}
}

//----------------------------------------------------------------------------------------
// GetMaximum
//----------------------------------------------------------------------------------------

SInt32 CToolboxControl_AC::GetMaximum() const
{
	ValidateControlRef();
	SInt32 maximum = fControl ? ::GetControlMaximum(fControl) : 0;
	return maximum;
}

//----------------------------------------------------------------------------------------
// SetMaximum
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetMaximum(SInt32 newMax)
{
	if (fControl)
	{
		ValidateControlRef();
		WarnIf32BitValue(newMax);
		::SetControlMaximum(fControl, static_cast<short>(newMax));
		
		// ??? Does the Control Manager do this for us?
		if (GetMaximum() < GetValue()) 
		{
			SetValue(GetMaximum());
		}
	}
}

//----------------------------------------------------------------------------------------
// GetViewSize
//----------------------------------------------------------------------------------------

SInt32 CToolboxControl_AC::GetViewSize() const
{
	SInt32 viewSize = 0;
#if qPowerPC
	if (fControl && AppearanceMgrVersion_AC() >= 0x110)
		viewSize = ::GetControlViewSize(fControl);
#endif
	return viewSize;
}

//----------------------------------------------------------------------------------------
// SetViewSize
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetViewSize(SInt32 newViewSize)
{
#if qPowerPC
	if (fControl && AppearanceMgrVersion_AC() >= 0x110)
		::SetControlViewSize(fControl, newViewSize);
#else
	#pragma unused (newViewSize)
#endif
}

#if qCarbon

//----------------------------------------------------------------------------------------
// SetID
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetID(const ControlID& inID)
{
	ThrowIfOSErr_AC( SetControlID(fControl, &inID) );
}

//----------------------------------------------------------------------------------------
// GetID
//----------------------------------------------------------------------------------------

ControlID CToolboxControl_AC::GetID()
{
	ControlID outID = {0, 0};
	ThrowIfOSErr_AC( GetControlID(fControl, &outID) );
	return outID;
}

#if UNIVERSAL_INTERFACES_VERSION >= 0x0335
//----------------------------------------------------------------------------------------
// SetCommandID
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetCommandID(UInt32 inCommandID)
{
	ThrowIfOSErr_AC( SetControlCommandID(fControl, inCommandID) );
}

//----------------------------------------------------------------------------------------
// GetCommandID
//----------------------------------------------------------------------------------------

UInt32 CToolboxControl_AC::GetCommandID()
{
	UInt32 outCommandID = 0;
	ThrowIfOSErr_AC( GetControlCommandID(fControl, &outCommandID) );
	return outCommandID;
}
#endif // UNIVERSAL_INTERFACES_VERSION >= 0x0335

#endif // qCarbon

//----------------------------------------------------------------------------------------
// GetProperty
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::GetProperty(OSType propertyCreator, OSType propertyTag, UInt32 bufferSize, 
						   UInt32* actualSize, void* propertyBuffer)
{
	ThrowIfOSErr_AC( GetControlProperty(fControl, propertyCreator, propertyTag, bufferSize,
									 actualSize, propertyBuffer) );
}

//----------------------------------------------------------------------------------------
// GetPropertySize
//----------------------------------------------------------------------------------------

UInt32 CToolboxControl_AC::GetPropertySize(OSType propertyCreator, OSType propertyTag)
{
	UInt32 size = 0;
	ThrowIfOSErr_AC( GetControlPropertySize(fControl, propertyCreator, propertyTag, &size) );
	return size;
}

//----------------------------------------------------------------------------------------
// SetProperty
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetProperty(OSType propertyCreator, OSType propertyTag, UInt32 propertySize,
						   void* propertyData)
{
	ThrowIfOSErr_AC( SetControlProperty(fControl, propertyCreator, propertyTag, propertySize,
									 propertyData) );
}

//----------------------------------------------------------------------------------------
// RemoveProperty
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::RemoveProperty(OSType propertyCreator, OSType propertyTag)
{
	ThrowIfOSErr_AC( RemoveControlProperty(fControl, propertyCreator, propertyTag) );

}

//----------------------------------------------------------------------------------------
// GetPropertyAttributes
//----------------------------------------------------------------------------------------

UInt32 CToolboxControl_AC::GetPropertyAttributes(OSType propertyCreator, OSType propertyTag)
{
	UInt32 attributes = 0;
	ThrowIfOSErr_AC( GetControlPropertyAttributes(fControl, propertyCreator, propertyTag,
											   &attributes) );
	return attributes;
}

//----------------------------------------------------------------------------------------
// ChangePropertyAttributes
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::ChangePropertyAttributes(OSType propertyCreator, OSType propertyTag,
										UInt32 attributesToSet, UInt32 attributesToClear)
{
	ThrowIfOSErr_AC( ChangeControlPropertyAttributes(fControl, propertyCreator, propertyTag,
												  attributesToSet, attributesToClear) );
}

//----------------------------------------------------------------------------------------
// GetRegion
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::GetRegion(ControlPartCode inPart, RgnHandle outRegion)
{
	ThrowIfOSErr_AC( GetControlRegion(fControl, inPart, outRegion) );
}

//----------------------------------------------------------------------------------------
// GetVariant
//----------------------------------------------------------------------------------------

SInt16 CToolboxControl_AC::GetVariant() const	// The type is the control variant (read-only)
{
	SInt16 variant = 0;
#if !qMSWindows
	ValidateControlRef();
	if (fControl)
		variant = ::GetControlVariant(fControl);
#endif
	return variant;
}

//----------------------------------------------------------------------------------------
// SetActionHandler
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetActionHandler(MControlHandler_AC* actionHandler)
{
#if !qMSWindows
	if (fControl)
	{
		ValidateControlRef();
		::SetControlReference(fControl, reinterpret_cast<long>(actionHandler));
		::SetControlAction(fControl, ToolboxControlActionUPP);
	}
#else
	#pragma unused (actionHandler)
#endif
}

//----------------------------------------------------------------------------------------
// GetActionHandler
//----------------------------------------------------------------------------------------

MControlHandler_AC* CToolboxControl_AC::GetActionHandler()
{
	MControlHandler_AC* handler = NULL;
#if !qMSWindows
	if (fControl)
	{
		ValidateControlRef();
		ControlActionUPP action = ::GetControlAction(fControl);
		if (action == ToolboxControlActionUPP)
			handler = reinterpret_cast<MControlHandler_AC*>(::GetControlReference(fControl));
	}
#endif
	return handler;
}

//----------------------------------------------------------------------------------------
// SetAction
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetAction(ControlActionUPP actionProc)
{
	ValidateControlRef();
	SetControlAction(fControl, actionProc);
}

//----------------------------------------------------------------------------------------
// GetAction
//----------------------------------------------------------------------------------------

ControlActionUPP CToolboxControl_AC::GetAction()
{
	ValidateControlRef();
	return GetControlAction(fControl);
}

//----------------------------------------------------------------------------------------
// SetReference
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetReference(SInt32 data)
{
	ValidateControlRef();
	SetControlReference(fControl, data);
}

//----------------------------------------------------------------------------------------
// GetReference
//----------------------------------------------------------------------------------------

SInt32 CToolboxControl_AC::GetReference()
{
	ValidateControlRef();
	return GetControlReference(fControl);
}

#if !qMSWindows && !qCarbon

//----------------------------------------------------------------------------------------
// InstallColor
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::InstallColor(const CRGBColor_AC& theColor)
{
	if (fControl)
	{
		ValidateControlRef();
		CCTabHandle newColorTableHandle;
		if (ChangeColorTable(theColor, newColorTableHandle))
		{
			// ••• change this call to PermCopyHandle, remove ThrowIfOSError
			//newColorTableHandle = (CCTabHandle)PermCopyHandle_AC((Handle) newColorTableHandle);
			ThrowIfOSErr_AC(HandToHand((Handle*) &newColorTableHandle));
			
			// Parse the color table, and make the appropriate settings.
			// The ctSize field defines the number of elements in the table, minus one.
			for (short i = 0; i <= (*newColorTableHandle)->ctSize; ++i)
			{
				switch ((*newColorTableHandle)->ctTable[i].value)
				{
					case cFrameColor:
					case cTextColor:
						(*newColorTableHandle)->ctTable[i].rgb = theColor;
						break;

					case cThumbColor:
					case cBodyColor:
						break;	// do nothing - InstallColor only affects the "fore" color
				}
			}
			::SetControlColor(fControl, newColorTableHandle);
		}
	}
}

//----------------------------------------------------------------------------------------
// ChangeColorTable
//----------------------------------------------------------------------------------------

bool CToolboxControl_AC::ChangeColorTable(const CRGBColor_AC& theColor, CCTabHandle& colorTableHandle) const
{
	// determine if the control color table needs to be changed
	bool changeColorTable = false;

	if (fControl)
	{
		ValidateControlRef();
		
		// retrieve the control's color table
		AuxCtlHandle itsAuxCtlHandle;
		bool hasAuxCtl = GetAuxiliaryControlRecord(fControl, &itsAuxCtlHandle);
		::ThrowIfNULL_AC(itsAuxCtlHandle);
		colorTableHandle = (*itsAuxCtlHandle)->acCTable;

		::ThrowIfNULL_AC(colorTableHandle);
		
		changeColorTable = true;

		// The ctSize field defines the number of elements in the table, minus one.
		for (short i = 0; i <= (*colorTableHandle)->ctSize; ++i)
		{
			if ((*colorTableHandle)->ctTable[i].value == cFrameColor)
			{
				changeColorTable = CRGBColor_AC((*colorTableHandle)->ctTable[i].rgb) != theColor;
				break;
			}
		}
	}
	
	return changeColorTable;
}

#endif // !qMSWindows && !qCarbon

//----------------------------------------------------------------------------------------
// SendMessage
//----------------------------------------------------------------------------------------

SInt32 CToolboxControl_AC::SendMessage(SInt16 inMessage, SInt32 inParam)
{
	ValidateControlRef();
#if UNIVERSAL_INTERFACES_VERSION >= 0x0335
	return SendControlMessage(fControl, inMessage, reinterpret_cast<void*>(inParam));
#else
	return SendControlMessage(fControl, inMessage, inParam);
#endif
}

//----------------------------------------------------------------------------------------
// AssureRootControl
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::AssureRootControl(WindowRef itsWindow) // static
{
#if qMSWindows
	#pragma unused (itsWindow)
#else
	if (::HasAppearanceMgr_AC())
	{
		::Assertion_AC(itsWindow != NULL, "In AssureRootControl, the WindowRef parameter is NULL.");
		ValidateWindow_AC(itsWindow);
		ControlHandle rootControl = NULL;
		OSErr ignored = ::CreateRootControl(itsWindow, &rootControl);
#if qProjectBuilder
		(void) ignored;
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// GetRootControl
//----------------------------------------------------------------------------------------

ControlRef CToolboxControl_AC::GetRootControl(WindowRef itsWindow) // static
{
	ControlRef rootControl = NULL;
	if (HasAppearanceMgr_AC())
	{
		Assertion_AC(itsWindow != NULL, "In GetRootControl, the WindowRef parameter is NULL.");
		ValidateWindow_AC(itsWindow);
		ThrowIfOSErr_AC( ::GetRootControl(itsWindow, &rootControl) );
	}
	return rootControl;
}

//----------------------------------------------------------------------------------------
// CanEmbed
//----------------------------------------------------------------------------------------

bool CToolboxControl_AC::CanEmbed() const
{
	bool	canEmbed = false;

	if (fControl && ::HasAppearanceMgr_AC())
	{
    	UInt32		controlFeatures;
		ThrowIfOSErr_AC(::GetControlFeatures(fControl, &controlFeatures));
		canEmbed = (controlFeatures & kControlSupportsEmbedding) != 0;
	}

	return canEmbed;
}

//----------------------------------------------------------------------------------------
// EmbedControl
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::EmbedControl(CToolboxControl_AC* inContainer)
{
	if (fControl)
	{
		if (::HasAppearanceMgr_AC())
			ThrowIfOSErr_AC(::EmbedControl(inContainer->GetControlRef(), GetControlRef()));
	}
#if qDebug
	else
		::ProgramBreak_AC("CToolboxControl_AC::EmbedControl: Our fControl is NULL so we cannot"
						  " embed a control.");
#endif
}

//----------------------------------------------------------------------------------------
// AutoEmbed
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::AutoEmbed(WindowRef inWindow)
{
	ThrowIfOSErr_AC( AutoEmbedControl(fControl, inWindow) );
}

//----------------------------------------------------------------------------------------
// GetParent
//----------------------------------------------------------------------------------------

ControlRef CToolboxControl_AC::GetParent()
{
	ControlRef outParent = NULL;
	ThrowIfOSErr_AC( GetSuperControl(fControl, &outParent) );
	return outParent;
}

//----------------------------------------------------------------------------------------
// CountChildren
//----------------------------------------------------------------------------------------

UInt16 CToolboxControl_AC::CountChildren()
{
	UInt16 outNumChildren = 0;
	ThrowIfOSErr_AC( CountSubControls(fControl, &outNumChildren) );
	return outNumChildren;
}

//----------------------------------------------------------------------------------------
// GetIndexedChild
//----------------------------------------------------------------------------------------

ControlRef CToolboxControl_AC::GetIndexedChild(UInt16 inIndex)
{
	ControlRef outSubControl = NULL;
	ThrowIfOSErr_AC( GetIndexedSubControl(fControl, inIndex, &outSubControl) );
	return outSubControl;
}

//----------------------------------------------------------------------------------------
// SetSupervisor
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetSupervisor(ControlRef inBoss)
{
	ThrowIfOSErr_AC( SetControlSupervisor(fControl, inBoss) );
}

//----------------------------------------------------------------------------------------
// GetKeyboardFocus
//----------------------------------------------------------------------------------------

ControlRef CToolboxControl_AC::GetKeyboardFocus(WindowRef inWindow) // static
{
	ControlRef outControl = NULL;
	ThrowIfOSErr_AC( ::GetKeyboardFocus(inWindow, &outControl) );
	return outControl;
}

//----------------------------------------------------------------------------------------
// SetKeyboardFocus
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetKeyboardFocus(ControlFocusPart focusPart)
{
#if qMSWindows
	#pragma unused (focusPart)
#else
	if (fControl && ::HasAppearanceMgr_AC())
	{
		ValidateControlRef();
		OSErr err = ::SetKeyboardFocus(GetWindowRef(), fControl, focusPart);
#if qProjectBuilder
		(void) err;
#endif
	}
#endif
}

//----------------------------------------------------------------------------------------
// ClearKeyboardFocus
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::ClearKeyboardFocus(WindowRef inWindow) // static
{
	ThrowIfOSErr_AC( ::ClearKeyboardFocus(inWindow) );
}

//----------------------------------------------------------------------------------------
// GetFeatures
//----------------------------------------------------------------------------------------

UInt32 CToolboxControl_AC::GetFeatures() const
{
	UInt32 features = 0;

#if !qMSWindows
	if (fControl && ::HasAppearanceMgr_AC())
	{
		ValidateControlRef();
		ThrowIfOSErr_AC(::GetControlFeatures(fControl, &features));
	}
#endif

	return features;
}

//----------------------------------------------------------------------------------------
// SetData
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetData(ControlPartCode inPart, ResType inTagName,
								 Size inSize, Ptr inData)
{
#if qMSWindows
	#pragma unused (inPart, inTagName, inSize, inData)
#else
	if (fControl && ::HasAppearanceMgr_AC())
	{
		ValidateControlRef();
		ThrowIfOSErr_AC(::SetControlData(fControl, inPart, inTagName, inSize, inData));
	}
#endif
}

//----------------------------------------------------------------------------------------
// GetData
//----------------------------------------------------------------------------------------

Size CToolboxControl_AC::GetData(ControlPartCode inPart, ResType inTagName,
								 Size inBufferSize, Ptr inBuffer)
{
	Size outActualSize = 0;

#if qMSWindows
	#pragma unused (inPart, inTagName, inBufferSize, inBuffer)
#else
	if (fControl && ::HasAppearanceMgr_AC())
	{
		ValidateControlRef();
		ThrowIfOSErr_AC(::GetControlData(fControl, inPart, inTagName, inBufferSize, inBuffer, &outActualSize));
	}
#endif

	return outActualSize;
}							 

//----------------------------------------------------------------------------------------
// GetDataSize
//----------------------------------------------------------------------------------------

Size CToolboxControl_AC::GetDataSize(ControlPartCode inPart, ResType inTagName)
{
	Size outMaxSize = 0;

#if qMSWindows
	#pragma unused (inPart, inTagName)
#else
	if (fControl && ::HasAppearanceMgr_AC())
	{
		ValidateControlRef();
		ThrowIfOSErr_AC(::GetControlDataSize(fControl, inPart, inTagName, &outMaxSize));
	}
#endif

	return outMaxSize;
}

//----------------------------------------------------------------------------------------
// HandleDragTracking
//----------------------------------------------------------------------------------------

bool CToolboxControl_AC::HandleDragTracking(DragTrackingMessage inMessage, DragReference inDrag)
{
	Boolean outLikesDrag = false;
	ThrowIfOSErr_AC( HandleControlDragTracking(fControl, inMessage, inDrag, &outLikesDrag) );
	return outLikesDrag;
}

//----------------------------------------------------------------------------------------
// HandleDragReceive
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::HandleDragReceive(DragReference inDrag)
{
	ThrowIfOSErr_AC( HandleControlDragReceive(fControl, inDrag ));
}

//----------------------------------------------------------------------------------------
// SetDragTrackingEnabled
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetDragTrackingEnabled(bool tracks)
{
	ThrowIfOSErr_AC( SetControlDragTrackingEnabled(fControl, tracks) );
}

//----------------------------------------------------------------------------------------
// IsDragTrackingEnabled
//----------------------------------------------------------------------------------------

bool CToolboxControl_AC::IsDragTrackingEnabled()
{
	Boolean tracks = false;
	ThrowIfOSErr_AC( IsControlDragTrackingEnabled(fControl, &tracks) );
	return tracks;
}

//----------------------------------------------------------------------------------------
// GetWindowRef
//----------------------------------------------------------------------------------------

WindowRef CToolboxControl_AC::GetWindowRef() const
{
	ValidateControlRef();
	WindowRef owner = NULL;
	if (fControl)
	{
#if !qCarbon
		owner = (*fControl)->contrlOwner;
#else
		owner = ::GetControlOwner(fControl);
#endif
	}
	return owner;
}

#if !qCarbon

//----------------------------------------------------------------------------------------
// SetWindowRef
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::SetWindowRef(WindowRef itsNewControlOwner)
{
	if (fControl)
	{
		ValidateControlRef();
#if !qCarbon
		(*fControl)->contrlOwner = itsNewControlOwner;
#else
		// Changing a control's owner is not allowed in Carbon
		#pragma unused (itsNewControlOwner)
#endif
	}
}

//----------------------------------------------------------------------------------------
// BeInPort
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::BeInPort(GrafPtr itsNewPort)
{
	// BeInPort(NULL) is interpreted as the window closing.
	// Moving the control to gWorkPort does not work with Appearance
	// control hierarchies.  The underlying control _must_ be deleted 
	// before the window is deleted to avoid double-deletion of the control.

	if (fControl)
	{
		if (itsNewPort != NULL)
		{
			WindowRef itsOldPort = GetWindowRef();
			if (itsOldPort != (WindowRef) itsNewPort)
			{
				// Get the control off the control list of the old owner
				RemoveFromWindowControlList(itsOldPort);
				
				// and on to the control list of the new owner
				AddToWindowControlList((WindowRef) itsNewPort);
			}
		}
		else
		{
			// No new owner, the window is about to be deleted,
			// we had better delete ourselves before the root control 
			// deletes us behind our back.
			DeleteControlRef();
		}
	}
}

//----------------------------------------------------------------------------------------
// RemoveFromWindowControlList
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::RemoveFromWindowControlList(WindowRef itsOldControlOwner)
{
	// Get the control off the control list of the old owner
	if (fControl && itsOldControlOwner)
	{
		ValidateControlRef();
		// first control on list
		#if !qCarbon
				ControlHandle currentControl = reinterpret_cast<ControlHandle>(((WindowPeek)itsOldControlOwner)->controlList);
		#else
				//ControlHandle currentControl = reinterpret_cast<ControlHandle>(::GetWindowControlList(itsOldControlOwner));
				ControlHandle currentControl = NULL;
		#endif
		
		if (currentControl == fControl)
		{
			#if !qCarbon
				((WindowPeek)itsOldControlOwner)->controlList = reinterpret_cast<Handle>((*fControl)->nextControl);
				(*fControl)->nextControl = NULL;
			#else
				//#pragma message ("CToolboxControl_AC::RemoveFromWindowControlList: SetNextControl may only be temporary.")
				// •••  Warning: MacWindows.h says "SetWindowControlList may only be temporary"	--	MB-9810-06-1423
				//::SetWindowControlList(itsOldControlOwner, (Handle) ::GetNextControl(fControl));
				// •••  Warning: Controls.h says "SetNextControl may only be temporary"	--	MB-9810-06-1412
				//::SetNextControl(fControl, NULL);
			#endif
		}
		else
		{
			while (currentControl)
			{
				#if !qCarbon
					if ((*currentControl)->nextControl == fControl)
					{
						(*currentControl)->nextControl = (*fControl)->nextControl;
						(*fControl)->nextControl = NULL;
						break;
					}
					currentControl = (*currentControl)->nextControl;
				#else
					break;
				#endif
			}
		}
	}
}

//----------------------------------------------------------------------------------------
// AddToWindowControlList
//----------------------------------------------------------------------------------------

void CToolboxControl_AC::AddToWindowControlList(WindowRef itsNewControlOwner)
{
	// add to the control list of the new owner
	if (fControl && itsNewControlOwner)
	{			
		::Assertion_AC(itsNewControlOwner != NULL, "In AddToWindowControlList, the WindowRef parameter is NULL.");
		ValidateWindow_AC(itsNewControlOwner);
		ValidateControlRef();
#if !qCarbon
		(*fControl)->nextControl = reinterpret_cast<ControlHandle>(((WindowPeek)itsNewControlOwner)->controlList);
		((WindowPeek)itsNewControlOwner)->controlList = reinterpret_cast<Handle>(fControl);
#else
//		::SetWindowControlList(itsNewControlOwner, (Handle) fControl);
//#pragma message ("CToolboxControl_AC::AddToWindowControlList: SetWindowControlList not in Carbon anymore?")
#endif
		
		SetWindowRef(itsNewControlOwner);
	}
}

#endif // !qCarbon

//----------------------------------------------------------------------------------------
// GetPrivateData
//----------------------------------------------------------------------------------------

Handle CToolboxControl_AC::GetPrivateData()
{
	ValidateControlRef();
	Handle contrlData = NULL;
	if (fControl)
	{
#if !qCarbon
		contrlData = (*fControl)->contrlData;
#else
		contrlData = GetControlDataHandle(fControl);
#endif
	}
	return contrlData;
}

//----------------------------------------------------------------------------------------
// GetHandler
//----------------------------------------------------------------------------------------

MControlHandler_AC* CToolboxControl_AC::GetHandler(ControlRef theControl)
{
#if qCoreDebug
	if (!ValidateControl_AC(theControl))
		ThrowLogicError_AC();
#endif
	MControlHandler_AC* handler = reinterpret_cast<MControlHandler_AC*>(GetControlReference(theControl));
#if qDebug
	ThrowIfNonObject_AC(handler);
#endif
	return handler;
}

//----------------------------------------------------------------------------------------
// ToolboxControlAction
//----------------------------------------------------------------------------------------

DEFINE_API(void) CToolboxControl_AC::ToolboxControlAction(ControlRef theControl, ControlPartCode partCode)
// CToolboxControl_AC will automatically use this actionProc callback,
// which it uses to call back to the control's MControlHandler_AC.
// (CToolboxControl_AC sets the control's user reference to the control handler).
{
	try
	{
		GetHandler(theControl)->DoControlAction(partCode);
	}
	catch (...)
	{
	}
}

//----------------------------------------------------------------------------------------
// ToolboxControlKeyFilter
//----------------------------------------------------------------------------------------

DEFINE_API(ControlKeyFilterResult) CToolboxControl_AC::ToolboxControlKeyFilter(ControlRef theControl, 
																			   SInt16 *keyCode, 
																			   SInt16 *charCode, 
																			   EventModifiers *modifiers)
{
	ControlKeyFilterResult result = kControlKeyFilterPassKey;
	try
	{
		result = GetHandler(theControl)->DoControlKeyFilter(theControl, keyCode, charCode, modifiers);
	}
	catch (...)
	{
	}
	return result;
}

#if UNIVERSAL_INTERFACES_VERSION >= 0x0335
//----------------------------------------------------------------------------------------
// ToolboxControlColor
//----------------------------------------------------------------------------------------

DEFINE_API(OSStatus) CToolboxControl_AC::ToolboxControlColor(ControlRef inControl, 
															 SInt16 inMessage, 
															 SInt16 inDrawDepth, 
															 Boolean inDrawInColor)
{
	OSStatus err = noErr;
	try
	{
		err = GetHandler(inControl)->DoControlColor(inControl, inMessage, inDrawDepth, inDrawInColor);
	}
	catch (CMacException_AC& ex)
	{
		err = ex.GetError();
	}
	catch (...)
	{
		if (!err)
			err = minErr;
	}
	return err;
}
#endif


//----------------------------------------------------------------------------------------
// End of CToolboxControl_AC.cpp