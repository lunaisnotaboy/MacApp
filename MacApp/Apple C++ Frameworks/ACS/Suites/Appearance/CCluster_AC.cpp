//----------------------------------------------------------------------------------------
// CCluster_AC.cpp
// Copyright © 1997-2001 by Apple Computer, Inc. All rights reserved. 
// Portions Copyright ©1997 by Trygve Isaacson.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/04/00	Conditional on qEmulateStandardControls
		09/22/00	Improved graphics device iterator. 
		12/21/99	Use kThemeStateInactive instead of kThemeStateDisabled (kThemeStateDisabled
					is obsolete). 
		03/24/99	Update copyright notice.
*/

#ifndef __CCluster_AC__
#include "CCluster_AC.h"
#endif

#if qEmulateStandardControls

// Appearance

#ifndef __AGAImaging_AC__
#include "AGAImaging_AC.h"
#endif

#ifndef __ColorRamp_AC__
#include "ColorRamp_AC.h"
#endif

// ACS

#ifndef __CDrawingEnvironment_AC__
#include "CDrawingEnvironment_AC.h"
#endif

#ifndef __CGDIterator_AC__
#include "CGDIterator_AC.h"
#endif

//========================================================================================
// CCluster_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CCluster_AC::CCluster_AC
//----------------------------------------------------------------------------------------

CCluster_AC::CCluster_AC(const CRect_AC& boundsRect, bool isActive, const CTextStyle_AC& titleStyle, SInt32 justification, bool groupBoxType, const CStr255_AC& titleString, SInt16 titleGap) :
	CCustomControl_AC(boundsRect, isActive),
	MControlBackground_AC(kInstallOnlyIfCustom),
	fTitle(titleString),
	fTitleStyle(titleStyle),
	fJustification(justification),
	fTitleGap(titleGap),
	fIsPrimaryBox(groupBoxType)
{
}

//----------------------------------------------------------------------------------------
// CCluster_AC::~CCluster_AC
//----------------------------------------------------------------------------------------

CCluster_AC::~CCluster_AC()
{
}

//----------------------------------------------------------------------------------------
// CCluster_AC::SetTitleGap
//----------------------------------------------------------------------------------------

void CCluster_AC::SetTitleGap(SInt16 titleGap)
{
	// Set the width of the title gap that will be left blank.

	fTitleGap = titleGap;
}

//----------------------------------------------------------------------------------------
// CCluster_AC::GetTitle
//----------------------------------------------------------------------------------------

CStr255_AC CCluster_AC::GetTitle() const
{
	return fTitle;
}

//----------------------------------------------------------------------------------------
// CCluster_AC::SetTitle
//----------------------------------------------------------------------------------------

void CCluster_AC::SetTitle(const CStr255_AC& newTitle)
{
	// Set the title, optionally redraw.

	fTitle = newTitle;

	if (fVisible)
		this->DrawControl();
}

//----------------------------------------------------------------------------------------
// CCluster_AC::DrawControl
//----------------------------------------------------------------------------------------

void CCluster_AC::DrawControl()
{
	CTempDrawingEnvironment_AC	env;

	// Draw the group box.

	CRect_AC	r(GetBounds());
	SInt16		titleGap = 0;
	SInt16		topIndent = 0;
	FontInfo	fontInfo;

	if (!fTitle.IsEmpty())
	{
		fTitleStyle.SetPortTextStyle();	// calculate gap for title's text style
		::GetFontInfo(&fontInfo);
		
		topIndent = fontInfo.ascent;	// text baseline should be at frame top
		
		titleGap = 5 + ::StringWidth(fTitle);
	}
	else
		titleGap = fTitleGap;

	DrawClusterFrame(topIndent, titleGap);

	if (!fTitle.IsEmpty())
	{
		CRect_AC	titleRect;
		
		titleRect.left = r.left + 4 + GetGapLeftInset(titleGap);
		titleRect.top = r.top + 2;
		titleRect.right = titleRect.left + titleGap - 5;
		titleRect.bottom = titleRect.top + fontInfo.ascent + fontInfo.descent;

		for (CGDIterator_AC iter; iter; ++iter)
		{
			AGAStringOut(fTitle, titleRect, kNoTruncation, fJustification, 
						 fActive ? kNormalOutput : kDisabledOutput, 
						 iter->IsDeep(), fTitleStyle);
		}
	}
}

//----------------------------------------------------------------------------------------
// CCluster_AC::SetFontStyle
//----------------------------------------------------------------------------------------

void CCluster_AC::SetFontStyle(const CControlTextStyle_AC& textStyle)
{
	// Set the QuickDraw text style for the labels.

	fTitleStyle = CTextStyle_AC(textStyle);

	if (fVisible)
		DrawControl();
}

//----------------------------------------------------------------------------------------
// CCluster_AC::GetFontStyle
//----------------------------------------------------------------------------------------

CControlTextStyle_AC CCluster_AC::GetFontStyle()
{
	return CControlTextStyle_AC(fTitleStyle);
}

//----------------------------------------------------------------------------------------
// CCluster_AC::DrawClusterFrame
//----------------------------------------------------------------------------------------

void CCluster_AC::DrawClusterFrame(SInt16 topIndent, SInt16 gapSize)
{
	// Draw the group box in whatever form is appropriate.

	bool drawEnabled = fActive;
	CRect_AC r(fBounds);
	
	r.top += topIndent;

	if (fIsPrimaryBox)
		AGADrawThemePrimaryGroup(r, drawEnabled ? kThemeStateActive : kThemeStateInactive);
	else
		AGADrawThemeSecondaryGroup(r, drawEnabled ? kThemeStateActive : kThemeStateInactive);

	EraseFrameGap(topIndent, gapSize);
}

//----------------------------------------------------------------------------------------
// CCluster_AC::EraseFrameGap
//----------------------------------------------------------------------------------------

void CCluster_AC::EraseFrameGap(SInt16 topIndent, SInt16 gapSize)
{
	// Paint in the gap if there is one.

	if (gapSize != 0)
	{
		CRect_AC r(fBounds);
		
		r.top += topIndent;

		if (fIsPrimaryBox)
			::PenSize(2, 2);

		for (CGDIterator_AC iter; iter; ++iter)
		{
			if (iter->IsDeep())
				ApplyBackgroundColor(fActive);
			else
				kRGBColorRamp[rW].SetForeColor();

			::MoveTo(r.left + GetGapLeftInset(gapSize), r.top);
			::Line(gapSize - 1, 0);
		}

		if (fIsPrimaryBox)
			::PenSize(1, 1);
	}
}

//----------------------------------------------------------------------------------------
// CCluster_AC::GetGapLeftInset
//----------------------------------------------------------------------------------------

SInt16 CCluster_AC::GetGapLeftInset(SInt16 gapSize)
{
	// Return the number of pixels from the left edge of the group box
	// to the start of the gap. This depends on the title justification,
	// because the gap is not necessarily a fixed number of pixels from
	// the left.
	
	SInt16	inset;
	
	switch (CTextStyle_AC::RuntimeJustify(fJustification))
	{
		case teCenter:
			inset = (fBounds.right - fBounds.left - gapSize - 12) / 2;
			break;
		case teFlushRight:
			inset = fBounds.right - fBounds.left - gapSize - 12;
			break;
		default: //case teFlushLeft:
			inset = 10;
			break;
	}
	
	return inset;
}


#endif // qEmulateStandardControls

//----------------------------------------------------------------------------------------
// End of CCluster_AC.cpp
