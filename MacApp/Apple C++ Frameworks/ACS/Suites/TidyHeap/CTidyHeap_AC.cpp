//----------------------------------------------------------------------------------------
// CTidyHeap_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		07/20/01	Added std::strlen and std::strcpy and descoped them in source.
		04/05/01	Correct message for kBadMarker3 in LogError.
		03/01/01	Need to include CAssertionFailure_AC. Include MacMemory instead
							of Memory. 
		02/14/01	Don't include Core_AC. 
		02/12/01	Instance method doesn't need an additional static bool to tell
							if fgSelf is defined. 
		01/02/01	Update copyright.
		11/01/00	[PB] Don't include SegLoad. 
		10/17/00	Shorten the file names CTidyHeapDebugStrLogger_AC.h, .cpp and 
							CTidyHeapLogFileLogger_AC.h, .cpp so they don't blow up MakeDepend. 
		06/06/00	[2477917] DonÕt define in-place operator new -- standard says
							not to override it.  Include new.
		05/04/00	Don't crash if TidyHeapSharedLib is missing. 
		01/04/00	Fine tune the compiler version check on operator new. 
		12/27/99	Minor cosmetic cleanup.
		12/07/99	[MPW] Removed developer identifying comment.  Modify MrC and SCPP
							tests. Strip path in CreateBlock and PushInfo.  Changed message in
							RemoveBlock and enhanced notification about no leaks.
		10/10/99	[2396150] Change TH_new to use PushInfo and the standard new
							operator because new with file and line number arguments is 
							treated by C++ as a placement new. Made PushInfo static for
							convenience and greater safety. 
		07/23/99	[C] Changed string handling in PrintDebugString.
		03/24/99	Update copyright notice.
		11/12/98	[2279223] Include <typeinfo> instead of <typeinfo.h>.
		11/12/98	For Carbon, don't delete fgSelf in CTidyHeap_AC::Terminate because it crashes
		----- R13u4 -----
		09/16/98	Define in-place operator new based on CodeWarrior version.
		09/02/98	[2271183] Check result of call to FindHeader before using in VerifyState.
		07/27/98	Backed out change in CreateBlock testing ÔfileÕ and operator
							new sending "UNKNOWN" for file name.
							[2253894] Added string length assertion.
		07/15/98	Changed name of CActIncrementalNewFailer_AC.h to CActIncrNewFailer_AC.h.
							Many other changes to allow TidyHeap for 68K.
		03/19/98	Conditionally compile in array new and delete.
		----- R13u3 -----
		09/10/97	Fix build problems.
		08/25/97	Fix up TidyHeap with new options.
		08/22/97	Add temp memory support.
		08/22/97	Double delete watching improvements.
		08/21/97	TidyHeap enhancements.
		08/21/97	TidyHeap improvements: PrintDebugString, HashTable, etc..
		08/20/97	Merge with latest r13 code.
		08/07/97	Bug fixes. Minor feature additions. API refinements.
		06/13/97	Fixup undeleted block handling.
		06/02/97	Fix crash at exit bug.
		05/30/97	Turn off prf debugging #define.
		05/30/97	[1659147] Make settings work correctly. 
		05/16/97	Bug fixes
		05/08/97	Use prefix inc/decrement where possible. 'More Effective C++' pp. 34. Important for user types, ok for integral types
		04/16/97	Fixes.
		04/14/97	Support for new 'BreakOnUnknownBlock' action prefs.
		03/27/97	Fixed _really_ lame bug.
		03/26/97	Made new/delete easier to step through.
		03/25/97	AC_ to _AC Name change.
		02/21/97	Added include for CTidyHeapActionsMore_AC.h.
		12/11/96	Added block in app heap support (PtrInAppHeap) and fixed up 
							the error logging a bit. Also now a block verification doesn't	
							log the block data if it passes (usenet feature request).
		10/18/96	Added Exemption Support. Added Get Block List.
		10/10/96	[1345531] Fixing no load builds.
		10/09/96	Fixed big mem leak. Added leak checking code that's conditionally
							compiled.
		09/26/96	Bracketed source with qTidyHeap
		09/26/96	Removed bogus check that caused the last block to not get deleted.
		09/26/96	Enhanced AquireLogger so you can turn off logging temporarily.
		09/25/96	Fixed bug where some data members weren't getting initialized in ctor
		09/12/96	Added ;g to the termination message.
		09/09/96	Renamed C to T.
		09/05/96	[1382830] Changed gTidyHeap to CTidyHeap_AC::Instance 
							to control creation better.
		09/05/96	Fixed up file type/creator stuff.
		07/16/96	Formatting changes
		07/11/96	Big Changes. Added loggers. Settings. Bitflags. Settings files,
							etc.
*/
#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qTidyHeap

// TidyHeap

#ifndef __CTidyHeapLogDebugStr_AC__
#include "CTidyHeapLogDebugStr_AC.h"
#endif

#ifndef __CTidyHeapAction_AC__
#include "CTidyHeapAction_AC.h"
#endif

#ifndef __CTidyHeapActions_AC__
#include "CTidyHeapActions_AC.h"
#endif

#ifndef __CTidyHeapActionsMore_AC__
#include "CTidyHeapActionsMore_AC.h"
#endif

#ifndef __CTidyHeapActionList_AC__
#include "CTidyHeapActionList_AC.h"
#endif

#ifndef __CTidyHeapBlock_AC__
#include "CTidyHeapBlock_AC.h"
#endif

#ifndef __CTidyHeapBlockList_AC__
#include "CTidyHeapBlockList_AC.h"
#endif

#ifndef __CTidyHeapFile_AC__
#include "CTidyHeapFile_AC.h"
#endif

#ifndef __CTidyHeapLogFile_AC__
#include "CTidyHeapLogFile_AC.h"
#endif

#ifndef __CTidyHeap_ACPRIVATE__
#include "CTidyHeapPrivate_AC.h"
#endif

#ifndef __CTidyHeapState_AC__
#include "CTidyHeapState_AC.h"
#endif

#ifndef __CActIncrNewFailer_AC__
#include "CActIncrNewFailer_AC.h"
#endif

#ifndef __CTidyHeapHashTable_AC__
#include "CTidyHeapHashTable_AC.h"
#endif

// TidyHeapSharedLib

#ifndef __TIDYHEAPSHAREDLIB__
#include "TidyHeapSharedLib.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

// Toolbox

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#ifndef __PROCESSES__
#include <Processes.h>
#endif

#ifndef __TEXTUTILS__
#include <TextUtils.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>		// Added for NewPtr,DisposePtr
#endif

// Standard Library

#if !(defined(_STDARG) || defined(__STDARG__))
#include <stdarg.h>
#endif

#if !(defined(_STRING) || defined(__STRING__))
#include <string.h>
#endif

#if !(defined(_STDIO) || defined(__STDIO__))
#include <stdio.h>
#endif

#ifndef __typeinfo__
#include <typeinfo>
#endif

#ifndef __STDLIB__
#include <stdlib.h>
#endif

#include <new>


static const long kHeaderSize = sizeof(BlockHeader) - sizeof(long);
static const long kTrailerSize = sizeof(BlockTrailer);

GlobalNewProc 		CTidyHeap_AC::GlobalNew;
GlobalDeleteProc  	CTidyHeap_AC::GlobalDelete;

CTidyHeap_AC* CTidyHeap_AC::fgSelf;
long CTidyHeap_AC::fgAddressRange;
long CTidyHeap_AC::fgBlockSize;

#define qDebugTidyHeapPrfFile 0

#if (q68K && !qModelCFM)
static bool fgTidyHeapHasBeenTerminated = false;	// Flag indicating TidyHeap has been shutdown
#endif

// usings

using std::strlen;
using std::strcpy;

//========================================================================================
// NEW / DELETE Overrides.
//========================================================================================

//----------------------------------------------------------------------------------------
// operator new 
//----------------------------------------------------------------------------------------
	
void* operator new(size_t size)
{
	CTidyHeap_AC* tidyHeap = CTidyHeap_AC::Instance();
	return tidyHeap->CreateBlock(size, NULL, -1);
}

//----------------------------------------------------------------------------------------
// operator new 
//----------------------------------------------------------------------------------------
	
void* operator new(size_t size, const char* file, short line)
{
	CTidyHeap_AC* tidyHeap = CTidyHeap_AC::Instance();
	return tidyHeap->CreateBlock(size, file, line);
}

//----------------------------------------------------------------------------------------
// operator delete 
//----------------------------------------------------------------------------------------
	
void operator delete(void* ptr )
{
	if (ptr)
	{
		CTidyHeap_AC* tidyHeap = CTidyHeap_AC::Instance();
		tidyHeap->RemoveBlock(ptr);
	}
}		

#if !defined(__MWERKS__) || __MWERKS__ >= 0x2100
#if !(defined(__MRC__) && !FIXED_MPW_BUG)
#if !(defined(__SC__) && !FIXED_MPW_BUG)

//----------------------------------------------------------------------------------------
// operator new[]
//----------------------------------------------------------------------------------------
	
void* operator new[](size_t size, const char* file, short line)
{
	CTidyHeap_AC* tidyHeap = CTidyHeap_AC::Instance();
	return tidyHeap->CreateBlock(size, file, line);
}

//----------------------------------------------------------------------------------------
// operator delete[]
//----------------------------------------------------------------------------------------
	
void operator delete[](void* ptr )
{
	if (ptr)
	{
		CTidyHeap_AC* tidyHeap = CTidyHeap_AC::Instance();
		tidyHeap->RemoveBlock(ptr);
	}
}		

#endif
#endif
#endif

//----------------------------------------------------------------------------------------
// ::TidyHeapTerminateProc_AC
//----------------------------------------------------------------------------------------

extern "C" void TidyHeapTerminateProc_AC();

extern "C" void TidyHeapTerminateProc_AC()
// This wraps the c++ function to be installed by atexit().  It is needed only for
// segmented 68K code.
{
	CTidyHeap_AC::Terminate();
}

//========================================================================================
// class CTidyHeap_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CTidyHeap_AC constructor
//----------------------------------------------------------------------------------------
		 
CTidyHeap_AC::CTidyHeap_AC() 
	:	fCount(0),
		fSizeTally(0),
		fDebugTally(0),
		fDeleteCount(0),
		fErr(0),
		fNextNewFails(false),
		fEnabledOnStart(false),
		fLogger(NULL),
		fLineNum(0),
		fExemptCount(0),
		fDoubleDeleteHashTable(NULL)
{
	fFileName[0] = '\0';
	fLogString[0] = '\0';
	fgAddressRange = 0;
	fgBlockSize = 32;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC ITidyHeap
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::ITidyHeap()
{
	
	CTidyHeapFile_AC file;
	file.SetTypeAndCreator(kSettingsFileType, kSettingsFileCreator);
	file.AppendExtension(".prf");
	
	file.ReadObject( *this );

	if (file.GetErr())
	{
		file.WriteObject(*this);
	}
	else
	if (SettingsModifiedExternally())
	{
#if qDebugTidyHeapPrfFile	
		PrintDebugString("TidyHeap Director Was last to modify .prf file;g");
#endif
		file.WriteObject( *this );
			// change the SettingsModifiedExternally bool to false in the file
	}

	MTidyHeapAllocator_AC::UseTempMem(UseTempMemory());
	
	SetToLogFileLogger();
	
	if ( IsEnabled() )
	{
		InstallPrefActions();
	}

#if !(q68K && !qModelCFM)
	// Was: TIDYHEAPSHAREDLIB_SETCALLBACK( Terminate );	
	// The definition of this routine is 'TIDYHEAPSHAREDLIB_SETCALLBACK(void (*"C")())'
	// and I don't want to change the definition of shared library so I decided to use
	// this wrapper instead.
	if (TIDYHEAPSHAREDLIB_SETCALLBACK != static_cast<void*>(kUnresolvedCFragSymbolAddress))
	{
		TIDYHEAPSHAREDLIB_SETCALLBACK(::TidyHeapTerminateProc_AC );
	}
	else
	{
		Logf("*** TidyHeapSharedLib not found!");
		Warnf("*** TidyHeapSharedLib not found!");
		if (::atexit(::TidyHeapTerminateProc_AC))
		{
			Logf("*** Failed to install TidyHeapTerminateProc");
			Warnf("*** Failed to install TidyHeapTerminateProc");
		}
	}
#endif
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC destructor
//----------------------------------------------------------------------------------------

CTidyHeap_AC::~CTidyHeap_AC()
{
	DeleteActions(fDeleteActions);
	DeleteActions(fNewActions);
	DeleteActions(fTerminationActions);	
			
	if (fLogger) delete fLogger;
	if (fDoubleDeleteHashTable) delete fDoubleDeleteHashTable;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetBlockCount
//----------------------------------------------------------------------------------------

long CTidyHeap_AC::GetBlockCount() const
{
	if (fgSelf)
		return fgSelf->fBlockList.GetCount();
	else
		return 0;
}	

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::FindTrailer
//----------------------------------------------------------------------------------------

BlockTrailer* CTidyHeap_AC::FindTrailer(BlockHeader* inBlock)
{
	BlockTrailer* outPtr = (BlockTrailer*) 
		(((char*)inBlock) + sizeof(BlockHeader) + inBlock->fBlockPtr->fSize - sizeof(long));	
		
	if (outPtr->fMarker3 != kMarker3)
	{
		outPtr = NULL;
		fErr = kBadMarker3;
	}
	
	if (fErr)
	{
		LogError();
	}

	return outPtr;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::CreateBlock
//----------------------------------------------------------------------------------------

void* CTidyHeap_AC::CreateBlock(size_t size, const char* file, short line)
{
	file = LeafName_AC(file);

	void* outPtr = NULL;
	
	if ( !IsEnabled() )
		outPtr = GlobalNew(size);
	else
	{
		++fCount; // this is always incremented.

		if (fNextNewFails) 
		{
			fNextNewFails = false;
		}
		else
		{
		
			BlockHeader* headerPtr = (BlockHeader*) GlobalNew(size + kHeaderSize + kTrailerSize);
			if (headerPtr)
			{
				
				CTidyHeapBlock_AC*	blockPtr = CreateBlockObject();
				if (!blockPtr)
	 			{
					GlobalDelete( (void*) headerPtr );
					headerPtr = NULL;
				}
				else
				{
					// Setup header
					new(headerPtr) BlockHeader; // call blocks' constructor
					
					// Setup trailer
					new(((char*)headerPtr) + kHeaderSize + size) BlockTrailer;
				
					outPtr = &(headerPtr->fData);
					fDebugTally += kHeaderSize;
					fSizeTally += size; 
					
					blockPtr->fSize = size;
					blockPtr->fAddress = outPtr;
					blockPtr->fHeader = headerPtr;
					blockPtr->fId = fCount;
					
					headerPtr->fBlockPtr = blockPtr;
					
					if (file)
					{
						strcpy(blockPtr->fFile, file);
						::Assertion_AC(strlen(blockPtr->fFile) < sizeof(blockPtr->fFile),
									   "CTidyHeap_AC::CreateBlock (1): Write beyond end of blockPtr->fFile.");
						blockPtr->fLineNum = line;
					}
					else if (fLineNum > 0)		// Was: if(::strlen(fFileName))
					{
						strcpy(blockPtr->fFile, fFileName);
						::Assertion_AC(strlen(blockPtr->fFile) < sizeof(blockPtr->fFile),
									   "CTidyHeap_AC::CreateBlock (2): Write beyond end of blockPtr->fFile.");
						blockPtr->fLineNum = fLineNum;
						fFileName[0] = '\0';
						fLineNum = 0;
					}
					
					CTidyHeapAction_AC* action = fNewActions.GetHead();
					
					while(action)
					{
						DoAction( action, headerPtr );
						action = action->Next();
					}
					
					if (fNextNewFails)
					{
						fNextNewFails = false;
						delete blockPtr;
						fgSelf->GlobalDelete(headerPtr);	
						outPtr = NULL;
					}
					else if (!blockPtr->IsExempt())
					{
						// exempting a block means don't track it
						fBlockList.Append(blockPtr);
					}
					
				}
			}
		
			if (outPtr && fDoubleDeleteHashTable)
				fDoubleDeleteHashTable->AddElement(outPtr);
		
		}
		#if (q68K && !qModelCFM)
		if (fgTidyHeapHasBeenTerminated)
		{
			Logf("\n### new called after TidyHeap has been terminated. (%ld undeleted blocks including this)", GetBlockCount());
			VerifyBlock(outPtr, true);

			if (WantsUndeletedBlockWarning() &&	GetBlockCount())
				Warnf("TidyHeap Warning: you have %ld undeleted blocks (more info in log file);g", GetBlockCount() );
		}
		#endif
	}	
	
	if (!outPtr)
		HandleNilAllocation(file, line);

	return outPtr;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::FindHeader
//----------------------------------------------------------------------------------------


BlockHeader* CTidyHeap_AC::FindHeader(char* inPtr)	
{
	fErr = 0;
	
	BlockHeader* outHeader = NULL;
	
	if (PointersLivesInAppHeap())
	{
		if (!PtrInAppHeap(inPtr))
		{
			fErr = kPtrNotInAppHeap;
		}
	}
	
	if (!fErr)
	{	
		// First place to check for the header is immediately on top of the incoming ptr.
		char* walker = inPtr;
	
		walker -= kHeaderSize;
		
		if (CharPtrToLong(walker) == kMarker1)
		{
			outHeader = (BlockHeader*) walker;
		
			if (outHeader->fMarker2 != kMarker2)
			{
				outHeader = NULL;
				
				fErr = kBadMarker2;
			}	
		}
		else
		{
			// If we get here that means the block is either corrupted
			// or the compiler has padded something. So now were going
			// to search backward for one of our markers.
			
			char* startOfValidMem = (inPtr - kHeaderSize);
				// I'm assuming that the header is there and that we have a block of mem
				// at least the sizeof the blockheader to search in. I can't guarentee that
				// mem at location less that startofValidMem is even there.
				 	 
			for(walker = inPtr; walker >= startOfValidMem; --walker)
			{
				if (CharPtrToLong(walker) == kMarker2)
				{
					// whoo hoo! We found the footMarker.
				
					walker -= sizeof( BlockHeader ) - sizeof(long); 
					
					if (CharPtrToLong(walker) == kMarker1)
					{
						outHeader = (BlockHeader*) walker;
						
					}
					else
						fErr = kBadMarker1;
					
					break;
				}
				else if (CharPtrToLong(walker) == kMarker1)
				{
					// whoo hoo! We found the headMarker.
				
					outHeader = (BlockHeader*) walker;

					if (outHeader->fMarker2 != kMarker2)
					{
						outHeader = NULL;
					}
					else
						fErr = kBadMarker2;
						
					break;
				}
				
			
			}
			
			if (!outHeader && !fErr)
			{
				fErr = kNoMarkersFound; // yikes!
			}
			
		#if qDebugTidyHeap	
			if (outHeader)
			{
				long offset = ((char*)outHeader) - inPtr;
				Logf("### Had to search header for markers. Found the offset at %d", offset);
			}
		#endif	
		
		
		} // else

	}	

	if (fErr)
		LogError();
	
	return outHeader;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::LogError
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::LogError()
{

	const char* descStr;
	
	switch(fErr)
	{
		// Should probably load these strings from a resource.
		
		case kNoErr:
			descStr = "No Error";
			break;
		
		case kBadMarker1:
			descStr = "Bad Block Header: Marker 1 corrupt";
			break;
		
		case kBadMarker2:
			descStr = "Bad Block Header: Marker 2 corrupt";
			break;
		
		case kBadMarker3:
			descStr = "Bad Block Trailer: Marker 3 corrupt";
			break;

		case kNoMarkersFound:
			descStr = "Found no markers at all! (Yikes!)";
			break;
		
		case kPtrCrossRefFailed:
			descStr = "Pointer Cross Reference failed.";
			break;
		
		case kPtrNotInAppHeap:
			descStr = "Block not in Application Heap.";
			break;
		
		default:
			descStr = "Invalid Error value. Run for your life!";
			break;
	
	}
	
	if (WantsWarnings())
	{
		Warnf("TidyHeap Error: %s (%d)", descStr, fErr );
	}

	Logf("### TidyHeap Error: %s (%d)", descStr, fErr );
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::RemoveBlock
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::RemoveBlock(void* ptr)
{
	if (!IsEnabled())
		GlobalDelete(ptr);
	else
	{
		#if (q68K && !qModelCFM)
		if (fgTidyHeapHasBeenTerminated)
		{
			Logf("\n### delete called after TidyHeap has been terminated."
				" (%ld undeleted blocks before deleting the one shown below)", GetBlockCount());
			VerifyBlock(ptr, true);
		}
		#endif

		++fDeleteCount;
		
		fErr = 0;
		
		bool doDeleteIt = true;
		
		if (fDoubleDeleteHashTable)
		{
			CTidyHeapHashTable_AC<void*>::CHashTableLink* elementLink = 
					fDoubleDeleteHashTable->FindElement(ptr);
			
			if (elementLink)
				fDoubleDeleteHashTable->RemoveElement(elementLink);
			else
			{
				CTidyHeap_AC::Instance()->Logf("### Block Double Delete detected!");
				CTidyHeap_AC::Instance()->Warnf("Block Double Delete detected!");
				doDeleteIt = false;
			}
		}
		
		if (doDeleteIt)
		{
			// This will log an error if it fails.
			BlockHeader* toDelete = FindHeader((char*) ptr);
				
			if (toDelete && !fErr)
			{
				BlockTrailer* trailer = FindTrailer(toDelete);
			
				CTidyHeapBlock_AC* blockPtr = toDelete->fBlockPtr;
				
				if (trailer && !fErr)
				{
					CTidyHeapAction_AC* action = fDeleteActions.GetHead();
					
					while(action)
					{
						DoAction( action, toDelete);
						action = action->Next();
					}
					
					CTidyHeapAction_AC* deleteAction = toDelete->fBlockPtr->fDeleteAction;
					
					if (deleteAction)
					{
						DoAction( deleteAction, toDelete);
						
						delete deleteAction;			
						toDelete->fBlockPtr->fDeleteAction = NULL;
					}		
					
					if (blockPtr->WasDeleted())
					{
						Logf("### Block Double Delete detected!");
						Warnf("Block Double Delete detected!");
						// add more here
					}
					else
					{
						blockPtr->WasDeleted(true); 
						
						if (!blockPtr->DontDelete())
						{
							fBlockList.Remove(blockPtr);
			
							GlobalDelete((char*)toDelete);
							
							delete blockPtr;
						}
					}
				}
			}
		
		}
		#if (q68K && !qModelCFM)
		if (fgTidyHeapHasBeenTerminated)
		{
			if (GetBlockCount())
			{
				if (WantsUndeletedBlockWarning())
					Warnf("TidyHeap Warning: you have %ld undeleted blocks (more info in log file);g", GetBlockCount() );
			}
			else
			{
				// Let them know that there were no leaks.
				if (WantsUndeletedBlockWarning())
					Warnf("TidyHeap Message: ALL BLOCKS HAVE BEEN DELETED (No Memory Leaks);g" );
				
				Logf( "\n### ALL BLOCKS HAVE BEEN DELETED (No Memory Leaks)." );
			}
		}
		#endif
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::PushInfo
//----------------------------------------------------------------------------------------

void* CTidyHeap_AC::PushInfo(const char* file, short lineNum)
{
	// If the TidyHeap instance doesn't exist yet, don't stomp on low memory. 
	// It's more important to be safe than to record who allocated the first
	// object. 
	if (fgSelf)
	{
		file = LeafName_AC(file);
		fgSelf->fLineNum = lineNum;
		strcpy(fgSelf->fFileName, file);
		::Assertion_AC(strlen(fgSelf->fFileName) < sizeof(fgSelf->fFileName),
					   "CTidyHeap_AC::PushInfo: Write beyond end of fgSelf->fFileName.");
	}

	// Return a dummy value so the TH_new macro can test it
	return 0;
}

//----------------------------------------------------------------------------------------
// Added proc wrappers for classic 68K.
// I don't know if NewPtrWrap is absolutely necessary, since linker did not complained
// about undefined NEWPTR.  But in any case, NewPtr and DisposePtr functions should be
// de-inlined to get the pointer to them (for classic 68K code), so that the overhead of
// these wrappers is not unreasonable.
//----------------------------------------------------------------------------------------

#if (q68K && !qModelCFM)
static void* NewPtrProc(size_t inSize)
	{ return(NewPtr(inSize)); }

static void DisposePtrProc(void* inPtr)
	{ DisposePtr(reinterpret_cast<Ptr>(inPtr)); }

#endif

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::Instance
//----------------------------------------------------------------------------------------

CTidyHeap_AC* CTidyHeap_AC::Instance()
{
	if (!fgSelf)
	{
		#if (q68K && !qModelCFM)
			// This is believed to be the next to best solution for segmented 68K code.
			// There is no guarantee that Terminate() will be called at the very last, 
			// but still it generates fairly useful information about potential memory
			// leaks.

			// Install CTidyHeap_AC::Terminate()
			if (::atexit(::TidyHeapTerminateProc_AC))
			{
				PrintDebugString("CTidyHeap_AC::Instance: Unable to install CTidyHeap_AC::Terminate() for segmented 68K code.");
				ExitToShell();
			}

			CTidyHeap_AC::GlobalNew = NewPtrProc;
			CTidyHeap_AC::GlobalDelete = DisposePtrProc;	
		#else
			CTidyHeap_AC::GlobalNew = (GlobalNewProc) NewPtr;
			CTidyHeap_AC::GlobalDelete = (GlobalDeleteProc) DisposePtr;	
		#endif
			
		fgSelf = CreateTidyHeap();
		if (!fgSelf )
		{	
			PrintDebugString("Unable to allocate TidyHeap. Something is seriously wrong.");
			ExitToShell();
		}
		fgSelf->ITidyHeap();	
	}
	
	return fgSelf;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::SetTempMemPref
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::SetTempMemPref()
{
	
}


//----------------------------------------------------------------------------------------
// CTidyHeap_AC::Terminate
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::Terminate()
{
	if (fgSelf)
	{
		fgSelf->HandleTermination();

		#if qCarbon
			// Get rid of crash on quit with merged TidyHeap code.
			// It happens when calling IsValidBlock when deleting fgSelf.
		#elif !(q68K && !qModelCFM)
			delete fgSelf;
			fgSelf = NULL;
		#else
			// Do not delete tidyheap under 68k classic runtime, since there is no 
			// guarantee that Terminate will be called at the very last.  delete
			// might be called after tidyheap termination.
			fgTidyHeapHasBeenTerminated = true;		// Instead, just set the flag.
		#endif

#if qDebugTidyHeap		
		if (MTidyHeapAllocator_AC::fgAllocationCounter > 0)
		{
			PrintDebugString("Number of TidyHeap's Leaks: %ld;g", MTidyHeapAllocator_AC::fgAllocationCounter);
		}
#endif
	}
	
}


//----------------------------------------------------------------------------------------
// CTidyHeap_AC::Logf
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::Logf(const char* format, ...)
{
	if (IsEnabled() && fLogger)
	{
		static va_list args;
		
		va_start(args, format);
		vsprintf(fLogString, format, args);
		::Assertion_AC(strlen(fLogString) < sizeof(fLogString),
					   "CTidyHeap_AC::Logf: Write beyond end of fLogString.");
		va_end(args);
		
		fLogger->Log(fLogString);
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::Warnf
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::Warnf(const char* format, ...)
{
	static va_list args;
	
	if (IsEnabled() && WantsWarnings())
	{
		va_start(args, format); // can't globally scope
		::vsprintf(fLogString, format, args);
		::Assertion_AC(strlen(fLogString) < sizeof(fLogString),
					   "CTidyHeap_AC::Warnf: Write beyond end of fLogString.");
		va_end(args); // can't globally scope
	
		PrintDebugString(fLogString);
	}
}
	
//----------------------------------------------------------------------------------------
// CTidyHeap_AC::VerifyAllBlocks
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::VerifyAllBlocks(bool logBlockData)
{
	if (IsEnabled())
	{
		long size = 0;
		if (!fBlockList.IsEmpty())
		{
			CTidyHeapBlock_AC* walker = fBlockList.GetHead();
			
			while(walker)
			{
				
				VerifyBlock( walker->fAddress, logBlockData );
				size += walker->fSize;
				
				walker = walker->Next();
			}
			
			Logf("### Sum of outstanding block sizes = %ld bytes.", size );
		}
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::VerifyBlock
//----------------------------------------------------------------------------------------

CTidyHeapError_AC CTidyHeap_AC::VerifyBlock(void* inBlock, bool logBlockData)
{
	if (IsEnabled())
	{
		CTidyHeapBlock_AC* block = 0;
		BlockHeader* header = FindHeader((char*)inBlock);
		BlockTrailer* trailer = NULL;
			
		if (header && !fErr)
			trailer = FindTrailer(header);

		if (!fErr)
		{
			block = header->fBlockPtr;
			
			if (	(block->fAddress != inBlock) || (block->fHeader != header))
			{
				fErr = kPtrCrossRefFailed;
			}
			else if (logBlockData)
				block->LogBlockData();
		}

		if (fErr)
		{
			// already logged the error in FindHeader or FindTrailer
			if (block)block->LogBlockData();	
		}
	}
		
	return fErr;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::SetDebugStrHook
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::SetToDebugStrLogger(bool doHalt)
{
	AquireLogger( new CTidyHeapDebugStrLogger_AC(doHalt) );
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::SetLogFileHook
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::SetToLogFileLogger()
{
	AquireLogger( new CTidyHeapLogFileLogger_AC );
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::VerifyState
//----------------------------------------------------------------------------------------

long CTidyHeap_AC::VerifyState(CTidyHeapState_AC &inShot)
{
	long count = 0;
	
	if (IsEnabled())
	{
		BlockHeader* marker = FindHeader((char*)inShot.fMarker);
		
		if (marker && marker->fBlockPtr != fBlockList.GetTail())
		{
			Logf("### Warning: outstanding blocks remaining after state saved.");
			
			CTidyHeapBlock_AC* walker = marker->fBlockPtr->Next();
			
			while(walker)
			{
				VerifyBlock( walker->fAddress );
				++count;
				walker = walker->Next();
			}
			
			Logf("### Num new blocks since state saved: %ld", count);
		}
		else
		{
			Logf("### State detected no leaks.");
		}
	}
	
	return count;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::DeleteActions
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::DeleteActions(CTidyHeapActionList_AC &inList)
{
	// Note:this should be a list method.
	
	CTidyHeapAction_AC* walker = inList.GetHead();
	CTidyHeapAction_AC* deleter = NULL;
	
	while(walker)
	{
		deleter = walker;
		walker = walker->Next();
	
		if (deleter) 
		{
			inList.Remove(deleter);
			delete deleter;	
		}
	}

}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::DoAction
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::DoAction(CTidyHeapAction_AC* action, BlockHeader* header)
{
	if (header)
	{
		action->DoAction(header->fBlockPtr);
	}
	else
	{
		action->DoAction(NULL);
	}
}



//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetBlock
//----------------------------------------------------------------------------------------

CTidyHeapBlock_AC* CTidyHeap_AC::GetBlock(void* inPtr)
{
	
	CTidyHeapBlock_AC* outBlock = NULL;
	
	if (IsEnabled())
	{
		fErr = 0;
		
		
		BlockHeader* header = FindHeader((char*) inPtr);
		if (header)
		{
			outBlock = header->fBlockPtr;
		}
	}	
	return outBlock;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetMarker
//----------------------------------------------------------------------------------------

CTidyHeapMarker_AC CTidyHeap_AC::GetMarker(void* inPtr, short markerNum)
{
	fErr = 0;
	CTidyHeapMarker_AC outMarker = 0xF0F0F0F0;
	
	if (IsEnabled())
	{
		BlockHeader* header = FindHeader((char*)inPtr);
		if (header)
		{
			switch( markerNum )
			{
				case 1:
					outMarker = header->fMarker1;
					break;
				
				case 2:
					outMarker = header->fMarker2;
					break;
				
				case 3:
					BlockTrailer* trailer = FindTrailer(header);
					if (!fErr)
					{
						outMarker = trailer->fMarker3;
					}	
				
					break;
			
			}	
		}
	}
	return outMarker;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::CreateBlockObject
//----------------------------------------------------------------------------------------

CTidyHeapBlock_AC* CTidyHeap_AC::CreateBlockObject()
{
	return new CTidyHeapBlock_AC;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::MakeNextNewFail
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::MakeNextNewFail()
{
	fNextNewFails = true;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::AquireNewAction
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::AquireNewAction(CTidyHeapAction_AC* inAction)
{
	inAction->SetActionType(CTidyHeapAction_AC::kNewAction);
	fNewActions.Append(inAction);
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::RemoveNewAction
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::RemoveNewAction(CTidyHeapAction_AC* inAction)
{
	fNewActions.Remove(inAction);
}


//----------------------------------------------------------------------------------------
// CTidyHeap_AC::AquireDeleteAction
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::AquireDeleteAction(CTidyHeapAction_AC* inAction)
{
	inAction->SetActionType(CTidyHeapAction_AC::kDeleteAction);
	fDeleteActions.Append(inAction);
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::RemoveDeleteAction
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::RemoveDeleteAction(CTidyHeapAction_AC* inAction)
{
	fDeleteActions.Remove(inAction);
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::AquireTerminationAction
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::AquireTerminationAction(CTidyHeapAction_AC* inAction)
{
	inAction->SetActionType(CTidyHeapAction_AC::kTerminateAction);
	fTerminationActions.Append(inAction);
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::RemoveTerminationAction
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::RemoveTerminationAction(CTidyHeapAction_AC* inAction)
{
	fTerminationActions.Remove(inAction);
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetTerminationActionList
//----------------------------------------------------------------------------------------

CTidyHeapActionList_AC& CTidyHeap_AC::GetTerminationActionList()
{
	return fTerminationActions;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetNewActionsList
//----------------------------------------------------------------------------------------

CTidyHeapActionList_AC& CTidyHeap_AC::GetNewActionsList()
{
	return fNewActions;
}
	
//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetDeleteActionList
//----------------------------------------------------------------------------------------

CTidyHeapActionList_AC& CTidyHeap_AC::GetDeleteActionList()
{
	return fDeleteActions;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::AquireLogger
//----------------------------------------------------------------------------------------

 CTidyHeapLogger_AC * CTidyHeap_AC::AquireLogger(CTidyHeapLogger_AC *inLogger, bool deletePrevious)
{
	CTidyHeapLogger_AC *outLogger = NULL;

	if (fLogger)
	{
		if (deletePrevious)
			delete fLogger;
		else
			outLogger = fLogger;
	}
		
	fLogger = inLogger;

	return outLogger;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::RemoveAllActions
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::RemoveAllActions()
{
	DeleteActions(fNewActions);
	DeleteActions(fDeleteActions);
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::DoubleDeleteHashProc
//----------------------------------------------------------------------------------------

long CTidyHeap_AC::DoubleDeleteHashProc(void* inElement)
{
	long element = (long) inElement;

	return (element % fgAddressRange) / fgBlockSize;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::InstallPrefActions
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::InstallPrefActions()
{
	if (WatchForDoubleDeletes())
	{
		fgAddressRange = FreeMem();
		
		CTidyHeapFile_AC statFile;
		
		statFile.AppendExtension(".stt");
		
		statFile.Open();
		
		if (!statFile.GetErr())
		{
			long blockSize = 0;

			statFile.Read(&blockSize, sizeof(long));
			
			statFile.Close();
		
			if (blockSize != 0)
				fgBlockSize = ((float) blockSize) * 1.10;
		}
		
		fDoubleDeleteHashTable = new CTidyHeapHashTable_AC<void*>(
			(fgAddressRange / fgBlockSize) + 1, DoubleDeleteHashProc);
	}	
	
	if (InstallMakeNewFail())
		AquireNewAction( new CActionMakeNewFail_AC(GetNewFailCount()));
	
	if (InstallIncrementalFailer())
		AquireNewAction(  new CActionIncrementalNewFailer_AC); 
	
	if (InstallNewVerifyAction())
		AquireNewAction( new CActionVerifyBlock_AC); 
	
	if (InstallDeleteVerifyAction())
		AquireDeleteAction( new CActionVerifyBlock_AC); 
	
	if (InstallNewVerifyAllAction())
		AquireNewAction(new CActionVerifyAll_AC); 
	
	if (InstallDeleteVerifyAllAction())
		AquireDeleteAction(new CActionVerifyAll_AC); 
	
	if (InstallExemptUnknownBlocks())
		AquireNewAction(new CActionExcemptUnknownBlocks_AC); 
	
	if (InstallGarbageIn())
		AquireNewAction(new CActionGarbageIn_AC ); 
	
	if (InstallGarbageOut())
		AquireDeleteAction(new CActionGarbageOut_AC ); 
	
	if (InstallNewBreakOnUnknownBlock())
		AquireNewAction(new CActionBreakOnUnknownBlock_AC ); 
	
	if (InstallDeleteBreakOnUnknownBlock())
		AquireDeleteAction(new CActionBreakOnUnknownBlock_AC ); 
	
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetSessionFileLoc
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::GetSessionFileLoc(short& vol, long &dirId)
{
	vol = 0;
	dirId = 0;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::HandleNilAllocation
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::HandleNilAllocation(const char* /*fileName*/, short /*line*/)
{
	// override this if you want to throw an exception or something.
	
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetErr
//----------------------------------------------------------------------------------------

CTidyHeapError_AC CTidyHeap_AC::GetErr()
{
	return fErr;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::GetBlockList
//----------------------------------------------------------------------------------------

CTidyHeapBlockList_AC& CTidyHeap_AC::GetBlockList()
{
	return fBlockList;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::PtrInAppHeap
//----------------------------------------------------------------------------------------

bool CTidyHeap_AC::PtrInAppHeap(void* inPtr)
{
	THz appZone = ::LMGetApplZone();
	return inPtr >= &(appZone->heapData) && inPtr < appZone->bkLim;
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::HandleTermination
//----------------------------------------------------------------------------------------

#define BoolToStr(b) b ? "true" : "false"

void CTidyHeap_AC::HandleTermination()
{
	CTidyHeapFile_AC file;
	file.SetTypeAndCreator(kSettingsFileType, kSettingsFileCreator);
	file.AppendExtension(".prf");
	
	CTidyHeapSettings_AC tempSettings;
	
	file.ReadObject(tempSettings);
	
	if (!tempSettings.SettingsModifiedExternally() || 
		tempSettings.GetLastWriteSeconds() <= GetLastWriteSeconds())
	{	
#if qDebugTidyHeapPrfFile	
		PrintDebugString("Writing prf file (TidyHeap director not last to modify it);g");
#endif		

		file.WriteObject(*this);
	}
#if qDebugTidyHeapPrfFile	
	else
	{
		PrintDebugString("TidyHeap director last to modify prf file - not writing;g");
		
		CTidyHeapSettings_AC::operator = (tempSettings);
	}
#endif	

	if (IsEnabled())
	{
		Logf("### TidyHeap Termination Messages:");
		
		
		// print info
		
		if (PrintExtraInfo())
		{
			Logf("\n### Installed New Actions:");
			
			PrintActionList(fNewActions);

			Logf("\n### Installed Delete Actions:");
			
			PrintActionList(fDeleteActions);
		
			Logf("\n### Installed Terminate Actions:");
			
			PrintActionList(fTerminationActions);

			Logf("\n### Features Settings:");
			Logf("###     IsEnabled: %s", BoolToStr(IsEnabled()) );
			Logf("###     WantsWarnings: %s", BoolToStr(WantsWarnings()) );
			Logf("###     WantsUndeletedBlockWarning: %s", BoolToStr(WantsUndeletedBlockWarning()) );
			Logf("###     DoLogUndeletedBlocks: %s", BoolToStr(DoLogUndeletedBlocks()) );
			Logf("###     PointersLivesInAppHeap: %s", BoolToStr(PointersLivesInAppHeap()) );
			Logf("###     WatchForDoubleDeletes: %s", BoolToStr(WatchForDoubleDeletes()) );
			Logf("###     Use Temporary Memory: %s", BoolToStr(UseTempMemory()));
			
			Logf("\n### TidyHeap Memory Stats:");
			Logf("###    Cumulative memory: %ld", MTidyHeapAllocator_AC::MemTally());
			Logf("###    Max memory: %ld", MTidyHeapAllocator_AC::MaxMemory());
			

			if (fDoubleDeleteHashTable) 
			{
				fDoubleDeleteHashTable->PrintStats();
				Logf("###    BlockSize: %ld", fgBlockSize);
			}
		}
		else
			Logf("###    Print Extra Info: false");

		// print info

		Logf("\n### %d Outstanding blocks, %ld total blocks, Ave Size %f",
			GetBlockCount(), 
			GetBlockCountTally(),
			GetAveBlockSize() );
		
		Logf("### New called %d times, Delete called %d times",
			 GetBlockCountTally(),
			 fDeleteCount);
	
		Logf("### Exempted %ld unknown blocks", fExemptCount);
	
		if (	WantsUndeletedBlockWarning() &&	GetBlockCount())
			Warnf("TidyHeap Warning: you have %ld undeleted blocks (more info in log file);g", GetBlockCount() );
		
		// log undeleted blocks
		
		if (	DoLogUndeletedBlocks() )
		{
			VerifyAllBlocks(true); // true means log the block data
		}
		
		// execute termination actions
		
		CTidyHeapAction_AC* actionWalker = fTerminationActions.GetHead();
		
		while(actionWalker)
		{
			DoAction(actionWalker, NULL);
			actionWalker = actionWalker->Next();
		}

		// save out ave block size

		CTidyHeapFile_AC statFile;
		
		statFile.AppendExtension(".stt");
		
		statFile.SetTypeAndCreator(kStatFileType, '????');
		
		statFile.Open(CTidyHeapFile_AC::kWrite);
		
		if (!statFile.GetErr())
		{
			long blockSize = GetAveBlockSize();

			statFile.Write(&blockSize, sizeof(long));
		}
		#if (q68K && !qModelCFM)
		Logf("\n#### End of TidyHeap - Termination message.");
		Logf("#################################################################################");
		#endif
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::ExemptBlockFromLeakCheck
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::ExemptBlockFromLeakCheck(void* inBlock)
{
	CTidyHeapBlock_AC* theBlock = Instance()->GetBlock(inBlock);
	if (theBlock)
	{
		Instance()->ExemptBlockFromLeakCheck(theBlock);
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::StopTrackingUnknownBlocks
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::StopTrackingUnknownBlocks()
{
	CTidyHeapBlock_AC* walker = fBlockList.GetHead();
	CTidyHeapBlock_AC* toRemove = NULL;
	
	long count = 0;
	
	while(walker)
	{
		toRemove = walker;
		walker = walker->Next();
		
		if (toRemove->GetLineNum() == 0)
		{
			ExemptBlockFromLeakCheck(toRemove);
			count++;
		}
	}
	
	Logf("### Stopped tracking %ld unknown blocks", count);
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::ExemptBlockFromLeakCheck
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::ExemptBlockFromLeakCheck(CTidyHeapBlock_AC* inBlock, bool doExempt)
{
	if (inBlock)
	{
		if (doExempt && !inBlock->IsExempt()) 
		{
			if (inBlock->InList(&fBlockList))
			{
				fBlockList.Remove(inBlock);
			}	
			
			inBlock->IsExemptFlag(true);
			fExemptCount++;
		}
		else
		if (!doExempt && inBlock->IsExempt()) 
		{
			if (!inBlock->InList(&fBlockList))
			{
				fBlockList.Append(inBlock);
				inBlock->IsExemptFlag(false);
				fExemptCount--;
			}
		}
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::PrintDebugString
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::PrintDebugString(const char* inString, ...)
{
	static char outputStr[512];
	static va_list args;
		
	va_start(args, inString);
	vsprintf(outputStr, inString, args);
	::Assertion_AC(strlen(outputStr) < sizeof(outputStr),
				   "CTidyHeap_AC::PrintDebugString: Write beyond end of outputStr.");
	va_end(args);
		
 #if !qCarbon
	c2pstr(outputStr);
	::DebugStr((StringPtr) outputStr);
 #else
	Str255 pString;
	CopyCStringToPascal(outputStr, pString);
	::DebugStr(pString);
 #endif

}

//----------------------------------------------------------------------------------------
// CTidyHeap_AC::PrintActionList
//----------------------------------------------------------------------------------------

void CTidyHeap_AC::PrintActionList(CTidyHeapActionList_AC& inList)
{
	CTidyHeapAction_AC* walker = inList.GetHead();
	
	while(walker)
	{
		Logf("###     %s", typeid(*walker).name() );
		walker = walker->Next();
	}
}


#endif
/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		06/12/96	Added calls to FailNil when forcing new to fail (doh!).
		06/10/96	Changed Install to Aquire. Added methods to remove actions,
							to get action lists, changed doIts to DoAction.
		06/05/96	Initial Implementation
*/