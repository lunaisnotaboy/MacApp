//----------------------------------------------------------------------------------------
// CTidyHeapList_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qTidyHeap

#ifndef __CTidyHeapList_AC__
#include "CTidyHeapList_AC.h"
#endif
#ifndef __CTidyHeapListItem_AC__
#include "CTidyHeapListItem_AC.h"
#endif

//========================================================================================
// class CTidyHeapListItem_AC
//========================================================================================

#if defined(__SC__) || defined(__MRC__)
//----------------------------------------------------------------------------------------
// CTidyHeapListItem_AC destructor
//----------------------------------------------------------------------------------------
CTidyHeapListItem_AC::~CTidyHeapListItem_AC() 
// De-inlined to force generate 'CTidyHeapListItem_AC::_rttivtbl' under SCPP and MrC.
{
	if (InList())
		fList->Remove(this);
}
#endif

//========================================================================================
// class CTidyHeapList_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CTidyHeapList_AC constructor
//----------------------------------------------------------------------------------------

CTidyHeapList_AC::CTidyHeapList_AC()
	:	fCount(0), 
		fHead(NULL), 
		fTail(NULL) 
{
}

//----------------------------------------------------------------------------------------
// CTidyHeapList_AC destructor
//----------------------------------------------------------------------------------------

CTidyHeapList_AC::~CTidyHeapList_AC() 
{
}

//----------------------------------------------------------------------------------------
// CTidyHeapList_AC::Push
//----------------------------------------------------------------------------------------

void CTidyHeapList_AC::Push(CTidyHeapListItem_AC* listItem)
{
	++fCount;
	listItem->fNext = fHead;
	listItem->fPrev = NULL;
	
	if (fHead)
		fHead->fPrev = listItem;
	
	fHead = listItem;	
	
	if (!fTail)
		fTail = fHead;
		
	listItem->fList = this;
	
	listItem->HandleListInsertion();
}

//----------------------------------------------------------------------------------------
// CTidyHeapList_AC::Append
//----------------------------------------------------------------------------------------

void CTidyHeapList_AC::Append(CTidyHeapListItem_AC* listItem)
{
	++fCount;
	listItem->fPrev = fTail;
	listItem->fNext = NULL;
	
	if (fTail)
		fTail->fNext = listItem;

	fTail = listItem;
	
	if (!fHead) 
		fHead = fTail;

	listItem->fList = this;
	
	listItem->HandleListInsertion();
}

//----------------------------------------------------------------------------------------
// CTidyHeapList_AC::Remove
//----------------------------------------------------------------------------------------

void CTidyHeapList_AC::Remove(CTidyHeapListItem_AC* listItem)
{
	if (listItem->InList(this))
	{
		--fCount;
		
		if (listItem == fHead)
		{
			fHead = fHead->fNext;
				// move head ptr up the chain
			
			if (fHead)
				fHead->fPrev = NULL;
			else
				fTail = NULL; // empty list

		}
		else
		if (listItem == fTail)
		{
			fTail = fTail->fPrev;
				// move tail up chain
				
			if (fTail)
				fTail->fNext = NULL; 
			else
				fHead = NULL; // empty list
		}
		else
		{
			listItem->fPrev->fNext = listItem->fNext;
			listItem->fNext->fPrev = listItem->fPrev;
		}
		
		listItem->fNext = NULL;
		listItem->fPrev = NULL;
		listItem->fList = NULL;
		
		listItem->HandleListRemoval();
	}
}

#endif
/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Changed nil back to NULL.
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/05/96	Initial Implementation
*/