//----------------------------------------------------------------------------------------
// MTidyHeapAllocator_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qTidyHeap

#ifndef __MTidyHeapAllocator_AC__
#include "MTidyHeapAllocator_AC.h"
#endif

#ifndef __MEMORY__
#include <Memory.h>
#endif

bool MTidyHeapAllocator_AC::fgUseTempMem;
long MTidyHeapAllocator_AC::fgMaxMemory;
long MTidyHeapAllocator_AC::fgMemTally;
long MTidyHeapAllocator_AC::fgCurMemory;

//========================================================================================
// class MTidyHeapAllocator_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// MTidyHeapAllocator_AC::operator new
//----------------------------------------------------------------------------------------

#if qDebugTidyHeap
long MTidyHeapAllocator_AC::fgAllocationCounter;
#endif

void* MTidyHeapAllocator_AC::operator new(size_t inSize)
{
	
	static bool firstTime = true;
	if(firstTime)
	{
		firstTime = false;	

		fgMaxMemory = 0;
		fgMemTally = 0;
		fgCurMemory = 0;

#if qDebugTidyHeap
		fgAllocationCounter = 1;
#endif		
	
		CTidyHeap_AC::Instance(); 
				// Make sure TidyHeap is created.
	}
#if qDebugTidyHeap
	else
		++fgAllocationCounter;
#endif	

	OSErr err = 0;
	void* outData = NULL;

	if(UseTempMem())
	{
		Handle tempMemHandle = ::TempNewHandle(inSize, &err);
		if(!err)
		{
			HLockHi(tempMemHandle);
			outData = *tempMemHandle;
		
			fgCurMemory += inSize;
		}
	}
	else
	{
		outData = CTidyHeap_AC::GlobalNew(inSize);
	}
	
	if(outData)
	{	
		
		if(fgCurMemory > fgMaxMemory)
			fgMaxMemory = fgCurMemory;
		
		fgMemTally += inSize;
	}
	
	return outData;
}

//----------------------------------------------------------------------------------------
// MTidyHeapAllocator_AC::operator delete
//----------------------------------------------------------------------------------------

void MTidyHeapAllocator_AC::operator delete(void* inPtr)
{
#if qDebugTidyHeap
	--fgAllocationCounter;
#endif

	if(UseTempMem())
	{
		Handle tempMemHandle = RecoverHandle((char*) inPtr);
		
		fgCurMemory -= GetHandleSize(tempMemHandle);

		::HUnlock(tempMemHandle);

		::DisposeHandle(tempMemHandle);
	}
	else
	{
		CTidyHeap_AC::GlobalDelete(inPtr);
	}
}

//----------------------------------------------------------------------------------------
// MTidyHeapAllocator_AC::FirstTime
//----------------------------------------------------------------------------------------

bool MTidyHeapAllocator_AC::FirstTime()
{
	static bool firstTime = true;
	
	bool outBool = firstTime;
	
	if(firstTime)
		firstTime = false;
		
	return outBool;
}

//----------------------------------------------------------------------------------------
// MTidyHeapAllocator_AC::UseTempMem
//----------------------------------------------------------------------------------------

void MTidyHeapAllocator_AC::UseTempMem(bool doUse)
{
	if(FirstTime())
		fgUseTempMem = doUse;
	else
		CTidyHeap_AC::PrintDebugString("MTidyHeapAllocator_AC::::UseTempMem Failed.");
}

//----------------------------------------------------------------------------------------
// MTidyHeapAllocator_AC::UseTempMem
//----------------------------------------------------------------------------------------

bool MTidyHeapAllocator_AC::UseTempMem()
{	
	if(FirstTime())
		fgUseTempMem = true;

	return fgUseTempMem; 
}

#endif