//----------------------------------------------------------------------------------------
// CTidyHeapActions_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		03/01/01	Do include CAssertionFailure_AC. 
		02/14/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
		10/06/98	Include Core for noload build. 
*/


// tidyheap

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qTidyHeap

#ifndef __CTidyHeapActions_AC__
#include "CTidyHeapActions_AC.h"
#endif

#ifndef __CTidyHeapBlock_AC__
#include "CTidyHeapBlock_AC.h"
#endif

// ACS

#ifndef __CAssertionFailure_AC__
#include "CAssertionFailure_AC.h"
#endif

// Toolbox

#ifndef __TEXTUTILS__
#include <TextUtils.h>
#endif

// Ansi

#if !(defined(_STDIO_H) || defined(__STDIO__))
#include <stdio.h>
#endif

#if !(defined(_STRING_H) || defined(__STRING__))
#include <string.h>
#endif

//========================================================================================
// class CActionBreakOnDelete_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CActionBreakOnDelete_AC::DoAction
//----------------------------------------------------------------------------------------

CActionBreakOnDelete_AC::CActionBreakOnDelete_AC(const char* outStr)
{
	strcpy(fStr, outStr);
	::Assertion_AC(::strlen(fStr) < sizeof(fStr),
				   "CActionBreakOnDelete_AC::CActionBreakOnDelete_AC: Write beyond end of fStr.");
}

//----------------------------------------------------------------------------------------
// CActionBreakOnDelete_AC::DoAction
//----------------------------------------------------------------------------------------

void CActionBreakOnDelete_AC::DoAction(CTidyHeapBlock_AC* inBlock)
{
	// this needs some work.
	CTidyHeap_AC::Instance()->Warnf("deleting Block #%ld at 0x%X", 
		inBlock->GetID(),
		inBlock->GetAddress());
	
	CTidyHeap_AC::Instance()->Logf("### Deleting the following block:");
	inBlock->LogBlockData();
}

//========================================================================================
// class CActionMakeNewFail_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CActionMakeNewFail_AC constructor
//----------------------------------------------------------------------------------------

CActionMakeNewFail_AC::CActionMakeNewFail_AC(long whenToFail): 
fNewTally(0), 
fFailNum(whenToFail)
{ 
}

//----------------------------------------------------------------------------------------
// CActionMakeNewFail_AC::DoAction
//----------------------------------------------------------------------------------------

void CActionMakeNewFail_AC::DoAction(CTidyHeapBlock_AC*)
{
	if(++fNewTally == fFailNum)
	{
		CTidyHeap_AC::Instance()->Warnf("Forcing new %ld to fail.", fNewTally);
		CTidyHeap_AC::Instance()->MakeNextNewFail();
	}
}

//========================================================================================
// class CActionVerifyAll_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// 	CActionVerifyAll_AC::DoAction
//----------------------------------------------------------------------------------------

void CActionVerifyAll_AC::DoAction(CTidyHeapBlock_AC* /*inBlock*/)
{
	CTidyHeapLogger_AC* oldPtr = NULL;
	
	if(!fLog)
	{
		oldPtr = CTidyHeap_AC::Instance()->AquireLogger(NULL, false);
	}
	
	CTidyHeap_AC::Instance()->VerifyAllBlocks();
	
	if(!fLog)
	{
		CTidyHeap_AC::Instance()->AquireLogger(oldPtr, false);
	}
}

//========================================================================================
// class CActionVerifyBlock_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// 	CActionVerifyBlock_AC::DoAction
//----------------------------------------------------------------------------------------

void CActionVerifyBlock_AC::DoAction(CTidyHeapBlock_AC* inBlock)
{
	CTidyHeapLogger_AC* oldPtr = NULL;
	
	if(!fLog)
	{
		oldPtr = CTidyHeap_AC::Instance()->AquireLogger(NULL, false);
	}
	
	inBlock->Verify();
	
	if(!fLog)
	{
		CTidyHeap_AC::Instance()->AquireLogger(oldPtr, false);
	}
}


//========================================================================================
// class CActionExemptBlocks_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// 	CActionExemptBlocks_AC::DoAction
//----------------------------------------------------------------------------------------

void CActionExemptBlocks_AC::DoAction(CTidyHeapBlock_AC* inBlock)
{
	if(!fStopper || fStopper >= inBlock->GetID())
		inBlock->SetExempt(true); 
}


//========================================================================================
// class CActionBreakOnNew_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// 	CActionBreakOnNew_AC::DoAction
//----------------------------------------------------------------------------------------

void CActionBreakOnNew_AC::DoAction(CTidyHeapBlock_AC* inBlock)
{
	if(inBlock->GetID() == fID)
	{
		CTidyHeap_AC::PrintDebugString("CActionBreakOnNew_AC: Block ID: %ld", fID);
	}
}





#endif
/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		06/10/96	Renamed CIncrementalFailureAction to 
							CIncrementalNewFailureAction
		06/10/96	Changed DoIt to DoAction. Added two new action classes.
		06/05/96	Initial Implementation
*/