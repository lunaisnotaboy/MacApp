//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		02/14/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		11/15/00	[C] Move string back into file name in AppendExtension.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		07/23/99	[C] Changed string handling in AppendExtension.
		03/24/99	Update copyright notice.
		11/12/98	[2279239] Moved inclusion of CTidyHeapFile_AC.h below include of
					CTidyHeap_AC.h so ConditionalMacros_AC.h is included in proper order.
*/

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#ifndef __CTidyHeapFile_AC__
#include "CTidyHeapFile_AC.h"
#endif

#if qTidyHeap

// tidyheap

#ifndef __CTidyHeapFile_AC__
#include "CTidyHeapFile_AC.h"
#endif

// ACS

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __TEXTUTILS__
#include <TextUtils.h>
#endif

// ANSI

#if !(defined(_STRING_H) || defined(__STRING__))
#include <string.h>
#endif

#if !(defined(_STDIO_H) || defined(__STDIO__))
#include <stdio.h>
#endif

//========================================================================================
// class CTidyHeapFile_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::CopySpec
//----------------------------------------------------------------------------------------
void CTidyHeapFile_AC::CopySpec(FSSpec *dest, const FSSpec *src)
	{ ::BlockMove_AC( src, dest, sizeof(FSSpec)); }


//----------------------------------------------------------------------------------------
// Default Constructor
//----------------------------------------------------------------------------------------

CTidyHeapFile_AC::CTidyHeapFile_AC() 
	:	fErr(0),
		fRef(0)
{
	fType = 'TEXT';
	fCreator = 'MPS ';
	
	CTidyHeap_AC::Instance()->GetSessionFileLoc(fSpec.vRefNum,fSpec.parID);
	
	SetName(CTidyHeap_AC::Instance()->GetSessionName());
}

//----------------------------------------------------------------------------------------
// Default Constructor
//----------------------------------------------------------------------------------------

CTidyHeapFile_AC::CTidyHeapFile_AC(const char* inName, long inDir, short inVol) 
	: fErr(0),
	fRef(0)
{
	fType = 'TEXT';
	fCreator = 'MPS ';
	
	Specify(inName, inDir, inVol);
}

//----------------------------------------------------------------------------------------
// Copy Constructor
//----------------------------------------------------------------------------------------

CTidyHeapFile_AC::CTidyHeapFile_AC(const CTidyHeapFile_AC &inFile)
{
	*this = inFile;
}

//----------------------------------------------------------------------------------------
// Conversion Constructor
//----------------------------------------------------------------------------------------

CTidyHeapFile_AC::CTidyHeapFile_AC(const FSSpec &inSpec) :
fErr(0),
fRef(0)
{
	fType = 'TEXT';
	fCreator = 'MPS ';
	CopySpec(&fSpec, &inSpec);
}

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

CTidyHeapFile_AC::~CTidyHeapFile_AC()
{
	Close();
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::Open
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::Open(ePerms inPerms)
{
	if( !fRef )
	{
		char perms = inPerms == kRead ? fsRdPerm : fsRdWrPerm;
			
		fErr = ::FSpOpenDF(&fSpec, perms, &fRef);
		
		if (fErr == fnfErr && perms == fsRdWrPerm) 
		{
			fErr =  ::FSpCreate(&fSpec,fCreator, fType,  0);

			if (!fErr)
				fErr = ::FSpOpenDF(&fSpec, perms, &fRef);
		}	
		
		
		if(!fErr)
		{
			if (inPerms == kAppend)
				fErr = ::SetFPos(fRef,fsFromLEOF,0);
			else if (inPerms == kWrite)
				fErr = ::SetEOF(fRef, 0);
		}
	
		ReportErr("Open Failed");
	}
}


//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::Close
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::Close()
{
	if (fRef)
	{
		fErr = FSClose(fRef);
		if (!fErr)
			fRef = 0;
		
		ReportErr("Close Failed");
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::Read
//----------------------------------------------------------------------------------------

long CTidyHeapFile_AC::Read(void *data, long size )
{
	if (fRef)
		fErr = ::FSRead(fRef,  &size, (Ptr) data);
	else
		fErr = fnOpnErr;

	ReportErr("Read Failed");
		
	return size;
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::Write
//----------------------------------------------------------------------------------------

long CTidyHeapFile_AC::Write( const void *data, long size )
{
	if (fRef)
		fErr = ::FSWrite(fRef, &size, data);
	else
		fErr = fnOpnErr;

	ReportErr("Write Failed");

	return size;
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::ReadObject
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::ReadObject(MTidyHeapPersistantObject_AC &inClass )
{
	fErr = 0;
	bool doOpen = !IsOpen();
	
	if (doOpen)
		Open( kRead );
	
	if (!fErr)
	{
		inClass.Read(this);
		if (doOpen)
			Close();
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::WriteObject
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::WriteObject(MTidyHeapPersistantObject_AC &inClass)
{
	fErr = 0;
	bool doOpen = !IsOpen();

	if (doOpen)
		Open(kWrite);
	
	if (!fErr)
	{
		inClass.Write(this);
		if (doOpen)
			Close();
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::SetTypeAndCreator
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::SetTypeAndCreator(OSType inType, OSType inCreator)
{
	fType = inType;
	fCreator = inCreator;
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::SetSpec
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::SetSpec( const FSSpec &inSpec )
{
	CopySpec(&fSpec, &inSpec);
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC assignment operator
//----------------------------------------------------------------------------------------

CTidyHeapFile_AC &CTidyHeapFile_AC::operator = (const CTidyHeapFile_AC &inFile)
{
	fErr = 0;
	fRef = 0;
	fType = inFile.fType;
	fCreator = inFile.fCreator;
	CopySpec(&fSpec, &inFile.fSpec);
	return *this;
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::SetName
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::SetName(const char* inName)
{
	long len = strlen(inName);

	if (len > 31)
	{
		CTidyHeap_AC::PrintDebugString("TidyHeapFile:File Name too long;g");
		len = 31;	
	}
	
	for (short i = 0; i < len; i++)
	{
		fSpec.name[i+1] = inName[i];
	}
	
	fSpec.name[0] = len;
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::SetVolRefNum
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::SetVolRefNum(short inId)
{
	fSpec.vRefNum = inId;
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::SetDirID
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::SetDirID(long inId)
{
	fSpec.parID = inId;
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::GetSize
//----------------------------------------------------------------------------------------
	
long CTidyHeapFile_AC::GetSize()
{
	long eof;
	fErr = ::GetEOF(fRef,&eof);
	
	ReportErr("GetSize Failed");

	return eof;
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::AppendExtension
//----------------------------------------------------------------------------------------
	
void CTidyHeapFile_AC::AppendExtension(const char* inExtension)
{
	const short maxLen = 28;
	
#if !qCarbon
	::p2cstr(fSpec.name);
	short len = ::strlen((char*) fSpec.name);
	
	if (len >= maxLen)
	{
		fSpec.name[maxLen] = '\0';
		len = maxLen; 
	}
	::strcat((char*) fSpec.name, inExtension);
	::c2pstr((char*)fSpec.name);
#else
	char cString[255];
	::CopyPascalStringToC(fSpec.name, &cString[0]);
	short len = ::strlen(&cString[0]);
	if (len >= maxLen)
	{
		cString[maxLen] = '\0';
		len = maxLen; 
	}
	::strcat(cString, inExtension);
	// Now that we have appended the extension save it back to the fSpec.name field.
	::CopyCStringToPascal( cString, fSpec.name);
#endif
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::ReportErr
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::ReportErr(const char* inMessage)
{
	// We have to output to CTidyHeap_AC::PrintDebugString because TidyHeap may not be contructed yet
	// and that case the error wouldn't be reported. Dang.

	if (fErr && fErr != fnfErr)
	{
		CTidyHeap_AC::PrintDebugString("TidyHeap File Error: %d:%s;g", fErr, inMessage);
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeapFile_AC::Specify
//----------------------------------------------------------------------------------------

void CTidyHeapFile_AC::Specify(const char* inName, long inDir, short inVol)
{
	SetName(inName);
	fSpec.parID = inDir;
	fSpec.vRefNum = inVol;
}


#endif

/*
	Historical Change Record:
		----- R11 -----
		07/11/96	initial implementation
*/