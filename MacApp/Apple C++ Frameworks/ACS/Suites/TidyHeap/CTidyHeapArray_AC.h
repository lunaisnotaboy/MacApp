// CTidyHeapArray_AC.h
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.

/*
	Change History
		03/01/01	Do include MemoryUtils_AC. 
		02/14/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		12/08/99	Include Core_AC.h for BlockMove_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __CTidyHeapArray_AC__
#define __CTidyHeapArray_AC__

// ACS

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

#ifndef __MTidyHeapAllocator_AC__
#include "MTidyHeapAllocator_AC.h"
#endif

//----------------------------------------------------------------------------------------
// CTidyHeapArray_AC
//----------------------------------------------------------------------------------------

template <class T>
class EXPORT_AC CTidyHeapArray_AC : public MTidyHeapAllocator_AC
{
public:
	CTidyHeapArray_AC(long inStartSize);
	
	virtual ~CTidyHeapArray_AC();
	
	T& operator[](long index)
	{	
		if(index < 0 || index >= fArraySize)
		{
			CTidyHeap_AC::PrintDebugString("CTidyHeapArray_AC::range error");
			return fArray[0];
		}
		
		return fArray[index]; 
	}

	void ChangeSize(long byAmount);

	long GetSize() const
	{	return fArraySize; }

protected:	
	T* fArray;
	long fArraySize;
};

template <class T>
inline CTidyHeapArray_AC<T>::CTidyHeapArray_AC(long inStartSize)
	: fArray(NULL),
	fArraySize(0)
{
	if(inStartSize) ChangeSize(inStartSize);
}

template <class T>
inline CTidyHeapArray_AC<T>::~CTidyHeapArray_AC()
{
	if(fArray)
		CTidyHeap_AC::GlobalDelete(fArray);
}

template <class T>
void CTidyHeapArray_AC<T>::ChangeSize(long byAmount)
{
	long newSize = fArraySize + byAmount;
 
 	T* newArray = (T*) CTidyHeap_AC::GlobalNew( newSize * sizeof(T));
	
	for( long i = 0; i < newSize; i++)
		newArray[i] = NULL;
	
	if(fArray)
		::BlockMove_AC(fArray, newArray, (fArraySize > newSize ? newSize : fArraySize) * sizeof(T) );
	
	fArraySize = newSize;
	
	T* swapper = fArray;
	fArray = newArray;
	if(swapper) CTidyHeap_AC::GlobalDelete(swapper);
}

#endif // __CTidyHeapArray_AC__