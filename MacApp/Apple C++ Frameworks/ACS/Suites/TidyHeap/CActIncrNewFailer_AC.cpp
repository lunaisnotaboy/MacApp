//----------------------------------------------------------------------------------------
// CActIncrNewFailer_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		07/23/99	Do not call c2pstr in Read.  [C] Changed string usage in
					CActionIncrementalNewFailer_AC.
		03/24/99	Update copyright notice.
*/

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qTidyHeap

#ifndef __CActIncrNewFailer_AC__
#include "CActIncrNewFailer_AC.h"
#endif

#ifndef __TextUtils__
#include <TextUtils.h>
#endif

//========================================================================================
// class CActionIncrementalNewFailer_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// 	CActionIncrementalNewFailer_AC constructor
//----------------------------------------------------------------------------------------

CActionIncrementalNewFailer_AC::CActionIncrementalNewFailer_AC() :
CActionMakeNewFail_AC(0),
fErr(0)
{
	FetchLastAndIncrement();
}

//----------------------------------------------------------------------------------------
// 	CActionIncrementalNewFailer_AC constructor
//----------------------------------------------------------------------------------------

CActionIncrementalNewFailer_AC::CActionIncrementalNewFailer_AC(long whenToFail) :
CActionMakeNewFail_AC(whenToFail),
fErr(0)
{
	SetFailNum(whenToFail);
}

//----------------------------------------------------------------------------------------
// 	CActionIncrementalNewFailer_AC destructor
//----------------------------------------------------------------------------------------

CActionIncrementalNewFailer_AC::~CActionIncrementalNewFailer_AC()
{
}

//----------------------------------------------------------------------------------------
// 	CActionIncrementalNewFailer_AC::Reset
//----------------------------------------------------------------------------------------

void CActionIncrementalNewFailer_AC::Reset()
{
	fNewTally = 0;
	SetFailNum(1);
}

//----------------------------------------------------------------------------------------
// 	CActionIncrementalNewFailer_AC::SetNewCount
//----------------------------------------------------------------------------------------

void CActionIncrementalNewFailer_AC::SetFailNum(long inCount)
{
	fFailNum = inCount;
	
	CTidyHeapFile_AC file;
	file.AppendExtension(".cnt");
	file.WriteObject( *this );
		// write out current fFailNum.
		
}

//----------------------------------------------------------------------------------------
// 	CActionIncrementalNewFailer_AC::FetchLastAndIncrement
//----------------------------------------------------------------------------------------

void CActionIncrementalNewFailer_AC::FetchLastAndIncrement()
{
	fNewTally = 0;
	fFailNum = 0;
	
	CTidyHeapFile_AC file;
	file.AppendExtension(".cnt");
	
	file.ReadObject( *this );
		// read in current value of fFailNum, if it exists.

	++fFailNum;

	file.WriteObject( *this );
		// write out current value of fFailNum
	
}

//----------------------------------------------------------------------------------------
// 	CActionIncrementalNewFailer_AC::Write
//----------------------------------------------------------------------------------------

void CActionIncrementalNewFailer_AC::Write( CTidyHeapFile_AC *inFile )
{
	Str255 str;

	::NumToString( fFailNum, str);
	short len = *str;
	
#if qCarbon
	char cString[255];
	::CopyPascalStringToC(str, &cString[0]);
	inFile->Write( &cString, len);
#else
	::p2cstr(str);
	inFile->Write( (char*) str, len);
#endif
	
	fErr = inFile->GetErr();
}

//----------------------------------------------------------------------------------------
// IsNum
//----------------------------------------------------------------------------------------

inline bool IsNum(char inChar)
{
	return inChar >= '0' && inChar <= '9';
}

//----------------------------------------------------------------------------------------
// 	CActionIncrementalNewFailer_AC::Read
//----------------------------------------------------------------------------------------

void CActionIncrementalNewFailer_AC::Read( CTidyHeapFile_AC *inFile)
{
	Str255 str;
	short len = inFile->GetSize();
	inFile->Read( (char*) str, len);
	fErr = inFile->GetErr();
	
	if(!fErr)
	{
		str[len] = '\0';
		
		short count = 0;
		while( str[count] != '\0' )
		{
			if( !IsNum(str[count++]) )
				break;
		}
		
		str[count] = '\0';

		
		::StringToNum( str, &fFailNum );
	}
}

#endif
/*
	Historical Change Record:
		----- R11 -----
		06/05/96	Initial Implementation
*/