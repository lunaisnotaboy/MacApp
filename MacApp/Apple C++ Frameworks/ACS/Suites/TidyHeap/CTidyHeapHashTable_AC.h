//----------------------------------------------------------------------------------------
// CTidyHeapHashTable_AC.h
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		03/24/99	Update copyright notice.
		03/10/99	Add typename to return value in FindElement.  Argument in FindElement
					and AddElement should be 'T', not 'void *'.
*/

#ifndef __CTidyHeapHashTable_AC__
#define __CTidyHeapHashTable_AC__


#include "CTidyHeap_AC.h"

#include "CTidyHeapArray_AC.h"

#include "CTidyHeapList_AC.h"

#include "CTidyHeapListItem_AC.h"


#ifndef __MTidyHeapAllocator_AC__
#include "MTidyHeapAllocator_AC.h"
#endif


template <class T>
class EXPORT_AC CTidyHeapHashTable_AC : public MTidyHeapAllocator_AC
{
public:
	typedef long (*HashProc)(T inElement);

	class CHashTableLink : public CTidyHeapListItem_AC
	{
	public:
		CHashTableLink(T inElement)
			: fElement(inElement)
		{
		}

		virtual ~CHashTableLink()
		{}
		
		CHashTableLink* Next()
		{	return (CHashTableLink*) CTidyHeapListItem_AC::Next(); }

		T fElement;
	};

	// API
	
	CTidyHeapHashTable_AC(unsigned long tableSize, HashProc inProc);
	
	virtual ~CTidyHeapHashTable_AC();

	void AddElement(T inElement);
	
	CHashTableLink* FindElement(T inElement);
	
	void RemoveElement(CHashTableLink* inLink);

	void FindAndRemoveElement(T inElement)
	{
		RemoveElement(FindElement(inElement));
	}

	long HashIndex(T inElement)

	{
		if(fHashProc)
			return fHashProc(inElement);
		else
		{
			CTidyHeap_AC::PrintDebugString("TidyHeap: No hash proc installed: Hash Failed.;g");
			return 0;
		}	
	}
	
	void DeleteTable();

	long GetNumCollisions() const
	{	return fCollisionsCnt; }
	
	long GetNumElements() const
	{	return fElementCount; }
	
	long GetArraySize() const
	{	return fArray.GetSize(); }

	long GetNumInsertions() const
	{	return fNumInsertions; }
	
	
	
	void PrintStats()
	{
		CTidyHeap_AC::Instance()->Logf("\n### HashTable Stats:");
		CTidyHeap_AC::Instance()->Logf("###    Num Insertions: %ld", GetNumInsertions() );
		CTidyHeap_AC::Instance()->Logf("###    Num Elements in Table: %ld", GetNumElements() );
		CTidyHeap_AC::Instance()->Logf("###    ArraySize: %ld", GetArraySize() );
		CTidyHeap_AC::Instance()->Logf("###    Num empty Slots: %ld", GetArraySize() - (GetNumElements() - GetNumCollisions()));
		CTidyHeap_AC::Instance()->Logf("###    Num Collisions: %ld", GetNumCollisions());
		CTidyHeap_AC::Instance()->Logf("###    MaxSearch: %ld", fMaxSearch);
		CTidyHeap_AC::Instance()->Logf("###    MaxDepth: %ld", fMaxDepth);
	}

private:
	long fCollisionsCnt;
	long fElementCount;
	long fNumInsertions;

	long fMaxSearch;
	long fMaxDepth;
	
	CTidyHeapArray_AC<CTidyHeapList_AC*> 	fArray;
	HashProc								fHashProc;
};

template <class T>
CTidyHeapHashTable_AC<T>::CTidyHeapHashTable_AC(unsigned long tableSize, HashProc inProc)
	: fArray(tableSize),
	fHashProc(inProc),
	fCollisionsCnt(0),
	fElementCount(0),
	fNumInsertions(0),
	fMaxSearch(0),
	fMaxDepth(0)
{
}

template <class T>
CTidyHeapHashTable_AC<T>::~CTidyHeapHashTable_AC()
{
	DeleteTable();
	
}

template <class T>
void CTidyHeapHashTable_AC<T>::DeleteTable()
{
	if(fArray.GetSize())
	{
		for(long i = 0; i < fArray.GetSize(); i++)
		{
			if(fArray[i])
			{
				CTidyHeapListItem_AC* walker = fArray[i]->GetHead();
				CTidyHeapListItem_AC* deleter = NULL;
				
				while(walker)
				{
					deleter = walker;
					
					walker = walker->Next();
					
					fArray[i]->Remove(walker);
					delete walker;
				}
			
				delete fArray[i];
				fArray[i] = NULL;
			}
		}
		
		fElementCount = 0;
	}

}

template <class T>
void CTidyHeapHashTable_AC<T>::AddElement(T inPtr)
{
	long index = HashIndex(inPtr);
	
	if(!fArray[index])
	{
		fArray[index] = new CTidyHeapList_AC;
	}
	else
		fCollisionsCnt++;
		
	fArray[index]->Append( new CHashTableLink(inPtr) ); 
	
	if(fArray[index]->GetCount() > fMaxDepth)
		fMaxDepth = fArray[index]->GetCount();
	
	fElementCount++;
	fNumInsertions++;
}

template <class T>
typename CTidyHeapHashTable_AC<T>::CHashTableLink* CTidyHeapHashTable_AC<T>::FindElement(T inPtr)
{
	long index = HashIndex(inPtr);

	long searchCnt = 0;

	CHashTableLink* walker = 	fArray[index] != NULL ?
								(CHashTableLink*) fArray[index]->GetHead() :
								NULL;
	
	while(walker != NULL)
	{
		searchCnt++;
		
		if(walker->fElement == inPtr)
		{
			break;
		}
		walker = walker->Next();
	}
	
	if(searchCnt > fMaxSearch)
		fMaxSearch = searchCnt;
	
	return walker;
}

template <class T>
void CTidyHeapHashTable_AC<T>::RemoveElement(CHashTableLink* inLink)
{
	if(inLink)
	{
		long index = HashIndex(inLink->fElement);
	
		if(fArray[index])
		{
			fArray[index]->Remove(inLink);
			fElementCount--;
		}
	}

}


#endif