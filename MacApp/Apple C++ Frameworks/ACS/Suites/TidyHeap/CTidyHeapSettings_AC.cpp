//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		02/14/01	Don't include Core_AC. 
		01/02/01	Update copyright.
		11/16/00	Fix typo. Add >> and << helper operators that properly
					route a bool through a Boolean intermediate. 
		11/15/00	sizeof(bool) is 4 on OS X, so use 1 instead
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		12/15/99	[2419286] Global pstrcpy macro causes conflicts. 
		07/23/99	[C] Changed string handling in SetSessionNameToDefault.
		03/24/99	Update copyright notice.
*/

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qTidyHeap

// TidyHeap

#ifndef __CTidyHeapSettings_AC__
#include "CTidyHeapSettings_AC.h"
#endif
#ifndef __CTidyHeapFile_AC__
#include "CTidyHeapFile_AC.h"
#endif

// ACS

// Toolbox

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

#if !(defined(_STRING_H) || defined(__STRING__))
#include <string.h>
#endif

#ifndef __TEXTUTILS__
#include <TextUtils.h>
#endif

//========================================================================================
// class CTidyHeapSettings_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC default constructor
//----------------------------------------------------------------------------------------

CTidyHeapSettings_AC::CTidyHeapSettings_AC()
{
	RevertToDefault();
}

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC copy constructor
//----------------------------------------------------------------------------------------

CTidyHeapSettings_AC::CTidyHeapSettings_AC(const CTidyHeapSettings_AC &inSettings)
{
	*this = inSettings;
}

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC destructor
//----------------------------------------------------------------------------------------

CTidyHeapSettings_AC::~CTidyHeapSettings_AC()
{
}

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC assignment operator
//----------------------------------------------------------------------------------------

CTidyHeapSettings_AC &CTidyHeapSettings_AC::operator = (const CTidyHeapSettings_AC &inSettings)
{
	IsEnabled = inSettings.IsEnabled;
	WantsWarnings = inSettings.WantsWarnings;
	WantsUndeletedBlockWarning = inSettings.WantsUndeletedBlockWarning;
	DoLogUndeletedBlocks = inSettings.DoLogUndeletedBlocks;
	PointersLivesInAppHeap = inSettings.PointersLivesInAppHeap;
	UseTempMemory = inSettings.UseTempMemory;
	WatchForDoubleDeletes = inSettings.WatchForDoubleDeletes;
	PrintExtraInfo = inSettings.PrintExtraInfo;
	
	InstallMakeNewFail = inSettings.InstallMakeNewFail;				
	InstallIncrementalFailer = inSettings.InstallIncrementalFailer;
	InstallNewVerifyAction = inSettings.InstallNewVerifyAction;
	InstallNewVerifyAllAction = inSettings.InstallNewVerifyAllAction;
	InstallExemptUnknownBlocks = inSettings.InstallExemptUnknownBlocks;
	InstallGarbageIn = inSettings.InstallGarbageIn;
	InstallNewBreakOnUnknownBlock = inSettings.InstallNewBreakOnUnknownBlock;
	
		 // Global Delete Actions
	InstallDeleteBreakOnUnknownBlock = inSettings.InstallDeleteBreakOnUnknownBlock;
	InstallDeleteVerifyAction = inSettings.InstallDeleteVerifyAction;
	InstallGarbageOut = inSettings.InstallGarbageOut;
	InstallDeleteVerifyAllAction = inSettings.InstallDeleteVerifyAllAction;
	SettingsModifiedExternally = inSettings.SettingsModifiedExternally;
	
	SetSessionName(inSettings.GetSessionName());
	
	fNewFailCount = inSettings.fNewFailCount;
	fLastWriteSeconds = inSettings.fLastWriteSeconds;
	
	return *this;
}

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC::RevertToDefault
//----------------------------------------------------------------------------------------

void CTidyHeapSettings_AC::RevertToDefault()
{
	SetSessionNameToDefault();
	
	IsEnabled(true);
	WantsWarnings(true);
	WantsUndeletedBlockWarning(true);
	DoLogUndeletedBlocks(true);
	PointersLivesInAppHeap(true);
	UseTempMemory(true);
	WatchForDoubleDeletes(true);
	PrintExtraInfo(true);
	
	// trues
	InstallGarbageIn(true);
	InstallGarbageOut(true);
	InstallDeleteVerifyAction(true);
	InstallNewVerifyAction(true);	
	
	// falses
	InstallMakeNewFail(false);				
	InstallIncrementalFailer(false);	
	InstallNewVerifyAllAction(false);
	InstallExemptUnknownBlocks(false);
	InstallNewBreakOnUnknownBlock(false);
	InstallDeleteBreakOnUnknownBlock(false);
	InstallDeleteVerifyAllAction(false);
	
	SettingsModifiedExternally(false);
		
	fNewFailCount = 0;
	fLastWriteSeconds = 0;
}

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC::Read
//----------------------------------------------------------------------------------------

template<class T>
inline CTidyHeapFile_AC& operator>>(CTidyHeapFile_AC& inFile, T& value)
{
	if (!inFile.GetErr())
	{
		inFile.Read(&value, sizeof(value));
	}
	return inFile;
}

inline CTidyHeapFile_AC& operator>>(CTidyHeapFile_AC& inFile, bool& value)
{
	if (!inFile.GetErr())
	{
		Boolean temp;
		inFile.Read(&temp, sizeof(temp));
		value = temp;
	}
	return inFile;
}

void CTidyHeapSettings_AC::Read(CTidyHeapFile_AC *inFile)
{
	short version;
	
	// prefs
	*inFile >> version;
	
	if(!inFile->GetErr()) 
	{
		if(version != kVersion)
		{
			CTidyHeap_AC::PrintDebugString("TidyHeap: .prf file old version: resetting, and using new format.;g");
		
			inFile->SetErr(true);	
		}
	}
	
	*inFile >> UseTempMemory;
	*inFile >> IsEnabled;
	*inFile >> WantsWarnings;
	*inFile >> WantsUndeletedBlockWarning;
	*inFile >> DoLogUndeletedBlocks;
	*inFile >> PointersLivesInAppHeap;
	*inFile >> WatchForDoubleDeletes;
	*inFile >> PrintExtraInfo;

	// new actions
	*inFile >> InstallGarbageIn;
	*inFile >> InstallMakeNewFail;				
	*inFile >> InstallNewVerifyAction;	
	*inFile >> InstallNewVerifyAllAction;
	*inFile >> InstallNewBreakOnUnknownBlock;
	*inFile >> InstallIncrementalFailer;	
	*inFile >> InstallExemptUnknownBlocks;
	
	// delete actions
	*inFile >> InstallGarbageOut;
	*inFile >> InstallDeleteBreakOnUnknownBlock;
	*inFile >> InstallDeleteVerifyAllAction;
	*inFile >> InstallDeleteVerifyAction;	

	// session name	
	if(!inFile->GetErr()) inFile->Read(fSessionName, kNameSize);

	// new fail count
	*inFile >> fNewFailCount;

	if(!inFile->GetErr())
	{
		// We're going to allow this to fail so we remain compatible with
		// old formats.
	
		*inFile >> SettingsModifiedExternally;
		*inFile >> fLastWriteSeconds;
		
		if(inFile->GetErr())
			inFile->SetErr(noErr);
	}
	
	if(inFile->GetErr()) 
	{
		RevertToDefault();
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC::Write
//----------------------------------------------------------------------------------------

template<class T>
inline CTidyHeapFile_AC& operator<<(CTidyHeapFile_AC& inFile, T value)
{
	if (!inFile.GetErr())
	{
		inFile.Write(&value, sizeof(value));
	}
	return inFile;
}

inline CTidyHeapFile_AC& operator<<(CTidyHeapFile_AC& inFile, bool value)
{
	if (!inFile.GetErr())
	{
		Boolean temp = value;
		inFile.Write(&temp, sizeof(temp));
	}
	return inFile;
}

void CTidyHeapSettings_AC::Write(CTidyHeapFile_AC *inFile)
{
	// prefs
	short version = kVersion;
	
	*inFile << version;
	*inFile << UseTempMemory;
	*inFile << IsEnabled;
	*inFile << WantsWarnings;
	*inFile << WantsUndeletedBlockWarning;
	*inFile << DoLogUndeletedBlocks;
	*inFile << PointersLivesInAppHeap;
	*inFile << WatchForDoubleDeletes;
	*inFile << PrintExtraInfo;

	// new actions
	*inFile << InstallGarbageIn;
	*inFile << InstallMakeNewFail;				
	*inFile << InstallNewVerifyAction;	
	*inFile << InstallNewVerifyAllAction;
	*inFile << InstallNewBreakOnUnknownBlock;
	*inFile << InstallIncrementalFailer;	
	*inFile << InstallExemptUnknownBlocks;
	
	// delete actions
	*inFile << InstallGarbageOut;
	*inFile << InstallDeleteBreakOnUnknownBlock;
	*inFile << InstallDeleteVerifyAllAction;
	*inFile << InstallDeleteVerifyAction;	

	if(!inFile->GetErr())
		inFile->Write(fSessionName, kNameSize );

	*inFile << fNewFailCount;
		
	if(!inFile->GetErr())
	{
		SettingsModifiedExternally(false);
		*inFile << SettingsModifiedExternally;
	}
	
	if(!inFile->GetErr())
	{
		GetDateTime(&fLastWriteSeconds);
		*inFile << fLastWriteSeconds;
	}
}

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC::SetSessionName
//----------------------------------------------------------------------------------------

void CTidyHeapSettings_AC::SetSessionName(const char* inStr)
{
	::strcpy(fSessionName, inStr);
	::Assertion_AC(::strlen(fSessionName) < sizeof(fSessionName),
				   "CTidyHeapSettings_AC::SetSessionName: Write beyond end of fSessionName.");
}

//----------------------------------------------------------------------------------------
// CTidyHeapSettings_AC::SetSessionNameToDefault
//----------------------------------------------------------------------------------------

inline void pstrcpy(unsigned char *dest, const unsigned char *src)
{
	::BlockMove_AC( (src), (dest), *(src) + 1 );
}

void CTidyHeapSettings_AC::SetSessionNameToDefault()
{
	Str255 temp;
	pstrcpy(temp, LMGetCurApName());
	
	#if !qCarbon
		p2cstr(temp);
		SetSessionName((char*) temp);
	#else
		char cString[255];
		::CopyPascalStringToC(temp, &cString[0]);
		SetSessionName(&cString[0]);
	#endif

	
}


#endif // qTidyHeap
