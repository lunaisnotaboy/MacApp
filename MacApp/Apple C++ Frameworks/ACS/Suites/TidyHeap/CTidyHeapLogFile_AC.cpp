//----------------------------------------------------------------------------------------
// CTidyHeapLogFile_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		01/02/01	Update copyright.
		11/01/00	[PB] Include MacErrors instead of Errors. 
		10/17/00	Shorten the file names CTidyHeapDebugStrLogger_AC.h, .cpp and 
					CTidyHeapLogFileLogger_AC.h, .cpp so they don't blow up MakeDepend. 
		12/27/99	Minor cosmetic cleanup.
		12/08/99	Fixed file name in banner.
		03/24/99	Update copyright notice.
*/

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

#if qTidyHeap

#ifndef __CTidyHeapLogFile_AC__
#include "CTidyHeapLogFile_AC.h"
#endif

// toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// ANSI

#if !(defined(_STRING_H) || defined(__STRING__))
#include <string.h>
#endif

//========================================================================================
// class CTidyHeapLogFileLogger_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CTidyHeapLogFileLogger_AC constructor
//----------------------------------------------------------------------------------------

CTidyHeapLogFileLogger_AC::CTidyHeapLogFileLogger_AC() 
{
	fFile.AppendExtension(".log");
	fFile.SetTypeAndCreator('TEXT','MPS ');
}

//----------------------------------------------------------------------------------------
// CTidyHeapLogFileLogger_AC destructor
//----------------------------------------------------------------------------------------

CTidyHeapLogFileLogger_AC::~CTidyHeapLogFileLogger_AC()
{
}

//----------------------------------------------------------------------------------------
// CTidyHeapLogFileLogger_AC::Log
//----------------------------------------------------------------------------------------

void CTidyHeapLogFileLogger_AC::Log(const char* inStr)
{
	static bool gotError = false;
	
	if(!gotError)
	{
		if(!fFile.IsOpen())
			fFile.Open(CTidyHeapFile_AC::kWrite);
	
		if(fFile.GetErr())
			gotError = true;
		else
		{
			static char lineFeed = 0xD;
			
			fFile.Write(inStr, strlen(inStr));
			fFile.Write(&lineFeed, sizeof(lineFeed));
		}
	}
}

#endif
/*
	Historical Change Record:
		----- R11 -----
		06/26/96	Install release marker.  Scope many globals.  Change TRUE/FALSE/NULL.
		06/25/96	[1345531] Added missing includes for noload buids
		06/19/96 	mwf		[1357827] now make mpw file not metrowerks.
		06/05/96	Initial Implementation
*/

//----------------------------------------------------------------------------------------
// End of CTidyHeapLogFile_AC.cpp
