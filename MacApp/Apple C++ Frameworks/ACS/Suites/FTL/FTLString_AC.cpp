//----------------------------------------------------------------------------------------
// FTLString_AC.cpp
// Copyright © 1999-2001 by Apple Computer, Inc., all rights reserved.
//----------------------------------------------------------------------------------------

// Contains:	Foundation Template Library strings

/*
	Change History:
		07/24/01	Change FTLString to a non-template class. Move implementation 
							out of line. Add constructors and operators for standard and 
							CF strings. Work around different char traits and iterator 
							implementation in g++ STL. 
							Fix some syntax errors. Work around a problem with compiling 
							in '+' functions. Fill in the stream and getline functions. 
		05/03/01	Consolidate inlines. 
		01/02/01	Update copyright.
		10/31/00	Move to ACS. 
		07/29/00	Build standalone without ACS. 
		07/24/00	CW Pro 6: namespacing. 
		07/14/00	Initial version. 
*/

#ifndef __FTLString_AC__
#include "FTLString_AC.h"
#endif

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

// Standard Library

#include <iostream>


//========================================================================================
// Global Functions
//========================================================================================

void ThrowIteratorsMustBeOnSame()
{
	ThrowLogicError_AC("iterators must be on the same string");
}

void ThrowIteratorMustBeOnThis()
{
	ThrowInvalidArgument_AC("iterator must be on this string");
}

void ThrowPositionMustBeInString()
{
	ThrowOutOfRange_AC("position must be within string");
}

void ThrowCharacterCountRequired()
{
	ThrowOutOfRange_AC("character count must be >= 0");
}

void ThrowLengthRequired()
{
	ThrowLengthError_AC("length required");
}


//========================================================================================
// FTLString_AC::proxy
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

FTLString_AC::proxy::proxy(FTLString_AC& str, size_type pos)
	:	fString(str),
		fPos(pos)
{
}

//----------------------------------------------------------------------------------------
// operator char
//----------------------------------------------------------------------------------------

#if 0 // Error   : illegal operator 
FTLString_AC::proxy::operator char() const
{
	return fString[fPos];
}
#endif

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

FTLString_AC::proxy& FTLString_AC::proxy::operator=(char c)
{
	fString.replace(fPos, 1, 1, c);
	return *this;
}


//========================================================================================
// FTLString_AC::iterator
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

FTLString_AC::iterator::iterator(FTLString_AC& str, size_type pos)
	:	fString(&str),
		fPos(pos)
{
}

FTLString_AC::iterator::iterator()
	:	fString(NULL),
		fPos(npos)
{
}

FTLString_AC::iterator::iterator(const iterator& iter)
	:	fString(iter.fString),
		fPos(iter.fPos)
{
}

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

FTLString_AC::iterator& FTLString_AC::iterator::operator=(const iterator& rhs)
{
	fString = rhs.fString;
	fPos = rhs.fPos;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator*
//----------------------------------------------------------------------------------------

FTLString_AC::proxy FTLString_AC::iterator::operator*() const
{
	return proxy(*fString, fPos);
}

//----------------------------------------------------------------------------------------
// operator->
//----------------------------------------------------------------------------------------

FTLString_AC::iterator FTLString_AC::iterator::operator->() const
{
	return iterator(*this);
}

//----------------------------------------------------------------------------------------
// operator++
//----------------------------------------------------------------------------------------

FTLString_AC::iterator& FTLString_AC::iterator::operator++()
{
	++fPos;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator++(int)
//----------------------------------------------------------------------------------------

FTLString_AC::iterator FTLString_AC::iterator::operator++(int)
{
	iterator result(*this);
	++fPos;
	return result;
}

//----------------------------------------------------------------------------------------
// operator--
//----------------------------------------------------------------------------------------

FTLString_AC::iterator& FTLString_AC::iterator::operator--()
{
	--fPos;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator--(int)
//----------------------------------------------------------------------------------------

FTLString_AC::iterator FTLString_AC::iterator::operator--(int)
{
	iterator result(*this);
	--fPos;
	return result;
}

//----------------------------------------------------------------------------------------
// operator+=
//----------------------------------------------------------------------------------------

FTLString_AC::iterator& FTLString_AC::iterator::operator+=(difference_type n)
{
	fPos += n;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator+
//----------------------------------------------------------------------------------------

FTLString_AC::iterator FTLString_AC::iterator::operator+(difference_type n)
{
	iterator temp(*this);
	temp += n;
	return temp;
}

//----------------------------------------------------------------------------------------
// operator-=
//----------------------------------------------------------------------------------------

FTLString_AC::iterator& FTLString_AC::iterator::operator-=(difference_type n)
{
	fPos -= n;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator-
//----------------------------------------------------------------------------------------

FTLString_AC::iterator FTLString_AC::iterator::operator-(difference_type n)
{
	iterator temp(*this);
	temp -= n;
	return temp;
}

#if 0	// Error   : illegal function overloading
FTLString_AC::difference_type FTLString_AC::iterator::operator-(const iterator& rhs) const
{
	if (fString != rhs.fString)
		ThrowIteratorsMustBeOnSame();

	return fPos - rhs.fPos;
}
#endif

//----------------------------------------------------------------------------------------
// operator[]
//----------------------------------------------------------------------------------------

FTLString_AC::proxy FTLString_AC::iterator::operator[](size_type i) const
{
	return proxy(*fString, fPos + i);
}

//----------------------------------------------------------------------------------------
// operator==
//----------------------------------------------------------------------------------------

bool FTLString_AC::iterator::operator==(const FTLString_AC::iterator& rhs) const
{
	return (fString == rhs.fString) && (fPos == rhs.fPos);
}

//----------------------------------------------------------------------------------------
// operator!=
//----------------------------------------------------------------------------------------

bool FTLString_AC::iterator::operator!=(const FTLString_AC::iterator& rhs) const
{
	return !(*this == rhs);
}

//----------------------------------------------------------------------------------------
// operator<
//----------------------------------------------------------------------------------------

bool FTLString_AC::iterator::operator<(const FTLString_AC::iterator& rhs) const
{
	return (fString < rhs.fString) || ((fString == rhs.fString) && (fPos < rhs.fPos));
}

//----------------------------------------------------------------------------------------
// operator>
//----------------------------------------------------------------------------------------

bool FTLString_AC::iterator::operator>(const FTLString_AC::iterator& rhs) const
{
	return (fString > rhs.fString) || ((fString == rhs.fString) && (fPos > rhs.fPos));
}

//----------------------------------------------------------------------------------------
// operator<=
//----------------------------------------------------------------------------------------

bool FTLString_AC::iterator::operator<=(const FTLString_AC::iterator& rhs) const
{
	return !(*this > rhs);
}

//----------------------------------------------------------------------------------------
// operator>=
//----------------------------------------------------------------------------------------

bool FTLString_AC::iterator::operator>=(const FTLString_AC::iterator& rhs) const
{
	return !(*this < rhs);
}

//----------------------------------------------------------------------------------------
// operator+
//----------------------------------------------------------------------------------------

FTLString_AC::iterator operator+(FTLString_AC::difference_type n, const FTLString_AC::iterator& rhs)
{
#if 0
	return rhs + n;
#else
	// Workaround because the line above doesn't compile with CW Pro 6
	FTLString_AC::iterator temp(rhs);
	temp += n;
	return temp;
#endif
}


//========================================================================================
// FTLString_AC::const_iterator
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator::const_iterator(const FTLString_AC& str, size_type pos)
	:	fString(&str),
		fPos(pos)
{
}

FTLString_AC::const_iterator::const_iterator()
	:	fString(NULL),
		fPos(npos)
{
}

FTLString_AC::const_iterator::const_iterator(const const_iterator& iter)
	:	fString(iter.fString),
		fPos(iter.fPos)
{
}

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator& FTLString_AC::const_iterator::operator=(const const_iterator& rhs)
{
	fString = rhs.fString;
	fPos = rhs.fPos;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator*
//----------------------------------------------------------------------------------------

char FTLString_AC::const_iterator::operator*() const
{
	return (*fString)[fPos];
}

//----------------------------------------------------------------------------------------
// operator->
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator FTLString_AC::const_iterator::operator->() const
{
	return const_iterator(*this);
}

//----------------------------------------------------------------------------------------
// operator++
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator& FTLString_AC::const_iterator::operator++()
{
	++fPos;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator++(int)
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator FTLString_AC::const_iterator::operator++(int)
{
	const_iterator result(*this);
	++fPos;
	return result;
}

//----------------------------------------------------------------------------------------
// operator--
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator& FTLString_AC::const_iterator::operator--()
{
	--fPos;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator--(int)
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator FTLString_AC::const_iterator::operator--(int)
{
	const_iterator result(*this);
	--fPos;
	return result;
}

//----------------------------------------------------------------------------------------
// operator+=
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator& FTLString_AC::const_iterator::operator+=(difference_type n)
{
	fPos += n;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator+
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator FTLString_AC::const_iterator::operator+(difference_type n)
{
	const_iterator temp(*this);
	temp += n;
	return temp;
}

//----------------------------------------------------------------------------------------
// operator-=
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator& FTLString_AC::const_iterator::operator-=(difference_type n)
{
	fPos -= n;
	return *this;
}

//----------------------------------------------------------------------------------------
// operator-
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator FTLString_AC::const_iterator::operator-(difference_type n)
{
	const_iterator temp(*this);
	temp -= n;
	return temp;
}

#if 0	// Error   : illegal function overloading
FTLString_AC::difference_type FTLString_AC::const_iterator::operator-(const const_iterator& rhs) const
{
	if (fString != rhs.fString)
		ThrowIteratorsMustBeOnSame();

	return fPos - rhs.fPos;
}
#endif

//----------------------------------------------------------------------------------------
// operator[]
//----------------------------------------------------------------------------------------

char FTLString_AC::const_iterator::operator[](size_type i) const
{
	return (*fString)[fPos + i];
}

//----------------------------------------------------------------------------------------
// operator==
//----------------------------------------------------------------------------------------

bool FTLString_AC::const_iterator::operator==(const FTLString_AC::const_iterator& rhs) const
{
	return (fString == rhs.fString) && (fPos == rhs.fPos);
}

//----------------------------------------------------------------------------------------
// operator!=
//----------------------------------------------------------------------------------------

bool FTLString_AC::const_iterator::operator!=(const FTLString_AC::const_iterator& rhs) const
{
	return !(*this == rhs);
}

//----------------------------------------------------------------------------------------
// operator<
//----------------------------------------------------------------------------------------

bool FTLString_AC::const_iterator::operator<(const FTLString_AC::const_iterator& rhs) const
{
	return (fString < rhs.fString) || ((fString == rhs.fString) && (fPos < rhs.fPos));
}

//----------------------------------------------------------------------------------------
// operator>
//----------------------------------------------------------------------------------------

bool FTLString_AC::const_iterator::operator>(const FTLString_AC::const_iterator& rhs) const
{
	return (fString > rhs.fString) || ((fString == rhs.fString) && (fPos > rhs.fPos));
}

//----------------------------------------------------------------------------------------
// operator<=
//----------------------------------------------------------------------------------------

bool FTLString_AC::const_iterator::operator<=(const FTLString_AC::const_iterator& rhs) const
{
	return !(*this > rhs);
}

//----------------------------------------------------------------------------------------
// operator>=
//----------------------------------------------------------------------------------------

bool FTLString_AC::const_iterator::operator>=(const FTLString_AC::const_iterator& rhs) const
{
	return !(*this < rhs);
}

//----------------------------------------------------------------------------------------
// operator+
//----------------------------------------------------------------------------------------

FTLString_AC::const_iterator operator+(FTLString_AC::difference_type n, const FTLString_AC::const_iterator& rhs)
{
#if 0
	return rhs + n;
#else
	// Workaround because the line above doesn't compile with CW Pro 6
	FTLString_AC::const_iterator temp(rhs);
	temp += n;
	return temp;
#endif
}


//========================================================================================
// FTLString_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// constructor
//----------------------------------------------------------------------------------------

//  Effects:
//    Constructs  an  object of class FTLString_AC.  The postconditions of
//    this function are indicated in Table 3:
//
//              Table 3--FTLString_AC() effects
//
//  +----------------------------------------------------------------------------+
//  | Element                                 Value                              |
//  +----------------------------------------------------------------------------+
//  |data()       a non-null pointer that is copyable and can have 0 added to it |
//  |size()       0                                                              |
//  |capacity()   an unspecified value                                           |
//  +----------------------------------------------------------------------------+

FTLString_AC::FTLString_AC()
	:	fCFString(__CFString::kUnlimited)
{
}

//  Requires:
//    pos <= str.size()
//  Throws:
//    out_of_range if pos > str.size().
//  Effects:
//    Constructs an object of class FTLString_AC and determines the effec-
//    tive length rlen of the initial string value as the smaller of n and
//    str.size() - pos, as indicated in Table 4:
//
//    Table 4--FTLString_AC(FTLString_AC,size_type,size_type) effects
//
//          +------------------------------------------------------+
//          |    Element                      Value                |
//          +------------------------------------------------------+
//          |data()            points at the first element  of  an |
//          |                  allocated  copy of rlen consecutive |
//          |                  elements of the  string  controlled |
//          |                  by str beginning at position pos    |
//          |size()            rlen                                |
//          |capacity()        a value at least as large as size() |
//          |get_allocator()   str.get_allocator()                 |
//          +------------------------------------------------------+

FTLString_AC::FTLString_AC(const FTLString_AC& str, size_type pos, size_type n)
	:	fCFString()
{
	difference_type rlen = str.size() - pos;
	if (rlen < 0)
		ThrowPositionMustBeInString();

	if ((n != npos) && (n < static_cast<unsigned>(rlen)))
		rlen = n;

	CAutoCFString_AC substring(str.fCFString, CCFRange_AC(pos, rlen));
	fCFString = __CFString::CreateMutableCopy(NULL, __CFString::kUnlimited, substring);
}

//  Requires:
//    s shall not be a null pointer and n < npos.
//  Throws:
//    out_of_range if n == npos.
//  Effects:
//    Constructs  an  object of class FTLString_AC and determines its ini-
//    tial string value from the array of char of length  n  whose  first
//    element is designated by s, as indicated in Table 5:
//
//    Table 5--FTLString_AC(const char*,size_type) effects
//
//             +-------------------------------------------------+
//             | Element                    Value                |
//             +-------------------------------------------------+
//             |data()       points  at  the first element of an |
//             |             allocated copy of the  array  whose |
//             |             first element is pointed at by s    |
//             |size()       n                                   |
//             |capacity()   a value at least as large as size() |
//             +-------------------------------------------------+

FTLString_AC::FTLString_AC(const char* s, size_type n)
	:	fCFString()
{
	if (!s)
		ThrowInvalidArgument_AC();

	if (n == npos)
		ThrowCharacterCountRequired();

	fCFString = __CFString::CreateMutableWithBytes(s, n, false, __CFString::kUnlimited);
}

//  Requires:
//    s shall not be a null pointer.
//  Effects:
//    Constructs  an  object of class FTLString_AC and determines its ini-
//    tial  string   value   from   the   array   of   char   of   length
//    traits::length(s)  whose first element is designated by  s, as indi-
//    cated in Table 6:
//
//        Table 6--FTLString_AC(const char*) effects
//
//             +-------------------------------------------------+
//             | Element                    Value                |
//             +-------------------------------------------------+
//             |data()       points at the first element  of  an |
//             |             allocated  copy  of the array whose |
//             |             first element is pointed at by s    |
//             |size()       traits::length(s)                   |
//             |capacity()   a value at least as large as size() |
//             +-------------------------------------------------+

FTLString_AC::FTLString_AC(const char* s)
	:	fCFString()
{
	if (!s)
		ThrowInvalidArgument_AC();

	fCFString = __CFString::CreateMutableWithBytes(s, traits_type::length(s), false, __CFString::kUnlimited);
}

//  Requires:
//    n < npos
//  Throws:
//    length_error if n == npos.
//  Effects:
//    Constructs an object of class FTLString_AC and determines  its  ini-
//    tial string value by repeating the char-like object c for all n ele-
//    ments, as indicated in Table 7:
//
//      Table 7--FTLString_AC(size_type,char) effects
//
//             +-------------------------------------------------+
//             | Element                    Value                |
//             +-------------------------------------------------+
//             |data()       points at the first element  of  an |
//             |             allocated array of n elements, each |
//             |             storing the initial value c         |
//             |size()       n                                   |
//             |capacity()   a value at least as large as size() |
//             +-------------------------------------------------+

FTLString_AC::FTLString_AC(size_type n, char c)
	:	fCFString(__CFString::kUnlimited)
{
	if (n == npos)
		ThrowLengthRequired();

	if (n > 0)
	{
		if (c)
		{
			char padCString[2] = {c, 0};
			fCFString->Pad(__CFStringMakeConstantString(padCString), n, 0);
		}
		else
		{
#if 0 && qDebug
			Warning(c, "padding with NULL characters doesn't seem to work");
#endif
		}
	}
}

#if 0
//  Effects:
//    Constructs a string from the values in the range  [first,  last),  as
//    indicated in Table 8:
//
//    Table 8--FTLString_AC(InputIterator,InputIterator) effects
//
//             +-------------------------------------------------+
//             | Element                    Value                |
//             +-------------------------------------------------+
//             |data()       points  at  the first element of an |
//             |             allocated copy of the  elements  in |
//             |             the range [begin,end)               |
//             |size()       distance between begin and end      |
//             |capacity()   a value at least as large as size() |
//             +-------------------------------------------------+
//  Notes:
//    see clause _lib.sequence.reqmts_.

template<class InputIterator>
FTLString_AC::FTLString_AC(InputIterator first, InputIterator last)
	:	fCFString()
{
	std::string temp(first, last);
	fCFString = __CFString::CreateMutableWithBytes(temp.data(), temp.size(), false, __CFString::kUnlimited);
}
#endif

FTLString_AC::FTLString_AC(const std::string& str)
	:	fCFString(__CFString::CreateMutableWithBytes(str.data(), str.size(), false, __CFString::kUnlimited))
{
}

FTLString_AC::FTLString_AC(CFStringRef cfstr)
	:	fCFString(__CFString::CreateMutableCopy(NULL, __CFString::kUnlimited, cfstr))
{
}

//----------------------------------------------------------------------------------------
// destructor
//----------------------------------------------------------------------------------------

FTLString_AC::~FTLString_AC()
{
}

//----------------------------------------------------------------------------------------
// operator=
//----------------------------------------------------------------------------------------

//  Effects:
//    If *this and str are not the same object, modifies *this as shown in
//    Table 9:
//
//    Table 9--operator=(const FTLString_AC&) effects
//
//             +-------------------------------------------------+
//             | Element                    Value                |
//             +-------------------------------------------------+
//             |data()       points at the first element  of  an |
//             |             allocated  copy  of the array whose |
//             |             first  element  is  pointed  at  by |
//             |             str.data()                          |
//             |size()       str.size()                          |
//             |capacity()   a value at least as large as size() |
//             +-------------------------------------------------+
//    If *this and str are the same object, the member has no effect.

FTLString_AC& FTLString_AC::operator=(const FTLString_AC& str)
{
	return assign(str);
}

FTLString_AC& FTLString_AC::operator=(const char* s)
{
	return assign(s);
}

FTLString_AC& FTLString_AC::operator=(char c)
{
	return assign(1, c);
}

FTLString_AC& FTLString_AC::operator=(const std::string& str)
{
	return assign(str.data(), str.length());
}

FTLString_AC& FTLString_AC::operator=(CFStringRef cfstr)
{
	if (fCFString != cfstr)
		fCFString = __CFString::CreateMutableCopy(NULL, __CFString::kUnlimited, cfstr);
	return *this;
}

//----------------------------------------------------------------------------------------
// iterator support
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// begin
//----------------------------------------------------------------------------------------

//  Returns:
//    an iterator referring to the first character in the string.

FTLString_AC::iterator FTLString_AC::begin()
{
	return iterator(*this, 0);
}

FTLString_AC::const_iterator FTLString_AC::begin() const
{
	return const_iterator(*this, 0);
}

//----------------------------------------------------------------------------------------
// end
//----------------------------------------------------------------------------------------

//  Returns:
//    an iterator which is the past-the-end value.

FTLString_AC::iterator FTLString_AC::end()
{
	return iterator(*this, size());
}

FTLString_AC::const_iterator FTLString_AC::end() const
{
	return const_iterator(*this, size());
}

//----------------------------------------------------------------------------------------
// rbegin
//----------------------------------------------------------------------------------------

//  Returns:
//    an  iterator  which  is  semantically  equivalent  to reverse_itera-
//    tor(end()).

FTLString_AC::reverse_iterator FTLString_AC::rbegin()
{
	return reverse_iterator(end());
}

FTLString_AC::const_reverse_iterator FTLString_AC::rbegin() const
{
	return const_reverse_iterator(end());
}

//----------------------------------------------------------------------------------------
// rend
//----------------------------------------------------------------------------------------

//  Returns:
//    an iterator  which  is  semantically  equivalent  to  reverse_itera-
//    tor(begin()).

FTLString_AC::reverse_iterator FTLString_AC::rend()
{
	return reverse_iterator(begin());
}

FTLString_AC::const_reverse_iterator FTLString_AC::rend() const
{
	return const_reverse_iterator(begin());
}

//----------------------------------------------------------------------------------------
// capacity
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// size
//----------------------------------------------------------------------------------------

//  Returns:
//    a  count of the number of char-like objects currently in the string.

FTLString_AC::size_type FTLString_AC::size() const
{
	size_type mySize = fCFString->GetLength();
	return mySize;
}

//----------------------------------------------------------------------------------------
// length
//----------------------------------------------------------------------------------------

FTLString_AC::size_type FTLString_AC::length() const
{
	return size();
}

//----------------------------------------------------------------------------------------
// max_size
//----------------------------------------------------------------------------------------

//  Returns:
//    The maximum size of the string.

FTLString_AC::size_type FTLString_AC::max_size() const
{
	// CFString doesn't support a maximum size, so just return
	// a very large number. 
	return 0x7FFFFFFF;
}

//----------------------------------------------------------------------------------------
// resize
//----------------------------------------------------------------------------------------

//  Requires:
//    n <= max_size()
//  Throws:
//    length_error if n > max_size().
//  Effects:
//    Alters the length of the string designated by *this as follows:
//
//  --If n <= size(), the function replaces the string designated by *this
//    with  a  string of length n whose elements are a copy of the initial
//    elements of the original string designated by *this.
//
//  --If n > size(), the function replaces the string designated by  *this
//    with  a string of length n whose first size() elements are a copy of
//    the original string designated by *this, and  whose  remaining  ele-
//    ments are all initialized to c.

void FTLString_AC::resize(size_type n, char c)
{
	char padCString[2] = {c, 0};
	fCFString->Pad(__CFStringMakeConstantString(padCString), n, 0);
}

//  Effects:
//    resize(n,char()).

void FTLString_AC::resize(size_type /*n*/)
{
	// CFString doesn't provide direct control over the string storage size
}

//----------------------------------------------------------------------------------------
// capacity
//----------------------------------------------------------------------------------------

//  Returns:
//    the size of the allocated storage in the string.

FTLString_AC::size_type FTLString_AC::capacity() const
{
	// CFString doesn't support a maximum size, so just return
	// a very large number. 
	return 0x7FFFFFFF;
}

//----------------------------------------------------------------------------------------
// reserve
//----------------------------------------------------------------------------------------

//1 The   member   function  reserve()  is  a  directive  that  informs  a
//  FTLString_AC object of a planned change in size, so that it can manage
//  the storage allocation accordingly.
//  Effects:
//    After  reserve(),  capacity() is greater or equal to the argument of
//    reserve.  Reallocation invalidates all the references, pointers, and
//    iterators referring to the elements in the sequence.

void FTLString_AC::reserve(size_type /*res_arg*/)
{
	// CFString doesn't provide direct control over the string storage size
}

//----------------------------------------------------------------------------------------
// clear
//----------------------------------------------------------------------------------------

//  Effects:
//    Behaves as if the function calls:
//
//  erase(begin(), end());

void FTLString_AC::clear()
{
	fCFString->Delete(CCFRange_AC(0, size()));
}

//----------------------------------------------------------------------------------------
// empty
//----------------------------------------------------------------------------------------

bool FTLString_AC::empty() const
{
	return size() == 0;
}

//----------------------------------------------------------------------------------------
// element access
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// operator[]
//----------------------------------------------------------------------------------------

//  Effects:
//    The  reference  returned  is  invalid  after  any subsequent call to
//    c_str(), data(), or any non-const member function for the object.
//  Returns:
//    If pos < size(), returns data()[pos].  Otherwise, if pos ==  size(),
//    the const version returns traits::eos().  Otherwise, the behavior is
//    undefined.

char FTLString_AC::operator[](size_type pos) const
{
	return at(pos);
}

FTLString_AC::proxy FTLString_AC::operator[](size_type pos)
{
	return at(pos);
}

//----------------------------------------------------------------------------------------
// at
//----------------------------------------------------------------------------------------

//  Requires:
//    pos < size()
//  Throws:
//    out_of_range if pos >= size().
//  Returns:
//    operator[](pos).

char FTLString_AC::at(size_type pos) const
{
	char theChar = fCFString->GetCharacterAtIndex(pos);
	return theChar;
}

FTLString_AC::proxy FTLString_AC::at(size_type pos)
{
	return proxy(*this, pos);
}

//----------------------------------------------------------------------------------------
// modifiers
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// operator+=
//----------------------------------------------------------------------------------------

FTLString_AC& FTLString_AC::operator+=(const FTLString_AC& str)
{
	return append(str);
}

FTLString_AC& FTLString_AC::operator+=(const char* s)
{
	return append(s);
}

FTLString_AC& FTLString_AC::operator+=(char c)
{
	return append(1, c);
}

//----------------------------------------------------------------------------------------
// append
//----------------------------------------------------------------------------------------

FTLString_AC& FTLString_AC::append(const FTLString_AC& str)
{
	fCFString->Append(str.fCFString);
	return *this;
}

//  Requires:
//    pos <= str.size()
//  Throws:
//    out_of_range if pos > str.size().
//
//  Effects:
//    Determines the effective length rlen of the string to append as  the
//    smaller  of  n  and  str.size()  -  pos.   The  function then throws
//    length_error if size() >= npos - rlen.
//    Otherwise, the function replaces the string controlled by *this with
//    a  string  of length size() + rlen whose first size() elements are a
//    copy of the original string controlled by *this and whose  remaining
//    elements are a copy of the initial elements of the string controlled
//    by str beginning at position pos.

FTLString_AC& FTLString_AC::append(const FTLString_AC& str, size_type pos, size_type n)
{
	return append(FTLString_AC(str, pos, n));
}

FTLString_AC& FTLString_AC::append(const char* s, size_type n)
{
	return append(FTLString_AC(s, n));
}

FTLString_AC& FTLString_AC::append(const char* s)
{
#if 0
	return append(FTLString_AC(s));
#else
	fCFString->AppendCString(s);
	return *this;
#endif
}

FTLString_AC& FTLString_AC::append(size_type n, char c)
{
	return append(FTLString_AC(n, c));
}

#if 0
template<class InputIterator>
FTLString_AC& FTLString_AC::append(InputIterator first, InputIterator last)
{
	std::string temp(first, last);
	append(temp.data(), temp.size());

	return *this;
}
#endif

//----------------------------------------------------------------------------------------
// assign
//----------------------------------------------------------------------------------------

FTLString_AC& FTLString_AC::assign(const FTLString_AC& str)
{
	if (this != &str)
		fCFString = __CFString::CreateMutableCopy(NULL, __CFString::kUnlimited, str.fCFString);

	return *this;
}

//  Requires:
//    pos <= str.size()
//  Throws:
//    out_of_range if pos > str.size().
//  Effects:
//    Determines the effective length rlen of the string to assign as  the
//    smaller of n and str.size() - pos.
//    The  function  then  replaces  the string controlled by *this with a
//    string of length rlen whose elements are a copy of the  string  con-
//    trolled by str beginning at position pos.

FTLString_AC& FTLString_AC::assign(const FTLString_AC& str, size_type pos, size_type n)
{
	return assign(FTLString_AC(str, pos, n));
}

FTLString_AC& FTLString_AC::assign(const char* s, size_type n)
{
	if (!s)
		ThrowInvalidArgument_AC();

	fCFString = __CFString::CreateMutableWithBytes(s, n, false, __CFString::kUnlimited);
	return *this;
}

FTLString_AC& FTLString_AC::assign(const char* s)
{
	if (!s)
		ThrowInvalidArgument_AC();

	fCFString = __CFString::CreateMutableWithBytes(s, traits_type::length(s), false, __CFString::kUnlimited);
	return *this;
}

FTLString_AC& FTLString_AC::assign(size_type n, char c)
{
	return assign(FTLString_AC(n, c));
}

#if 0
template<class InputIterator>
FTLString_AC& FTLString_AC::assign(InputIterator first, InputIterator last)
{
	std::string temp(first, last);
	fCFString = __CFString::CreateMutableWithBytes(temp.data(), temp.size(), false, __CFString::kUnlimited);
}
#endif

//----------------------------------------------------------------------------------------
// insert
//----------------------------------------------------------------------------------------

FTLString_AC& FTLString_AC::insert(size_type pos1, const FTLString_AC& str)
{
	if (pos1 > size())
		ThrowPositionMustBeInString();

	fCFString->Insert(pos1, str.fCFString);
	return *this;
}

//  Requires
//    pos1 <= size() and pos2 <= str.size()
//  Throws:
//    out_of_range if pos1 > size() or pos2 > str.size().
//  Effects:
//    Determines  the effective length rlen of the string to insert as the
//    smaller of n and str.size() - pos2.   Then  throws  length_error  if
//    size() >= npos - rlen.
//    Otherwise, the function replaces the string controlled by *this with
//    a string of length size() + rlen whose first  pos1  elements  are  a
//    copy  of  the  initial elements of the original string controlled by
//    *this, whose next rlen elements are a copy of the  elements  of  the
//    string  controlled  by  str  beginning  at  position pos2, and whose
//    remaining elements are a copy of the remaining elements of the orig-
//    inal string controlled by *this.

FTLString_AC& FTLString_AC::insert(size_type pos1, const FTLString_AC& str, size_type pos2, size_type n)
{
	return insert(pos1, FTLString_AC(str, pos2, n));
}

FTLString_AC& FTLString_AC::insert(size_type pos, const char* s, size_type n)
{
	return insert(pos, FTLString_AC(s, n));
}

FTLString_AC& FTLString_AC::insert(size_type pos, const char* s)
{
	return insert(pos, FTLString_AC(s));
}

FTLString_AC& FTLString_AC::insert(size_type pos, size_type n, char c)
{
	return insert(pos, FTLString_AC(n, c));
}

//  Requires:
//    p is a valid iterator on *this.
//  Effects:
//    inserts a copy of c before the character referred to by p.
//  Returns:
//    an iterator which refers to the copy of the inserted character.

FTLString_AC::iterator FTLString_AC::insert(iterator p, char c)
{
	if (p.fString != this)
		ThrowIteratorMustBeOnThis();

	insert(p.fPos, 1, c);
	return p;
}

//  Requires:
//    p is a valid iterator on *this.
//  Effects:
//    inserts n copies of c before the character referred to by p.

void FTLString_AC::insert(iterator p, size_type n, char c)
{
	if (p.fString != this)
		ThrowIteratorMustBeOnThis();

	insert(p.fPos, n, c);
}

//  Requires:
//    p is a valid iterator on *this.  [first,last) is a valid range.
//  Effects:
//    inserts  copies  of  the characters in the range [first,last) before
//    the character referred to by p.

#if 0
template<class InputIterator>
void FTLString_AC::insert(iterator p, InputIterator first, InputIterator last)
{
#if 0
	// space efficient
	if (p.fString != this)
		ThrowIteratorMustBeOnThis();

	size_type pos = p.fPos;
	while (first != last)
		insert(pos++, *first++);
#else
	// time efficient
	insert(p.fPos, FTLString_AC(first, last));
#endif
}
#endif

//----------------------------------------------------------------------------------------
// erase
//----------------------------------------------------------------------------------------

//  Requires:
//    pos  <= size()
//  Throws:
//    out_of_range if pos > size().
//  Effects:
//    Determines the effective length xlen of the string to be removed  as
//    the smaller of n and size() - pos.
//    The  function  then  replaces  the string controlled by *this with a
//    string of length size() - xlen whose first pos elements are  a  copy
//    of  the initial elements of the original string controlled by *this,
//    and whose remaining elements are a copy of the elements of the orig-
//    inal string controlled by *this beginning at position pos + xlen.

FTLString_AC& FTLString_AC::erase(size_type pos, size_type n)
{
	difference_type rlen = size() - pos;
	if (rlen < 0)
		ThrowPositionMustBeInString();

	if ((n != npos) && (n < static_cast<unsigned>(rlen)))
		rlen = n;

	fCFString->Delete(CCFRange_AC(pos, rlen));
	return *this;
}

//  Requires:
//    p is a valid iterator on *this.
//  Effects:
//    removes the character referred to by p.
//  Returns:
//    an  iterator  which  points  to  the element immediately following p
//    prior to the element being erased.  If no such element exists, end()
//    is returned.

FTLString_AC::iterator FTLString_AC::erase(iterator p)
{
	if (p.fString != this)
		ThrowIteratorMustBeOnThis();

	erase(p.fPos);
	return p;
}

//  Requires:
//    first  and  last  are  valid  iterators  on  *this, defining a range
//    [first,last).
//  Effects:
//    removes the characters in the range [first,last).
//  Returns:
//    an iterator which points to the element immediately  following  last
//    prior to the element being erased.  If no such element exists, end()
//    is returned.

FTLString_AC::iterator FTLString_AC::erase(iterator first, iterator last)
{
	if ((first.fString != this) || (last.fString != this))
		ThrowIteratorMustBeOnThis();

	erase(first.fPos, last - first);

	return last;
}

//----------------------------------------------------------------------------------------
// replace
//----------------------------------------------------------------------------------------

FTLString_AC& FTLString_AC::replace(size_type pos1, size_type n1, const FTLString_AC& str)
{
	difference_type rlen = size() - pos1;
	if (rlen < 0)
		ThrowPositionMustBeInString();

	if ((n1 != npos) && (n1 < static_cast<unsigned>(rlen)))
		rlen = n1;

	fCFString->Replace(CCFRange_AC(pos1, rlen), str.fCFString);
	return *this;
}

//  Requires:
//    pos1 <= size() && pos2 <= str.size().
//  Throws:
//    out_of_range if pos1 > size() or pos2 > str.size().
//  Effects:
//    Determines the effective length xlen of the string to be removed  as
//    the  smaller of n1 and size() - pos1.  It also determines the effec-
//    tive length rlen of the string to be inserted as the smaller  of  n2
//    and str.size() - pos2 .
//    Throws length_error if size() - xlen >= npos - rlen.
//    Otherwise, the function replaces the string controlled by *this with
//    a string of length size() - xlen + rlen whose  first  pos1  elements
//    are a copy of the initial elements of the original string controlled
//    by *this, whose next rlen elements are a copy of  the  initial  ele-
//    ments  of  the  string controlled by str beginning at position pos2,
//    and whose remaining elements are a copy of the elements of the orig-
//    inal string controlled by *this beginning at position pos1 + xlen.

FTLString_AC& FTLString_AC::replace(size_type pos1, size_type n1, const FTLString_AC& str, size_type pos2, size_type n2)
{
	return replace(pos1, n1, FTLString_AC(str, pos2, n2));
}

FTLString_AC& FTLString_AC::replace(size_type pos, size_type n1, const char* s, size_type n2)
{
	return replace(pos, n1, FTLString_AC(s, n2));
}

FTLString_AC& FTLString_AC::replace(size_type pos, size_type n1, const char* s)
{
	return replace(pos, n1, FTLString_AC(s));
}

FTLString_AC& FTLString_AC::replace(size_type pos, size_type n1, size_type n2, char c)
{
	return replace(pos, n1, FTLString_AC(n2, c));
}

//  Requires:
//    The  iterators  i1  and  i2 are valid iterators on *this, defining a
//    range [i1,i2).
//  Effects:
//    Replaces the string controlled by *this  with  a  string  of  length
//    size()  -  (i2  - i1) + str.size() whose first begin() - i1 elements
//    are a copy of the initial elements of the original string controlled
//    by  *this,  whose  next str.size() elements are a copy of the string
//    controlled by str, and whose remaining elements are a  copy  of  the
//    elements  of  the  original  string controlled by *this beginning at
//    position i2.
//  Returns:
//    *this.
//  Notes:
//    After the call, the  length  of  the  string  will  be  changed  by:
//    str.size() - (i2 - i1).

FTLString_AC& FTLString_AC::replace(iterator i1, iterator i2, const FTLString_AC& str)
{
	if ((i1.fString != this) || (i2.fString != this))
		ThrowIteratorMustBeOnThis();

	return replace(i1.fPos, i2 - i1, str);
}

//  Notes:
//    Length change: n - (i2 - i1).

FTLString_AC& FTLString_AC::replace(iterator i1, iterator i2, const char* s, size_type n)
{
	return replace(i1, i2, FTLString_AC(s, n));
}

//  Notes:
//    Length change: traits::length(s) - (i2 - i1).
//    Uses traits::length().

FTLString_AC& FTLString_AC::replace(iterator i1, iterator i2, const char* s)
{
	return replace(i1, i2, FTLString_AC(s));
}

//  Notes:
//    Length change: n - (i2 - i1).

FTLString_AC& FTLString_AC::replace(iterator i1, iterator i2, size_type n, char c)
{
	return replace(i1, i2, FTLString_AC(n, c));
}

//  Notes:
//    Length change: j2 - j1 - (i2 - i1).

#if 0
template<class InputIterator>
FTLString_AC& FTLString_AC::replace(iterator i1, iterator i2, InputIterator j1, InputIterator j2)
{
	return replace(i1, i2, FTLString_AC(j1, j2));
}
#endif

//----------------------------------------------------------------------------------------
// copy
//----------------------------------------------------------------------------------------

//  Requires:
//    pos <= size()
//  Throws:
//    out_of_range if pos > size().
//  Effects:
//    Determines  the  effective  length rlen of the string to copy as the
//    smaller of n and size() - pos.  s shall designate  an  array  of  at
//    least rlen elements.
//    The  function then replaces the string designated by s with a string
//    of length rlen whose elements are a copy of the string controlled by
//    *this beginning at position pos.
//    The  function does not append a null object to the string designated
//    by s.
//  Returns:
//    rlen.

FTLString_AC::size_type FTLString_AC::copy(char* s, size_type n, size_type pos) const
{
	difference_type rlen = size() - pos;
	if (rlen < 0)
		ThrowPositionMustBeInString();

	if ((n != npos) && (n < static_cast<unsigned>(rlen)))
		rlen = n;

	CFIndex whatIsThis = fCFString->GetBytes(CCFRange_AC(pos, rlen), 0, false, s, n, NULL);
#ifdef __GNUC__
	(void) whatIsThis;
#endif

	return rlen;
}

//----------------------------------------------------------------------------------------
// swap
//----------------------------------------------------------------------------------------

//  Effects:
//    Swaps the contents of the two strings.
//  Postcondition:
//    *this contains the characters that were in s, s contains the charac-
//    ters that were in *this.
//  Complexity:
//    constant time.

void FTLString_AC::swap(FTLString_AC& s)
{
	CFMutableStringRef temp = s.fCFString;
	s.fCFString.set(fCFString);
	fCFString.set(temp);
}

//----------------------------------------------------------------------------------------
// string operations
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// c_str
//----------------------------------------------------------------------------------------

//  Returns:
//    A  pointer  to  the initial element of an array of length size() + 1
//    whose first size() elements equal the corresponding elements of  the
//    string  controlled by *this and whose last element is a null charac-
//    ter specified by traits::eos().
//  Requires:
//    The program shall not alter any of the values stored in  the  array.
//    Nor  shall  the  program treat the returned value as a valid pointer
//    value after any subsequent call to a non-const  member  function  of
//    the class FTLString_AC that designates the same object as this.
//  Notes:
//    Uses traits::eos().

const char* FTLString_AC::c_str() const
{
	const char* s = fCFString->GetCStringPtr();
	ThrowIfBadAlloc_AC(s);
	return s;
}

//----------------------------------------------------------------------------------------
// data
//----------------------------------------------------------------------------------------

//  Returns:
//    If  size()  is  nonzero, the member returns a pointer to the initial
//    element of an array whose first size()  elements  equal  the  corre-
//    sponding  elements  of the string controlled by *this.  If size() is
//    zero, the member returns a non-null pointer that is copyable and can
//    have zero added to it.
//  Requires:
//    The  program shall not alter any of the values stored in the charac-
//    ter array.  Nor shall the program treat  the  returned  value  as  a
//    valid pointer value after any subsequent call to a non- const member
//    function of FTLString_AC that designates the same object as this.

const char* FTLString_AC::data() const
{
	const char* s = fCFString->GetCStringPtr();
	ThrowIfBadAlloc_AC(s);
	return s;
}

//----------------------------------------------------------------------------------------
// get_allocator
//----------------------------------------------------------------------------------------

FTLString_AC::allocator_type FTLString_AC::get_allocator() const
{
	return std::allocator<char>();
}

//----------------------------------------------------------------------------------------
// find
//----------------------------------------------------------------------------------------

FTLString_AC::size_type FTLString_AC::find(const FTLString_AC& str, size_type pos) const
{
	return find_first_of(str, pos);
}

FTLString_AC::size_type FTLString_AC::find(const char* s, size_type pos, size_type n) const
{
	return find_first_of(s, pos, n);
}

FTLString_AC::size_type FTLString_AC::find(const char* s, size_type pos) const
{
	return find_first_of(s, pos);
}

FTLString_AC::size_type FTLString_AC::find(char c, size_type pos) const
{
	return find_first_of(c, pos);
}

//----------------------------------------------------------------------------------------
// rfind
//----------------------------------------------------------------------------------------

FTLString_AC::size_type FTLString_AC::rfind(const FTLString_AC& str, size_type pos) const
{
	return find_last_of(str, pos);
}

FTLString_AC::size_type FTLString_AC::rfind(const char* s, size_type pos, size_type n) const
{
	return find_last_of(s, pos, n);
}

FTLString_AC::size_type FTLString_AC::rfind(const char* s, size_type pos) const
{
	return find_last_of(s, pos);
}

FTLString_AC::size_type FTLString_AC::rfind(char c, size_type pos) const
{
	return find_last_of(c, pos);
}

//----------------------------------------------------------------------------------------
// find_first_of
//----------------------------------------------------------------------------------------

//  Effects:
//    Determines the lowest position xpos, if possible, such that both of
//    the following conditions obtain:
//
//  --pos <= xpos and xpos < size();
//
//  --at(xpos) == str.at(I) for some element I of the string controlled by
//    str.
//  Returns:
//    xpos  if  the  function can determine such a value for xpos.  Other-
//    wise, returns npos.
//  Notes:
//    Uses traits::eq().

FTLString_AC::size_type FTLString_AC::find_first_of(const FTLString_AC& str, size_type pos) const
{
	size_type xpos = npos;

	CCFRange_AC rangeToSearch(pos, size() - pos);
	CCFRange_AC result(0, 0);
	if (fCFString->FindWithOptions(str.fCFString, rangeToSearch, &result))
		xpos = result.location;

	return xpos;
}

FTLString_AC::size_type FTLString_AC::find_first_of(const char* s, size_type pos, size_type n) const
{
	return find_first_of(FTLString_AC(s, n), pos);
}

FTLString_AC::size_type FTLString_AC::find_first_of(const char* s, size_type pos) const
{
	return find_first_of(FTLString_AC(s), pos);
}

FTLString_AC::size_type FTLString_AC::find_first_of(char c, size_type pos) const
{
	return find_first_of(FTLString_AC(&c, 1), pos);
}

//----------------------------------------------------------------------------------------
// find_last_of
//----------------------------------------------------------------------------------------

//  Effects:
//    Determines the highest position xpos, if possible, such that both of
//    the following conditions obtain:
//
//  --xpos <= pos and pos < size();
//
//  --at(xpos) == str.at(I) for some element I of the string controlled by
//    str.
//  Returns:
//    xpos if the function can determine such a value  for  xpos.   Other-
//    wise, returns npos.
//  Notes:
//    Uses traits::eq().

FTLString_AC::size_type FTLString_AC::find_last_of(const FTLString_AC& str, size_type pos) const
{
	size_type xpos = npos;

	CCFRange_AC rangeToSearch(1, pos);
	CCFRange_AC result(0, 0);
	if (fCFString->FindWithOptions(str.fCFString, rangeToSearch, kCFCompareBackwards, &result))
		xpos = result.location;

	return xpos;
}

FTLString_AC::size_type FTLString_AC::find_last_of(const char* s, size_type pos, size_type n) const
{
	return find_last_of(FTLString_AC(s, n), pos);
}

FTLString_AC::size_type FTLString_AC::find_last_of(const char* s, size_type pos) const
{
	return find_last_of(FTLString_AC(s), pos);
}

FTLString_AC::size_type FTLString_AC::find_last_of(char c, size_type pos) const
{
	return find_last_of(FTLString_AC(&c, 1), pos);
}

//----------------------------------------------------------------------------------------
// find_first_not_of
//----------------------------------------------------------------------------------------

//  Effects:
//    Determines  the lowest position xpos, if possible, such that both of
//    the following conditions obtain:
//
//  --pos <= xpos and xpos < size();
//
//  --at(xpos) == str.at(I) for no element I of the string  controlled  by
//    str.
//  Returns:
//    xpos  if  the  function can determine such a value for xpos.  Other-
//    wise, returns npos.
//  Notes:
//    Uses traits::eq().

FTLString_AC::size_type FTLString_AC::find_first_not_of(const FTLString_AC& str, size_type pos) const
{
	size_type xpos = npos;

	difference_type rlen = size() - pos;
	while (rlen > 0)
	{
		if (compare(pos, rlen, str) != 0)
		{
			xpos = pos;
			break;
		}
		++pos;
		--rlen;
	}

	return xpos;
}

FTLString_AC::size_type FTLString_AC::find_first_not_of(const char* s, size_type pos, size_type n) const
{
	return find_first_not_of(FTLString_AC(s, n), pos);
}

FTLString_AC::size_type FTLString_AC::find_first_not_of(const char* s, size_type pos) const
{
	return find_first_not_of(FTLString_AC(s), pos);
}

FTLString_AC::size_type FTLString_AC::find_first_not_of(char c, size_type pos) const
{
	return find_first_not_of(FTLString_AC(&c, 1), pos);
}

//----------------------------------------------------------------------------------------
// find_last_not_of
//----------------------------------------------------------------------------------------

//  Effects:
//    Determines the highest position xpos, if possible, such that both of
//    the following conditions obtain:
//
//  --xpos <= pos and pos < size();
//
//  --at(xpos)  == str.at(I)) for no element I of the string controlled by
//    str.
//  Returns:
//    xpos if the function can determine such a value  for  xpos.   Other-
//    wise, returns npos.
//  Notes:
//    Uses traits::eq().

FTLString_AC::size_type FTLString_AC::find_last_not_of(const FTLString_AC& str, size_type pos) const
{
	size_type xpos = npos;

	if ((pos == npos) || (pos >= size()))
		pos = size() - 1;

	difference_type rlen = size() - pos;
	while (pos >= 0)
	{
		if (compare(pos, rlen, str) != 0)
		{
			xpos = pos;
			break;
		}
		--pos;
		++rlen;
	}

	return xpos;
}

FTLString_AC::size_type FTLString_AC::find_last_not_of(const char* s, size_type pos, size_type n) const
{
	return find_last_not_of(FTLString_AC(s, n), pos);
}

FTLString_AC::size_type FTLString_AC::find_last_not_of(const char* s, size_type pos) const
{
	return find_last_not_of(FTLString_AC(s), pos);
}

FTLString_AC::size_type FTLString_AC::find_last_not_of(char c, size_type pos) const
{
	return find_last_not_of(FTLString_AC(&c, 1), pos);
}

//----------------------------------------------------------------------------------------
// substr
//----------------------------------------------------------------------------------------

//  Requires:
//    pos <= size()
//  Throws:
//    out_of_range if pos > size().
//  Effects:
//    Determines  the  effective  length rlen of the string to copy as the
//    smaller of n and size() - pos.

FTLString_AC FTLString_AC::substr(size_type pos, size_type n) const
{
	difference_type rlen = size() - pos;
	if (rlen < 0)
		ThrowPositionMustBeInString();

	if ((n != npos) && (n < static_cast<unsigned>(rlen)))
		rlen = n;

	return FTLString_AC(*this, pos, rlen);
}

//----------------------------------------------------------------------------------------
// compare
//----------------------------------------------------------------------------------------

//  Effects:
//    Determines the effective length rlen of the strings  to  compare  as
//    the  smallest  of size() and str.size().  The function then compares
//    the  two  strings  by  calling  traits::compare(data(),  str.data(),
//    rlen).
//  Returns:
//    the nonzero result if the result of the comparison is nonzero.  Oth-
//    erwise, returns a value as indicated in Table 10:
//
//                        Table 10--compare() results
//
//                   +------------------------------------+
//                   |     Condition         Return Value |
//                   +------------------------------------+
//                   |size() <  str.size()   < 0          |
//                   |size() == str.size()     0          |
//                   |size() >  str.size()   > 0          |
//                   +------------------------------------+

int FTLString_AC::compare(const FTLString_AC& str) const
{
	return fCFString->Compare(str.fCFString);
}

int FTLString_AC::compare(size_type pos1, size_type n1, const FTLString_AC& str) const
{
	return fCFString->CompareWithOptions(str.fCFString, CCFRange_AC(pos1, n1), 0);
}

int FTLString_AC::compare(size_type pos1, size_type n1, const FTLString_AC& str, size_type pos2, size_type n2) const
{
	return compare(pos1, n1, FTLString_AC(str, pos2, n2));
}

int FTLString_AC::compare(const char *s) const
{
	return compare(FTLString_AC(s));
}

int FTLString_AC::compare(size_type pos1, size_type n1, const char *s, size_type n2) const
{
	return compare(pos1, n1, FTLString_AC(s, n2));
}

//----------------------------------------------------------------------------------------
// conversion
//----------------------------------------------------------------------------------------

std::string FTLString_AC::AsString() const
{
	const char* s = fCFString->GetCStringPtr();
	return std::string(s);
}

CFStringRef FTLString_AC::CFString() const
{
	return fCFString;
}

CFMutableStringRef FTLString_AC::CFMutableString()
{
	return fCFString;
}

//----------------------------------------------------------------------------------------
// testing
//----------------------------------------------------------------------------------------

#if qDebug

void FTLString_AC::Test()
{
	FTLString_AC emptyString;
}

#endif // qDebug

//----------------------------------------------------------------------------------------
// non-member functions
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// operator+
//----------------------------------------------------------------------------------------

FTLString_AC operator+(const FTLString_AC& lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(lhs).append(rhs);
}

FTLString_AC operator+(const char* lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(lhs).append(rhs);
}

FTLString_AC operator+(char lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(&lhs, 1).append(rhs);
}

FTLString_AC operator+(const FTLString_AC& lhs, const char* rhs)
{
	return lhs + FTLString_AC(rhs);
}

FTLString_AC operator+(const FTLString_AC& lhs, char rhs)
{
	return lhs + FTLString_AC(&rhs, 1);
}

//----------------------------------------------------------------------------------------
// operator==
//----------------------------------------------------------------------------------------

bool operator==(const FTLString_AC& lhs, const FTLString_AC& rhs)
{
	return lhs.compare(rhs) == 0;
}

bool operator==(const char* lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(lhs).compare(rhs);
}

bool operator==(const FTLString_AC& lhs, const char* rhs)
{
	return lhs.compare(rhs);
}

//----------------------------------------------------------------------------------------
// operator!=
//----------------------------------------------------------------------------------------

bool operator!=(const FTLString_AC& lhs, const FTLString_AC& rhs)
{
	return !(lhs == rhs);
}

bool operator!=(const char* lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(lhs) != rhs;
}

bool operator!=(const FTLString_AC& lhs, const char* rhs)
{
	return lhs != FTLString_AC(rhs);
}

//----------------------------------------------------------------------------------------
// operator<
//----------------------------------------------------------------------------------------

bool operator<(const FTLString_AC& lhs, const FTLString_AC& rhs)
{
	return lhs.compare(rhs) < 0;
}

bool operator<(const char* lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(lhs) < rhs;
}

bool operator<(const FTLString_AC& lhs, const char* rhs)
{
	return lhs < FTLString_AC(rhs);
}

//----------------------------------------------------------------------------------------
// operator>
//----------------------------------------------------------------------------------------

bool operator>(const FTLString_AC& lhs, const FTLString_AC& rhs)
{
	return lhs.compare(rhs) > 0;
}

bool operator>(const char* lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(lhs) > rhs;
}

bool operator>(const FTLString_AC& lhs, const char* rhs)
{
	return lhs > FTLString_AC(rhs);
}

//----------------------------------------------------------------------------------------
// operator<=
//----------------------------------------------------------------------------------------

bool operator<=(const FTLString_AC& lhs, const FTLString_AC& rhs)
{
	return lhs.compare(rhs) <= 0;
}

bool operator<=(const char* lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(lhs) <= rhs;
}

bool operator<=(const FTLString_AC& lhs, const char* rhs)
{
	return lhs <= FTLString_AC(rhs);
}

//----------------------------------------------------------------------------------------
// operator>=
//----------------------------------------------------------------------------------------

bool operator>=(const FTLString_AC& lhs, const FTLString_AC& rhs)
{
	return lhs.compare(rhs) >= 0;
}

//----------------------------------------------------------------------------------------
// operator>=
//----------------------------------------------------------------------------------------

bool operator>=(const char* lhs, const FTLString_AC& rhs)
{
	return FTLString_AC(lhs) >= rhs;
}

bool operator>=(const FTLString_AC& lhs, const char* rhs)
{
	return lhs >= FTLString_AC(rhs);
}

//----------------------------------------------------------------------------------------
// swap
//----------------------------------------------------------------------------------------

void swap(FTLString_AC& lhs, FTLString_AC& rhs)
{
	lhs.swap(rhs);
}

//----------------------------------------------------------------------------------------
// Inserters and extractors
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// operator>>
//----------------------------------------------------------------------------------------

//  Effects:
//    Begins by constructing a sentry object k as if k were constructed by
//    basic_istream<char,traits>::sentry k(is).  If bool(k) is  true,  it
//    calls  str.erase()  and then extracts characters from is and appends
//    them to str as if by  calling  str.append(1,c).   If  is.width()  is
//    greater  than  zero,  the maximum number n of characters appended is
//    is.width(); otherwise n is str.max_size().  Characters are extracted
//    and appended until any of the following occurs:
//
//  --n characters are stored;
//
//  --end-of-file occurs on the input sequence;
//
//  --isspace(c,getloc())  is  true for the next available input character
//    c.  After the last character (if any) is extracted,  is.width(0)  is
//    called and the sentry object k is destroyed.
//  Returns:
//    is

std::istream& operator>>(std::istream& is, FTLString_AC& str)
{
	std::string temp;
	is >> temp;
	str.append(temp.data(), temp.size());
	return is;
}

//----------------------------------------------------------------------------------------
// operator<<
//----------------------------------------------------------------------------------------

//  Effects:
//    Begins by constructing a sentry object k as if k were constructed by
//    basic_ostream<char,traits>::sentry  k(os).   If  bool(k)  is  true,
//    inserts  characters  as  if by calling os.rdbuf()->sputn(str.data(),
//    n), padding as described in stage 3 of _lib.facet.num.put.virtuals_,
//    where  n  is  the  smaller  of os.width() and str.size(); then calls
//    os.width(0).   If  the  call   to   sputn   fails,   calls   os.set-
//    state(ios_base::failbit).
//  Returns:
//    os

std::ostream& operator<<(std::ostream& os, const FTLString_AC& str)
{
	return os << str.AsString();
}

//----------------------------------------------------------------------------------------
// getline
//----------------------------------------------------------------------------------------

//  Effects:
//    Begins    by   constructing   a   sentry   object   k   as   if   by
//    basic_istream<char,traits>::sentry k(is).  If bool(k) is  true,  it
//    calls  str.erase()  and then extracts characters from is and appends
//    them to str as if by calling str.append(1,c) until any of  the  fol-
//    lowing occurs:
//
//  --end-of-file occurs on the input sequence (in which case, the getline
//    function calls is.setstate(ios_base::eofbit)).
//
//  --c == delim for the next available input character c (in which  case,
//    c is extracted but not appended) (_lib.iostate.flags_)
//
//  --str.max_size()  characters  are  stored (in which case, the function
//    calls is.setstate(ios_base::failbit) (_lib.iostate.flags_)
//
//1 The conditions are tested in the order shown.  In any case, after  the
//  last character is extracted, the sentry object k is destroyed.
//
//2 If   the   function   extracts   no   characters,   it  calls  is.set-
//  state(ios_base::failbit)    which    may    throw    ios_base::failure
//  (_lib.iostate.flags_).
//  Returns:
//    is.

std::istream& getline(std::istream& is, FTLString_AC& str, char delim)
{
	std::string temp;
	getline(is, temp, delim);
	str.append(temp.data(), temp.size());
	return is;
}

//----------------------------------------------------------------------------------------
// getline
//----------------------------------------------------------------------------------------

//  Returns:
//    getline(is,str,is.widen('\n'))

std::istream& getline(std::istream& is, FTLString_AC& str)
{
	std::string temp;
	getline(is, temp);
	str.append(temp.data(), temp.size());
	return is;
}


//----------------------------------------------------------------------------------------
// End of FTLString_AC.cpp
