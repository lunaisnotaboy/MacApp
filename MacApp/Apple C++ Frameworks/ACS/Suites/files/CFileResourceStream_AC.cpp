//----------------------------------------------------------------------------------------
// CFileResourceStream_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		02/15/01	Need to include CTidyHeap_AC. 
		01/02/01	Update copyright.
		06/05/00	[2477847] CFileResourceStream_AC ctor cannot possibly be using the
					correct file.  Moved empty dtor implementation into header.
					Added CFileResourceStreamRep_AC.  Added an Initialize function
					that is called prior to any data member access.  Include CReporter_ac.h.
		03/24/99	Update copyright notice.
*/

#ifndef __CFileResourceStream_AC__
#include "CFileResourceStream_AC.h"
#endif

// ACS

#ifndef __ResFileUtils_AC__
#include "ResFileUtils_AC.h"
#endif

#ifndef __CFile_AC__
#include "CFile_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif


//========================================================================================
// CLASS CFileResourceStream_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CFileResourceStream_AC::CFileResourceStream_AC: 
//----------------------------------------------------------------------------------------

CFileResourceStream_AC::CFileResourceStream_AC( CFile_AC*	theFile, 
												ResType		theType, 
												ResNumber	theID) 
	:	CResourceStream_AC(TH_new CFileResourceStreamRep_AC(theFile, theType, theID)),
		fFile(theFile)
// CFileResourceStream_AC constructor initializes a CResourceStream_AC and
// sets the resource file.
//
// theFile:	A pointer to the CFile_AC which contains the resource to be streamed.
// theType:	The ResType of the resource to be streamed.
// theID:	The resource ID of the resource to be streamed.
{
}

//----------------------------------------------------------------------------------------
// CFileResourceStream_AC::WriteBytes: 
//----------------------------------------------------------------------------------------

void CFileResourceStream_AC::WriteBytes(const void* p, long count)
{
	CTempUseResFile_AC tempUseResFile(fFile->GetRsrcRefNum());
	CResourceStream_AC::WriteBytes(p, count);
}

//----------------------------------------------------------------------------------------
// CFileResourceStream_AC::ReadBytes: 
//----------------------------------------------------------------------------------------

void CFileResourceStream_AC::ReadBytes(void* p, long count)
{
	CTempUseResFile_AC tempUseResFile(fFile->GetRsrcRefNum());
	CResourceStream_AC::ReadBytes(p, count);
}

//----------------------------------------------------------------------------------------
// CFileResourceStream_AC::SetSize: 
//----------------------------------------------------------------------------------------

void CFileResourceStream_AC::SetSize(long newSize)
{
	CTempUseResFile_AC tempUseResFile(fFile->GetRsrcRefNum());
	CResourceStream_AC::SetSize(newSize);
}

//========================================================================================
// CLASS CFileResourceStreamRep_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CFileResourceStreamRep_AC::CFileResourceStreamRep_AC
//----------------------------------------------------------------------------------------

CFileResourceStreamRep_AC::CFileResourceStreamRep_AC(	CFile_AC*	theFile, 
														ResType		theType, 
														ResNumber	theID)
	:	CResourceStreamRep_AC(theType, theID),
		fFile(theFile)
{
#if qDebug
	if (fFile == NULL)
		ProgramBreak_AC("CFileResourceStreamRep_AC::CFileResourceStreamRep_AC: fFile == NULL.");
#endif
}

//----------------------------------------------------------------------------------------
// CFileResourceStreamRep_AC::Initialize
//----------------------------------------------------------------------------------------

void CFileResourceStreamRep_AC::Initialize() const
{
	if (!fInitialized)
	{
		if (fFile)
		{
			CTempUseResFile_AC tempUseResFile(fFile->GetRsrcRefNum());
			CResourceStreamRep_AC::Initialize();
		}
#if qDebug
		else
			ProgramBreak_AC("CFileResourceStreamRep_AC::Initialize: fFile == NULL.");
#endif
	}
}

//----------------------------------------------------------------------------------------
// End of UFileStream.cp
