//----------------------------------------------------------------------------------------
// CFSSpec_AC.cpp
// Copyright © 1985-2001 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History
		05/31/01	GetPathName was placing the delimeter on the wrong side of
					the newly added directory.
		03/19/01	Use template version of BlockZero_AC
		03/19/01	Use BlockZero_AC, instead of BlockSet_AC(,,0)
		02/14/01	Include MacMemory instead of Memory_AC. 
		01/24/01	[W] Takes a Str255 in SetName.
		01/11/01	Use CString_AC instead of CStr255_AC.  GetPathName throws rather
					than returning an OSErr.
		01/02/01	Update copyright.
		11/09/00	[PB] Check the error return from GetFinderInfo in IsStationery. 
		11/01/00	[PB] Include MacErrors instead of Errors. 
		03/20/00	[2446397] Change IsDirectory to return false if error returned
					from GetFinderInfo.
		03/24/99	Update copyright notice.
		10/06/98	Clean up includes. 
*/

#ifndef __CFSSpec_AC__
#include "CFSSpec_AC.h"
#endif

// ACS

#ifndef __Configuration_AC__
#include "Configuration_AC.h"
#endif

#ifndef __CPascalString_AC__
#include "CPascalString_AC.h"
#endif

#ifndef __FileTypes_AC__
#include "FileTypes_AC.h"
#endif

#ifndef __MemoryUtils_AC__
#include "MemoryUtils_AC.h"
#endif

// Toolbox

#ifndef __MACERRORS__
#include <MacErrors.h>
#endif

#ifndef __MACMEMORY__
#include <MacMemory.h>
#endif

//========================================================================================
// CLASS CFSSpec_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CFSSpec_AC::SetName: 
//----------------------------------------------------------------------------------------


void CFSSpec_AC::SetName(const CString_AC& newName)
{
#if !qMSWindows
	newName.AsStr63(name);
#else
	newName.AsStr255(name);
#endif
}

//----------------------------------------------------------------------------------------
//	CFSSpec_AC::Set
//----------------------------------------------------------------------------------------
	
void CFSSpec_AC::Set(const FSSpec& inFSSpec)
{
	*(FSSpec*)this = *(FSSpec*)&inFSSpec;
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::GetPathName: 
//----------------------------------------------------------------------------------------

CString_AC CFSSpec_AC::GetPathName() const
// GetPathName constructs the full path to the directory to which our FSSpec refers by
// building up a string containing all of the intermediate directories until the root
// directory is encountered.
//
// Call?	As needed.
{
	CString_AC	thePathName;
	Str255	 	dirName;		// This is big enough to handle either Str63 or Str255.
	
#if !qMSWindows
	const CString_AC delimiter(HasAUX_AC() ? "/" : ":");
#else
	const CString_AC delimiter("\\");
#endif
	
	CInfoPBRec cInfoPB;
	cInfoPB.dirInfo.ioFDirIndex = -1;
	cInfoPB.dirInfo.ioVRefNum = vRefNum;
	cInfoPB.dirInfo.ioDrDirID = parID;
	cInfoPB.dirInfo.ioNamePtr = dirName;
	
	// Build up the string by pushing each successive 
	// directory name onto the front of the string.
	OSErr err = noErr;
	while (err == noErr)
	{
		err = PBGetCatInfoSync(&cInfoPB);
		thePathName.insert(0, CString_AC(&dirName[1], dirName[0]) + delimiter);

		// If this is the root directory then we are done.
		if (cInfoPB.dirInfo.ioDrDirID == fsRtDirID)
			break;

		cInfoPB.dirInfo.ioDrDirID = cInfoPB.dirInfo.ioDrParID;
	}
	
	if (HasAUX_AC())
		thePathName.insert(0, delimiter);
	
	ThrowIfOSErr_AC(err);
	
	return thePathName;
}

//----------------------------------------------------------------------------------------
// Comparison operators for CFSSpec_AC
//----------------------------------------------------------------------------------------
	
bool CFSSpec_AC::operator ==(const CFSSpec_AC& inFSSpec) const
{
	return vRefNum == inFSSpec.vRefNum && parID == inFSSpec.parID && *(CStr63_AC*)&name == *(CStr63_AC*)&inFSSpec.name;
}

//----------------------------------------------------------------------------------------
// GetFinderInfo: This is the only File Manager abstraction provided by CFSSpec,
// which can be used for quick looks at a file's existence and type.  All other
// queries or operations on a file should go through the CFile class.
//----------------------------------------------------------------------------------------

//----------------------------------------------------------------------------------------
// CFSSpec_AC::GetFinderInfo: 
//----------------------------------------------------------------------------------------


OSErr CFSSpec_AC::GetFinderInfo(FInfo& fndrInfo) const
{
	FXInfo itsFXInfo;
	bool isDirectory;

	return GetFinderInfo(fndrInfo, itsFXInfo, isDirectory);
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::GetFinderInfo: 
//----------------------------------------------------------------------------------------


OSErr CFSSpec_AC::GetFinderInfo(FInfo& fndrInfo, FXInfo& itsFXInfo, bool& isDirectory) const
{
	CInfoPBRec cInfo;

	BlockZero_AC(cInfo);// zero-out our storage 
	cInfo.hFileInfo.ioCompletion = NULL;

	cInfo.hFileInfo.ioNamePtr = const_cast<StringPtr>(name);

	cInfo.hFileInfo.ioVRefNum = vRefNum;
	cInfo.hFileInfo.ioFDirIndex = 0;
	cInfo.hFileInfo.ioDirID = parID;

	PBGetCatInfoSync(&cInfo);
	
	if (cInfo.hFileInfo.ioResult == noErr)
	{
		isDirectory = cInfo.hFileInfo.ioFlAttrib & ioDirMask;
		if (isDirectory)
		{
			fndrInfo = *(FInfo*)&cInfo.dirInfo.ioDrUsrWds;
			itsFXInfo = *(FXInfo*)&cInfo.dirInfo.ioDrFndrInfo;
		}
		else
		{
			fndrInfo = cInfo.hFileInfo.ioFlFndrInfo;
			itsFXInfo = cInfo.hFileInfo.ioFlXFndrInfo;
		}
	}

	return cInfo.hFileInfo.ioResult;
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::Exists: Returns whether the specified file exists on disk.
//----------------------------------------------------------------------------------------

bool CFSSpec_AC::Exists() const
{
	FInfo fndrInfo;
	FXInfo itsFXInfo;
	bool isDirectory;
	
	OSErr err = GetFinderInfo(fndrInfo, itsFXInfo, isDirectory);
	return (err == noErr);
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::IsDirectory: Returns whether the specified file is a directory.
//----------------------------------------------------------------------------------------

bool CFSSpec_AC::IsDirectory() const
{
	FInfo fndrInfo;
	FXInfo itsFXInfo;
	bool isDirectory;
	
	OSErr err = GetFinderInfo(fndrInfo, itsFXInfo, isDirectory);
	return (isDirectory && (err == noErr));
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::IsFile: Returns whether the specified file is a file (not a directory).
//----------------------------------------------------------------------------------------

bool CFSSpec_AC::IsFile() const
{
	FInfo fndrInfo;
	FXInfo itsFXInfo;
	bool isDirectory;
	
	OSErr err = GetFinderInfo(fndrInfo, itsFXInfo, isDirectory);
	return (err == noErr) && !isDirectory;
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::IsStationery: Returns whether the specified file is stationery.
//----------------------------------------------------------------------------------------

bool CFSSpec_AC::IsStationery() const
{
	FInfo fndrInfo;
	FXInfo itsFXInfo;
	bool isDirectory;
	
	OSErr err = GetFinderInfo(fndrInfo, itsFXInfo, isDirectory);
	return (err == noErr) && !isDirectory && ((fndrInfo.fdFlags & kIsStationery) != 0);
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::GetFileType: Returns the file's type.
//----------------------------------------------------------------------------------------


OSType CFSSpec_AC::GetFileType() const
{
	FInfo finderInfo;
	FXInfo xFinderInfo;
	bool isDirectory;
	
	OSErr theErr = GetFinderInfo(finderInfo, xFinderInfo, isDirectory);
	return theErr == noErr ? (isDirectory ? kFolderType_AC : finderInfo.fdType) : kAllQuestionsType_AC;
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::GetFileCreator: Returns the file's creator.
//----------------------------------------------------------------------------------------


OSType CFSSpec_AC::GetFileCreator() const
{
	FInfo finderInfo;
	FXInfo xFinderInfo;
	bool isDirectory;
	
	OSErr theErr = GetFinderInfo(finderInfo, xFinderInfo, isDirectory);
	return theErr == noErr ? (isDirectory ? kFolderCreator_AC : finderInfo.fdCreator) : kGenericCreator_AC;
}

//----------------------------------------------------------------------------------------
// CFSSpec_AC::MakeUnique: Makes the spec unique by changing the name of the file.
//----------------------------------------------------------------------------------------

bool CFSSpec_AC::FindUniqueSpec()
{
	FInfo fndrInfo;
	FXInfo itsFXInfo;
	bool isDirectory;
	bool foundOne = false;
	
	OSErr err = GetFinderInfo(fndrInfo, itsFXInfo, isDirectory);
	CFSSpec_AC savedSpec = *this;

	long counter = 0;
	Str255 counterStr;
		
	while(err == noErr)
	{
		*this = savedSpec;
		
		NumToString(++counter, counterStr);
			
		short numLen = *counterStr;
		short insertIndex = *name;
				
		if(insertIndex + numLen + 1 > 31)
		{
			insertIndex = 31 - numLen - 1;
			*name = insertIndex;
			name[insertIndex] = '…';
		}

		name[++insertIndex] = ' ';	
		(*name)++;
		
		for(short i = 1; i <= numLen; i++)
		{
			name[insertIndex+i] = counterStr[i];
			(*name)++;
		}
		
		err = GetFinderInfo(fndrInfo, itsFXInfo, isDirectory);
	}	
	
	if(err == fnfErr)
		foundOne = true;
	
	if(!foundOne)
		*this = savedSpec;
		
	return foundOne;
}

//----------------------------------------------------------------------------------------
// End of CFSSpec_AC.cpp
