//----------------------------------------------------------------------------------------
// CResourceStream_AC.cpp
// Copyright © 1984-2001 by Apple Computer, Inc. All rights reserved.
// Originally written by Larry S. Rosenstein. Used by permission
//----------------------------------------------------------------------------------------

/*
	Change History
		06/10/01	Need to include CMultiLocal_AC. 
		02/15/01	Need to include CTidyHeap_AC. 
		01/02/01	Update copyright.
		11/09/00	[PB] Change initialization order to match declaration. 
		06/14/00	Use CTempResLoad instead of SetResLoad.  Eliminate unnecessary 
					GetRegionCode calls.  Include ResourceUtils_AC.h.
		06/05/00	[2477847] Moved CResourceStreamRep_AC into header so that
					CFileResourceStream_AC can have a CFileResourceStreamRep_AC.
					Moved CResourceStreamRep_AC and CResourceStream_AC dtor into 
					header since empty.  Added fInitialized and an Initialize
					function that is called prior to any data member access.
					Test fResource for NULLness in a few places.  Include CReporter_AC.h.
		03/24/99	Update copyright notice.
		12/16/98	[W] ReadBytes and WriteBytes not implemented since partial
					resource calls are not supported under Windows.  These are 
					abstract functions in CStreamRep_AC and have to be resolved
					at some point.
*/

#ifndef __CResourceStream_AC__
#include "CResourceStream_AC.h"
#endif

// ACS

#ifndef __CMultiLocal_AC__
#include "CMultiLocal_AC.h"
#endif

#ifndef __CReporter_AC__
#include "CReporter_AC.h"
#endif

#ifndef __ResourceUtils_AC__
#include "ResourceUtils_AC.h"
#endif

#ifndef __CTidyHeap_AC__
#include "CTidyHeap_AC.h"
#endif

// Toolbox

#ifndef __RESOURCES__
#include <Resources.h>
#endif

#ifndef __LOWMEM__
#include <LowMem.h>
#endif

//========================================================================================
// CLASS CResourceStreamRep_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CResourceStreamRep_AC::CResourceStreamRep_AC
//----------------------------------------------------------------------------------------

CResourceStreamRep_AC::CResourceStreamRep_AC(ResType theType, ResNumber theID)
	:	fResource(NULL),
		fPosition(0),
		fSize(0),
		fResType(theType),
		fResID(theID),
		fInitialized(false)
{
}

//----------------------------------------------------------------------------------------
// CResourceStreamRep_AC::Initialize
//----------------------------------------------------------------------------------------

void CResourceStreamRep_AC::Initialize() const
{
	if (!fInitialized)
	{
		if (fResType != kNoIdentifier_AC)
		{
			{
				ACS::CTempResLoad(false);
				fResource = CMultiLocale_AC::GetResource(fResType, fResID);
			}
			::ThrowIfNULLResource_AC(fResource);
		
			fSize = GetResourceSizeOnDisk(fResource);
			::ThrowIfResError_AC();
			fInitialized = true;
		}
#if qDebug
		else
			ProgramBreak_AC("CResourceStreamRep_AC::Initialize: fResType == kNoIdentifier_AC.");
#endif
	}
}

//----------------------------------------------------------------------------------------
// CResourceStreamRep_AC::GetPosition: 
//----------------------------------------------------------------------------------------

long CResourceStreamRep_AC::GetPosition() const
{
	Initialize();
	return fPosition;
}

//----------------------------------------------------------------------------------------
// CResourceStreamRep_AC::SetPosition: 
//----------------------------------------------------------------------------------------

void CResourceStreamRep_AC::SetPosition(long newPosition )
{
	fPosition = newPosition;
}

//----------------------------------------------------------------------------------------
// CResourceStreamRep_AC::GetSize: 
//----------------------------------------------------------------------------------------

long CResourceStreamRep_AC::GetSize() const
{
	Initialize();
	return fSize;
}

//----------------------------------------------------------------------------------------
// CResourceStreamRep_AC::SetSize: 
//----------------------------------------------------------------------------------------

void CResourceStreamRep_AC::SetSize(long newSize)
{
	Initialize();
	::ThrowIfNULLResource_AC(fResource);
	SetResourceSize(fResource, newSize);
	::ThrowIfResError_AC();

	fSize = newSize;							// update if successfull

	if (newSize < fPosition)					// If we shrunk the size, then we have to adjust the position.
		fPosition = newSize;
}

//----------------------------------------------------------------------------------------
// CResourceStreamRep_AC::WriteBytes: 
//----------------------------------------------------------------------------------------

void CResourceStreamRep_AC::WriteBytes	(const void* p,
										long count)
{
#if qMSWindows
	#pragma unused (p, count)
	#pragma message ("CResourceStreamRep_AC::WriteBytes: Must be implemented.")
#else
	Initialize();
	::ThrowIfNULLResource_AC(fResource);
	register long minSize = GetPosition() + count;
	if (minSize > GetSize())
		SetSize(minSize);						// increase the size before writing
	::WritePartialResource(fResource, GetPosition(), p, count);
	::ThrowIfResError_AC();

	SetPosition(minSize);						// Advance the position. 
#endif
}

//----------------------------------------------------------------------------------------
// CResourceStreamRep_AC::ReadBytes: 
//----------------------------------------------------------------------------------------

void CResourceStreamRep_AC::ReadBytes(	void* p,
										long count)
{
#if qMSWindows
	#pragma unused (p, count)
	#pragma message ("CResourceStreamRep_AC::ReadBytes: Must be implemented.")
#else
	Initialize();
	::ThrowIfNULLResource_AC(fResource);
	register long minToRead = Min_AC(count, GetSize() - GetPosition());
	::ReadPartialResource(fResource, GetPosition(), p, minToRead);
	::ThrowIfResError_AC();

	SetPosition(GetPosition() + minToRead);		// Advance the position. 
#endif
}

//========================================================================================
// CLASS CResourceStream_AC
//========================================================================================

//----------------------------------------------------------------------------------------
// CResourceStream_AC constructor
//----------------------------------------------------------------------------------------

CResourceStream_AC::CResourceStream_AC(ResType theType,ResNumber theID)
	: CRandomAccessStream_AC(TH_new CResourceStreamRep_AC(theType, theID))
{
}

//----------------------------------------------------------------------------------------
// CRandomAccessStream_AC::CRandomAccessStream_AC
//----------------------------------------------------------------------------------------

CResourceStream_AC::CResourceStream_AC(CResourceStreamRep_AC* inRep)
	: CRandomAccessStream_AC(inRep)
{
}

//----------------------------------------------------------------------------------------
// End of CResourceStream_AC.cpp
