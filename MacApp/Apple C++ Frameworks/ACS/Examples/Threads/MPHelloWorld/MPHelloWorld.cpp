//----------------------------------------------------------------------------------------
// MPHelloWorld.cpp
// Copyright © 2000 by Apple Computer, Inc. All rights reserved.
//----------------------------------------------------------------------------------------

/*
	Change History:
		07/19/01	Added using std::printf.
		03/06/01	[PB] Check for Metrowerks before using SIOUX. 
		04/13/00	Turn off reference counting on stack based threads. 
		02/04/00	ACS version. 
*/

// ACS

#ifndef __CException_AC__
#include "CException_AC.h"
#endif

#ifndef __CMPQueue_AC__
#include "CMPQueue_AC.h"
#endif

#ifndef __CMPThread_AC__
#include "CMPThread_AC.h"
#endif

#if qTidyHeap
	#ifndef __CTidyHeap_AC__
	#include "CTidyHeap_AC.h"
	#endif
#endif

#ifndef __CMPFailure_AC__
#include "CMPFailure_AC.h"
#endif


// Toolbox

#ifndef __ERRORS__
#include <Errors.h>
#endif

#ifndef __MACTYPES__
#include <MacTypes.h>
#endif

#ifndef __MULTIPROCESSING__
#include <Multiprocessing.h>
#endif

// ANSI

#ifndef _STDIO_H
#include <stdio.h>
#endif

#ifdef __MWERKS__
	#ifndef __SIOUX__
	#include <SIOUX.h>
	#endif
#endif

using std::printf;

//========================================================================================
// Global Functions
//========================================================================================

static CMPQueue_AC& operator <<(CMPQueue_AC& queue, char *string)
// Send the string through the queue one character at a time.
{
	while (*string)
	{
		queue.Notify((void *) *string, 0, 0);
		string++;
	}

	queue.Notify((void *) '\0', 0, 0);			// Send the final null character. 

	return queue;
}

static CMPQueue_AC& operator >>(CMPQueue_AC& queue, char *string)
// Reassemble a string being transferred over the queue and return it to the caller.
{
	void *first;		// The first word of the message. 
	void *second;		// The second word of the message. 
	void *third;		// The third word of the message. 

	for (;;)
	{
		queue.Wait(&first, &second, &third, kDurationForever);
		*string = (char) first;

		if (*string == '\0')
			break;

		string++;
	}

	return queue;
}


#if qTidyHeap
CTidyHeap_AC* CreateTidyHeap()
{
	return new CTidyHeap_AC;
}
#endif


//========================================================================================
// CHelloTask
//========================================================================================

class CHelloTask : public CMPThread_AC
{
public:
	CHelloTask(CQueue& communicationQueue) :
		CMPThread_AC(),
		fCommunicationQueue(communicationQueue)
	{}
	virtual ~CHelloTask();
	
	virtual void Run();

	static int main();

private:
	CQueue&	fCommunicationQueue;
};

//----------------------------------------------------------------------------------------
// Destructor
//----------------------------------------------------------------------------------------

CHelloTask::~CHelloTask()
{
}

//----------------------------------------------------------------------------------------
// Run
//----------------------------------------------------------------------------------------

void CHelloTask::Run()
{
	fCommunicationQueue << "Hello, World!";
}

//----------------------------------------------------------------------------------------
// main
//----------------------------------------------------------------------------------------

int CHelloTask::main()
{
	CTempMPQueue_AC communicationQueue;	// This queue will be used to communicate between the app and the task. 
	communicationQueue.Create();	// Create the queue we'll use to communicate with. 

	CHelloTask hello(communicationQueue);
	hello.SetIsRefCountable(false);
	hello.Start();

	{
		char myString[100];
		communicationQueue >> myString;
		printf("%s\n", myString);
	}

	// Wait for the task to complete: 
	return hello.GetResult(5000);
}

//----------------------------------------------------------------------------------------
// main
//----------------------------------------------------------------------------------------

int main()
{
#ifdef __MWERKS__
	SIOUXSettings.asktosaveonclose = 0;
#endif

	int status = 0;

	if (!MPLibraryIsLoaded())
	{
		printf("Can't run without the \"%s\" shared library.\n", MPLibraryName);
		return 1;
	}

	try
	{
		status = CHelloTask::main();
	}
	catch (CException_AC& fi)
	{
		status = fi.GetError();
		printf("Exception: %d\n", status);
	}
	catch (...)
	{
	}

	if (status)
		printf("Error: %d\n", status);

#ifdef __MWERKS__
	printf("\nCommand-Q to Quit\n");
#endif

	return status;
}

//----------------------------------------------------------------------------------------
// End of MPHelloWorld.cpp
