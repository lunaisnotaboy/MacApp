/*
	Simple CFPreferences example program; reads/writes a preference.
	Author: Ali Ozer
	4/13/99

	Copyright (c) 1999-2001 by Apple Computer, Inc., all rights reserved.

	You may incorporate this sample code into your applications without
	restriction, though the sample code has been provided "AS IS" and the
	responsibility for its operation is 100% yours. However, what you are
	not permitted to do is to redistribute the source as "DSC Sample Code"
	after having made changes. If you're going to re-distribute the source,
	we require that you make it clear in the source that the code was
	descended from Apple Sample Code, but that you've made changes.
*/

/*
	Change History:
		02/27/01	Redesign so CF references point to CF objects. 
		01/18/01	Moved into ACS. 
		07/31/00	Use Carbon++ classes. 
*/

// CarbonPlus

#include "CCFAllocator_AC.h"
#include "CCFData_AC.h"
#include "CCFNumber_AC.h"
#include "CCFPreferences_AC.h"
#include "CCFString_AC.h"

// ANSI

#include <stdio.h>
#include <stdlib.h>


// This function will print the provided arguments (printf style varargs) out to the console.
// Note that the CFString formatting function accepts "%@" as a way to display CF types.
// For types other than CFString and CFNumber, the result of %@ is mostly for debugging
// and can differ between releases and different platforms.

static void show(CFStringRef formatString, ...)
{
	va_list argList;
	va_start(argList, formatString);

	CAutoCFString_AC resultString = __CFString::CreateWithFormatAndArguments(NULL, NULL, formatString, argList);
	va_end(argList);

	CAutoCFData_AC data = resultString->CreateExternalRepresentation(NULL, CFStringGetSystemEncoding(), '?');
	if (data != NULL)
	{
		printf ("%.*s\n\n", (int)data->GetLength(), data->GetBytePtr());
	}
}


// Read old high score, which is saved as a CFNumber under the key "High Score"; bump it up 
// and save it.

static void simplePreferencesExample()
{
	CCFPreferences_AC appPrefs(CFSTR("A Game"));
	CFStringRef highScoreKey(CFSTR("High Score"));

	// First retrieve the previous value...

	// CFPreferencesCopyAppValue() and CFPreferencesSetAppValue() are the most straightforward way
	// for an app to read/write preferences that are per user and per app; they will apply on all 
	// machines (on which this user can log in, of course --- for users who are local to a machine,
	// the preferences will end up being restricted to that host). These functions also do a search 
	// through the various cases; if a preference has been set in a less-specific domain (for 
	// instance, "all apps"), its value will be retrieved with this call. This allows globally 
	// setting some preference values (which makes more sense for some preferences than others).

	// Note that you can read/write any "property list" type in preferences; these are
	// CFArray, CFDictionary, CFNumber, CFBoolean, CFData, and CFString.
	// This example just shows CFNumber.

	int highScore;

	CAutoCFNumber_AC value = DynamicCast_AC<CFNumberRef>(appPrefs.CopyValue(highScoreKey));
	if (value)
	{
		// Numbers come out of preferences as CFNumbers.
		if (!value->GetInt(highScore))
			highScore = 0;

		show(CFSTR("The old high score was %d."), highScore);
	}
	else
	{
		// No previous value
		show(CFSTR("There is no old high score."));
		highScore = 0;
	}

	highScore += 5;

	show(CFSTR("Recording new high score, %d"), highScore);

	value = __CFNumber::CreateInt(highScore);

	appPrefs.SetValue(highScoreKey, value);

	// Without an explicit synchronize, the saved values actually do not get written out.
	// If you are writing multiple preferences, you might want to sync only after the last one.
	// A preference panel might want to synchronize when the user hits "OK".
	// In some cases you might not want to sync at all until the app quits.
	// The AppKit automatically synchronizes on app termination.

	appPrefs.Synchronize();
}


int main (int argc, const char *argv[])
{
#pragma unused (argc, argv)

	simplePreferencesExample();
	
	return 0;
}


