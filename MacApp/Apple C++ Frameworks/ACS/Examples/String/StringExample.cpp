/*
	Simple CFString example program.
	Author: Ali Ozer
	4/2/99

	Copyright (c) 1999-2001 by Apple Computer, Inc., all rights reserved.

	You may incorporate this sample code into your applications without
	restriction, though the sample code has been provided "AS IS" and the
	responsibility for its operation is 100% yours.  However, what you are
	not permitted to do is to redistribute the source as "DSC Sample Code"
	after having made changes. If you're going to re-distribute the source,
	we require that you make it clear in the source that the code was
	descended from Apple Sample Code, but that you've made changes.
*/

/*
	Change History:
		03/13/01	[PB] Cannot pass objects through '...'. 
		02/27/01	Redesign so CF references point to CF objects. 
		01/18/01	Moved into ACS. 
		07/13/00	Convenience constructors for auto-pointers. 
		07/12/00	Simplify string constructors. 
							GetDefault returns an object. 
		07/10/00	Allocators. 
		06/30/00	Use Carbon++ classes. 
*/

// CarbonPlus

#include "CCFAllocator_AC.h"
#include "CCFData_AC.h"
#include "CCFString_AC.h"

// ANSI

#include <stdio.h>
#include <stdlib.h>
#include <string.h>


// This function will print the provided arguments (printf style varargs) out to the console.
// Note that the CFString formatting function accepts "%@" as a way to display CF types.
// For types other than CFString and CFNumber, the result of %@ is mostly for debugging
// and can differ between releases and different platforms.

static void show(CFStringRef formatString, ...)
{
	va_list argList;
	va_start(argList, formatString);
	CAutoCFString_AC resultString(__CFString::CreateWithFormatAndArguments(NULL, NULL, formatString, argList));
	va_end(argList);

	CAutoCFData_AC data(resultString->CreateExternalRepresentation(NULL, '?'));
	if (data != NULL)
	{
		printf ("%.*s\n\n", (int)data->GetLength(), data->GetBytePtr());
	}
}

template<class T>
inline void show(CFStringRef formatString, const TemplateAutoRef_AC<T>& ref)
// This glue works around GCC not wanting to pass an object through '...'
// (even though the object has a perfectly good operator T() method)
{
	show(formatString, ref.get());
}


static void simpleStringExample()
{
	// Create a simple immutable string from a Pascal string and convert it to Unicode

	CAutoCFString_AC str("\pFoo Bar");

	// Create the Unicode representation of the string
	// "0", lossByte, indicates that if there's a conversion error, fail (and return NULL)

	CAutoCFData_AC data(str->CreateExternalRepresentation(NULL, kCFStringEncodingUnicode, 0));

	show(CFSTR("String	   : %@"), str);
	show(CFSTR("Unicode data : %@"), data);

	// Create a string from the Unicode data...

	str = __CFString::CreateFromExternalRepresentation(NULL, data, kCFStringEncodingUnicode);

	show(CFSTR("String Out   : %@"), str);

	// Create a string for which you already have some allocated contents which you want to 
	// pass ownership of to the CFString. The last argument, "NULL," indicates that the default allocator
	// should be used to free the contents when the CFString is freed (or you can pass in CFAllocatorGetDefault()).

	char *bytes = (char *) __CFAllocator::GetDefault()->Allocate(6, 0);
	strcpy(bytes, "Hello");

	str = __CFString::CreateWithCStringNoCopy(NULL, bytes, NULL);

	// Now create a string with a Pascal string which is not copied, and not freed when the string is
	// This is an advanced usage; obviously you need to guarantee that the string bytes do not go away
	// before the CFString does. 

	str = __CFString::CreateWithPascalStringNoCopy(NULL, "\pFoo Bar", kCFAllocatorNull);
}



static void stringGettingContentsAsCStringExample()
{
	// Create some test CFString
	// Note that in general the string might contain Unicode characters which cannot
	// be converted to a 8-bit character encoding

	CFStringRef str = __CFString::CreateWithCString(NULL, "Hello World");

	// First, the fast but unpredictable way to get at the C String contents...
	// This is O(1), meaning it takes constant time.
	// This might return NULL!

	const char *bytes = str->GetCStringPtr();

	// If that fails, you can try to get the contents by copying it out

	if (bytes == NULL)
	{
		// This might also fail, either if you provide a buffer that is too small, 
		// or the string cannot be converted into the specified encoding
		char localBuffer[10];
		bool success = str->GetCString(localBuffer, 10);
		(void) success;
	}
	
	// A pretty simple solution is to use a CFData; this frees you from guessing at the buffer size
	// But it does allocate a CFData...

	CFDataRef data = str->CreateExternalRepresentation(NULL, 0);
	if (data)
	{
		bytes = (const char *)data->GetBytePtr();
	}

	// More complicated but efficient solution is to use a fixed size buffer, and put a loop in

	CCFRange_AC rangeToProcess(0, str->GetLength());

	while (rangeToProcess.length > 0)
	{
		UInt8 localBuffer[100];
		CFIndex usedBufferLength = 0;
		CFIndex numChars = str->GetBytes(rangeToProcess, 0, FALSE, (UInt8 *)localBuffer, 100,
										 &usedBufferLength);

		if (numChars == 0) break;	// Means we failed to convert anything...

		// Otherwise we converted some stuff; process localBuffer containing usedBufferLength bytes
		// Note that the bytes in localBuffer are not NULL terminated
		
		// Update the remaining range to continue looping
		rangeToProcess.location += numChars;
		rangeToProcess.length -= numChars;
	}
}


static void stringGettingAtCharactersExample()
{
	// Create some test CFString

	CFStringRef str = __CFString::CreateWithCString(NULL, "Hello World");

	// The fastest way to get the contents; this might return NULL though
	// depending on the system, the release, etc, so don't depend on it 
	// (unless you used CFStringCreateMutableWithExternalCharactersNoCopy())

	const UniChar *chars = str->GetCharactersPtr();

	// If that fails, you can try copying the UniChars out
	// either into some stack buffer or some allocated piece of memory...
	// Using the former is fine, but you need to know the size; the latter
	// always works but requires allocating some memory; not too efficient.

	if (chars == NULL)
	{
		CFIndex length = str->GetLength();
		UniChar *buffer = (UniChar *) malloc(length * sizeof(UniChar));
		str->GetCharacters(CCFRange_AC(0, length), buffer);
		// Process the chars...
		free(buffer);
	}

	// You can use CFStringGetCharacterAtIndex() to get at the characters one at a time,
	// but doing a lot of characters this way might get slow...
	// An option is to use "inline buffer" functionality which mixes the convenience of
	// one-at-a-time char access with efficiency of bulk access

	{
		CFIndex length = str->GetLength();
		CCFStringInlineBuffer_AC inlineBuffer(str, CCFRange_AC(0, length));
		for (CFIndex cnt = 0; cnt < length; cnt++)
		{
			UniChar ch = inlineBuffer.GetCharacter(cnt);
			// Process character...
			(void) ch;
		}
	}
}


static void stringWithExternalContentsExample()
{
	enum { BufferSize = 1000 };

	// Allocate a contents store that is empty (but has space for BufferSize chars)...
	UniChar *myBuffer = (UniChar *) malloc(BufferSize * sizeof(UniChar));

	// Now create a mutable CFString which uses this buffer
	// The 0 and BufferSize indicate the length and capacity (in UniChars)
	// The kCFAllocatorNull indicates how the CFString should reallocate or free this buffer (in this case, do nothing)

	CAutoCFMutableString_AC mutStr(myBuffer, 0, BufferSize, kCFAllocatorNull);
	mutStr->Append(CFSTR("Appended string... "));
	mutStr->Append(CFSTR("More stuff... "));
	mutStr->AppendPascalString("\pA pascal string. ");
	mutStr->AppendFormat(NULL, CFSTR("%d %4.2f %@..."), 42, -3.14, CFSTR("Hello"));
	
	show(CFSTR("String: %@"), mutStr);

	free(myBuffer);

	// Now create a similar string, but give CFString the ability to reallocate or free the buffer
	// The last "NULL" argument specifies that the default allocator should be used
	// Here we provide an initial buffer of 32 characters, but if it grows beyond this, it's OK
	// (unlike the previous example, where if the string grew beyond 1000, it's an error)

	myBuffer = (UniChar *) __CFAllocator::GetDefault()->Allocate(32 * sizeof(UniChar), 0);
	mutStr = __CFString::CreateMutableWithExternalCharactersNoCopy(NULL, myBuffer, 0, 32, NULL);

	mutStr->Append(CFSTR("Appended string... "));
	mutStr->Append(CFSTR("Appended string... "));
	mutStr->Append(CFSTR("Appended string... "));
	mutStr->Append(CFSTR("Appended string... "));
	mutStr->Append(CFSTR("Appended string... "));

	show(CFSTR("String: %@"), mutStr);

	// Here we don't free the buffer, as CFString does that
}



int main ()
{
	simpleStringExample();
	stringGettingContentsAsCStringExample();
	stringGettingAtCharactersExample();
	stringWithExternalContentsExample();
	
	return 0;
}

