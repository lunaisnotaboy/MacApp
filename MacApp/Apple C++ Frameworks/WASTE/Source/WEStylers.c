/*
	WEStylers.c

	WASTE PROJECT
	Style objects

	Copyright © 1998-2001 by Apple Computer, Inc. All rights reserved.

	Portions based on WASTE:
	Copyright (c) 1993-1998 Marco Piovanelli. 
	All Rights Reserved
*/

/*
	Change History:
		12/09/99	Cosmetic. 
		11/22/99	Allow both stylers and objects to draw. 
		11/17/99	Streaming support for stylers. 
							Rename styler procs for clarity. 
		11/15/99	Add stylers. 
*/


#include "WASTEIntf.h"

#if WASTE_STYLERS

// static variables

static WEStylerHandlerTable _weStylerHandlerTable;



pascal FlavorType WEGetStylerType(WEStylerReference styler)
{
	return (*styler)->stylerType;
}

pascal Handle WEGetStylerDataHandle(WEStylerReference styler)
{
	return (*styler)->stylerDataHandle;
}

pascal WEHandle WEGetStylerOwner(WEStylerReference styler)
{
	return (*styler)->stylerOwner;
}

pascal SInt32 WEGetStylerRefCon(WEStylerReference styler)
{
	return (*styler)->stylerRefCon;
}

pascal void WESetStylerRefCon(WEStylerReference styler, SInt32 stylerRefCon)
{
	(*styler)->stylerRefCon = stylerRefCon;
}

pascal SInt32 _WELookupStylerType(FlavorType stylerType)
{
	// look for a WEStylerHandlerEntry record for the specified styler kind
	// in the given styler table

	SInt32 nEntries, index;
	WEStylerHandlerEntry *pTable;

	// do nothing if the Style Handler Table has not been inited yet
	if (_weStylerHandlerTable == nil)
	{
		return kUnknownObjectType;
	}

	// calculate entry count
	nEntries = GetHandleSize((Handle) _weStylerHandlerTable) / sizeof(WEStylerHandlerEntry);

	// scan the Style Handler Table looking for a type match
	pTable = *_weStylerHandlerTable;
	for ( index = 0; index < nEntries; index++ )
	{
		if (pTable->stylerType == stylerType)
		{
			return index;
		}
		pTable++;
	}

	return kUnknownObjectType;
}

pascal OSErr _WEGetIndStylerType(SInt32 index, FlavorType *stylerType)
{
	SInt32 nEntries;

	*stylerType = 0L;

	// index must be non-negative
	if (index < 0)
	{
		return weUnknownObjectTypeErr;
	}

	// calculate number of entries in the global handler table
	nEntries = 0;
	if (_weStylerHandlerTable != nil)
	{
		nEntries = GetHandleSize((Handle) _weStylerHandlerTable) / sizeof(WEStylerHandlerEntry);
	}

	// return an error code if index is too large
	if (index >= nEntries)
	{
		return weUnknownObjectTypeErr;
	}

	*stylerType = (*_weStylerHandlerTable)[index].stylerType;

	return noErr;
}

pascal OSErr WENewStyler(FlavorType stylerType, Handle stylerDataHandle, WEHandle hWE,
						 WEStylerReference *styler)
{
	SInt32 index;
	OSErr err = noErr;

	*styler = nil;

	// look up the specified styler type in the global handler table
	index = _WELookupStylerType(stylerType);
	if (index == kUnknownObjectType)
	{
		err = weUnknownObjectTypeErr;
		goto bail;
	}

	// create a new relocatable block to hold the styler descriptor
	err = _WEAllocate(sizeof(WEStyler), kAllocClear, (Handle *)styler);
	if (err != noErr)
		goto bail;

	// fill in the styler descriptor
	{
		WEStyler *pDesc = **styler;

		pDesc->stylerType = stylerType;
		pDesc->stylerOwner = hWE;
		pDesc->stylerRefCon = 0;
		pDesc->stylerDataHandle = stylerDataHandle;
		pDesc->stylerIndex = index;
	}

	// Add the styler to its owner table
	_WEInsertStyler(*styler);

	// Give the styler a chance to initialize itself
	if (_weStylerHandlerTable != nil)
	{
		WEStylerNewUPP stylerNew = (*_weStylerHandlerTable)[index].stylerNew;

		// call the new handler, if any
		if (stylerNew != nil)
		{
			err = CallWEStylerNewProc(*styler, stylerNew);
		}
	}

bail:
	return err;
}

pascal OSErr WEDisposeStyler(WEStylerReference styler)
{
	WEStyler *pDesc;
	OSErr err = noErr;

	// sanity check: do nothing if we have a null descriptor handle
	if (styler == nil)
	{
		return nilHandleErr;
	}

	// Remove the styler from its owner table
	_WERemoveStyler(styler);

	// lock the descriptor record
	HLock((Handle)styler);
	pDesc = *styler;

	if (_weStylerHandlerTable != nil)
	{
		WEStylerDisposeUPP stylerDispose = (*_weStylerHandlerTable)[pDesc->stylerIndex].stylerDispose;

		// call the dispose handler, if any
		if (stylerDispose != nil)
		{
			err = CallWEStylerDisposeProc(styler, stylerDispose);
		}
	}

	// if styler kind is unknown or there's no custom dispose handler, use DisposeHandle
	_WEForgetHandle(&pDesc->stylerDataHandle);

	// finally, dispose of the styler descriptor itself
	DisposeHandle((Handle)styler);

	return err;
}

pascal OSErr _WEInsertStyler(WEStylerReference styler)
{
	OSErr err = noErr;

	if (styler)
	{
		WEHandle hWE = WEGetStylerOwner(styler);
		if (hWE)
		{
			// create the styler table, if it doesn't exist
			WEStylerTable hStylers = (*hWE)->hStylers;
			if (hStylers == nil)
			{
				hStylers = (WEStylerTable) NewHandle(0);
				if ((err = MemError()) != noErr)
				{
					return err;
				}
				(*hWE)->hStylers = hStylers;
			}

			err = _WESplice((Handle) hStylers, &styler, sizeof(WEStylerReference), -1);
		}
	}

	return err;
}

pascal OSErr _WERemoveStyler(WEStylerReference styler)
{
	OSErr err = noErr;

	if (styler)
	{
		WEHandle hWE = WEGetStylerOwner(styler);
		if (hWE)
		{
			WEStylerTable hStylers = (*hWE)->hStylers;
			if (hStylers != nil)
			{
				SInt32 index = 0;
				SInt32 nEntries = GetHandleSize((Handle) hStylers) / sizeof(WEStylerReference);
				for (index = 0; index < nEntries; ++index)
				{
					if ((*hStylers)[index] == styler)
					{
						err = _WESplice((Handle) hStylers, NULL, -sizeof(WEStylerReference), index * sizeof(WEStylerReference));
						break;
					}
				}
			}
		}
	}

	return err;
}

pascal OSErr _WEResetStylers(WEStylerTable hStylers)
{
	OSErr err = noErr;

	if (hStylers != nil)
	{
		SInt32 index = GetHandleSize((Handle) hStylers) / sizeof(WEStylerReference);
		while (--index >= 0)
		{
			WEStylerReference styler = (*hStylers)[index];
			WEDisposeStyler(styler);
		}
	}

	return err;
}

pascal Boolean _WEDrawStyler(Ptr pText, SInt32 textLength, Fixed slop, JustStyleCode styleRunPosition, 
							 WEStylerReference styler)
{
	Boolean handled = false;
	WEStyler *pDesc;
	Boolean saveDescLock;

	// lock the styler descriptor
	saveDescLock = _WESetHandleLock((Handle)styler, true);
	pDesc = *styler;

	if (_weStylerHandlerTable != nil)
	{
		WEStylerDrawUPP stylerDraw = (*_weStylerHandlerTable)[pDesc->stylerIndex].stylerDraw;

		// call the drawing handler, if any
		if (stylerDraw != nil)
		{
			handled = CallWEStylerDrawProc(pText, textLength, slop, styleRunPosition, styler, stylerDraw);
		}
	}

	// unlock the styler descriptor
	_WESetHandleLock((Handle)styler, saveDescLock);

	return handled;
}

pascal Boolean _WEClickStyler(Point hitPt, EventModifiers modifiers, UInt32 clickTime,
							  WEStylerReference styler)
{
	WEStyler *pDesc;
	Boolean saveDescLock;
	Boolean clickHandled = false;

	// lock the styler descriptor
	saveDescLock = _WESetHandleLock((Handle)styler, true);
	pDesc = *styler;

	if (_weStylerHandlerTable != nil)
	{
		WEStylerClickUPP stylerClick = (*_weStylerHandlerTable)[pDesc->stylerIndex].stylerClick;

		// call the click handler, if any
		if (stylerClick != nil)
		{
			clickHandled = CallWEStylerClickProc(hitPt, modifiers, clickTime, styler, stylerClick);
		}
	}

	// unlock the styler descriptor
	_WESetHandleLock((Handle)styler, saveDescLock);

	return clickHandled;
}

pascal OSErr _WEStreamStyler(SInt16 destKind, FlavorType *theType, Handle *theData, 
							 Boolean *canDisposeData, WEStylerReference styler)
{
	WEStyler *pDesc;
	Boolean saveDescLock;
	OSErr err = weNotHandledErr;

	*canDisposeData = true;

	// lock the styler descriptor
	saveDescLock = _WESetHandleLock((Handle)styler, true);
	pDesc = *styler;

	{
		WEStylerStreamUPP streamHandler = (*_weStylerHandlerTable)[pDesc->stylerIndex].stylerStream;

		// call the stream handler, if any
		if (streamHandler != nil)
		{
			err = CallWEStylerStreamProc(destKind, theType, *theData, styler, streamHandler);
		}
	}

	if (err == weNotHandledErr)
	{
		// default streaming behavior
		_WEForgetHandle(theData);
		*canDisposeData = false;
		*theType = pDesc->stylerType;
		*theData = pDesc->stylerDataHandle;
		err = noErr;
	}

	// unlock the styler descriptor
	_WESetHandleLock((Handle) styler, saveDescLock);

	return err;
}

pascal OSErr _WESoupStyler(WESoupHandle *hStylerSoup, const WERunInfoPriv *info, SInt32 offset)
{
	// if info describes an embedded styler, copy a new styler descriptor,
	// complete with the associated styler data, to a new soup handle.

	WEStylerReference styler = info->runAttrs.runStyle.tsStyler;
	Handle hStylerData = nil;
	Boolean disposeData = false;
	OSErr err = noErr;

	*hStylerSoup = nil;

	if (styler != nil)
	{
		FlavorType stylerType;
		WESoup soup;

		// create a temporary handle for the streaming callback
		if ((err = _WEAllocate(0, kAllocTemp, &hStylerData)) != noErr)
		{
			goto cleanup;
		}

		// get the styler type/data
		if ((err = _WEStreamStyler(weToSoup, &stylerType, &hStylerData, &disposeData, styler)) != noErr)
		{
			goto cleanup;
		}

		// fill in a soup item
		BLOCK_CLR(soup);
		soup.soupOffset = offset;
		soup.soupType = stylerType;
		// hack: the styler has a length like a run of text instead
		// of a dimension like an object
		*(long *)&soup.soupSize = info->runEnd - info->runStart;
		soup.soupDataSize = GetHandleSize(hStylerData);

		// move it to the soup handle
		if ((err = _WEAllocate(sizeof(soup), kAllocTemp, hStylerSoup)) != noErr)
		{
			goto cleanup;
		}

		BlockMoveData(&soup, **hStylerSoup, sizeof(soup));

		// append the actual styler data to the soup handle
		{
			Boolean saveDataLock = _WESetHandleLock(hStylerData, true);
			err = _WESplice(*hStylerSoup, *hStylerData, soup.soupDataSize, -1);
			_WESetHandleLock(hStylerData, saveDataLock);
		}
	} // if styler reference is not nil

cleanup:
	if (disposeData)
	{
		_WEForgetHandle(&hStylerData);
	}

	return err;
}

pascal OSErr _WEGetStylerEntry(FlavorType stylerType, SInt32 *index)
{
	OSErr err = noErr;

	*index = kUnknownObjectType;

	// create the handler table, if it doesn't exist
	if (_weStylerHandlerTable == nil)
	{
		_weStylerHandlerTable = (WEStylerHandlerTable) NewHandle(0);
		if ((err = MemError()) != noErr)
		{
			return err;
		}
	}

	// look for the entry corresponding to the specified styler type
	if ((*index = _WELookupStylerType(stylerType)) == kUnknownObjectType)
	{
		WEStylerHandlerEntry entry;
		BLOCK_CLR(entry);
		entry.stylerType = stylerType;

		// previously unknown styler type: append a new entry at the end of the handler table
		*index = GetHandleSize((Handle) _weStylerHandlerTable) / sizeof(WEStylerHandlerEntry);
		err = _WESplice((Handle) _weStylerHandlerTable, &entry, sizeof(entry), -1);
	}

	return err;
}

pascal OSErr WEInstallStylerNewProc(FlavorType stylerType, WEStylerNewUPP stylerNew)
{
	OSErr err;
	SInt32 index;

	err = _WEGetStylerEntry(stylerType, &index);
	if (err == noErr)
	{
		(*_weStylerHandlerTable)[index].stylerNew = stylerNew;
	}

	return err;
}

pascal OSErr WEInstallStylerComputeProc(FlavorType stylerType, WEStylerComputeUPP stylerCompute)
{
	OSErr err;
	SInt32 index;

	err = _WEGetStylerEntry(stylerType, &index);
	if (err == noErr)
	{
		(*_weStylerHandlerTable)[index].stylerCompute = stylerCompute;
	}

	return err;
}

pascal OSErr WEInstallStylerDrawProc(FlavorType stylerType, WEStylerDrawUPP stylerDraw)
{
	OSErr err;
	SInt32 index;

	err = _WEGetStylerEntry(stylerType, &index);
	if (err == noErr)
	{
		(*_weStylerHandlerTable)[index].stylerDraw = stylerDraw;
	}

	return err;
}

pascal OSErr WEInstallStylerClickProc(FlavorType stylerType, WEStylerClickUPP stylerClick)
{
	OSErr err;
	SInt32 index;

	err = _WEGetStylerEntry(stylerType, &index);
	if (err == noErr)
	{
		(*_weStylerHandlerTable)[index].stylerClick = stylerClick;
	}

	return err;
}

pascal OSErr WEInstallStylerStreamProc(FlavorType stylerType, WEStylerStreamUPP stylerStream)
{
	OSErr err;
	SInt32 index;

	err = _WEGetStylerEntry(stylerType, &index);
	if (err == noErr)
	{
		(*_weStylerHandlerTable)[index].stylerStream = stylerStream;
	}

	return err;
}

pascal OSErr WEInstallStylerDisposeProc(FlavorType stylerType, WEStylerDisposeUPP stylerDispose)
{
	OSErr err;
	SInt32 index;

	err = _WEGetStylerEntry(stylerType, &index);
	if (err == noErr)
	{
		(*_weStylerHandlerTable)[index].stylerDispose = stylerDispose;
	}

	return err;
}

pascal OSErr WESetStyler(WEStylerReference styler, WEHandle hWE)
{
	WEStyleMode mode;
	WETextStyle ts;

	mode = weDoStyler;
	BLOCK_CLR(ts);
	ts.tsStyler = styler;
	
	if (styler && (_weStylerHandlerTable != nil))
	{
		WEStylerComputeUPP stylerCompute = (*_weStylerHandlerTable)[(*styler)->stylerIndex].stylerCompute;
		if (stylerCompute != nil)
		{
			CallWEStylerComputeProc(&mode, (TextStyle *)&ts, styler, stylerCompute);
		}
	}

	return WESetStyle(mode, (TextStyle *)&ts, hWE);
}


pascal OSErr _WEPrependStyler(WESoupHandle hSoup, const WERunInfoPriv *info, SInt32 offsetDelta)
{
	// if info describes an embedded styler, prepend a new styler descriptor,
	// complete with the associated styler data, to the specified soup.
	// in any case, advance all character offsets in the soup by offsetDelta

	WESoupHandle hStylerSoup = nil;
	OSErr err;

	err = _WESoupStyler(&hStylerSoup, info, 0);
	if (err != noErr)
		goto cleanup;

	err = _WEPrependSoup(hSoup, hStylerSoup, offsetDelta);

cleanup:
	_WEForgetHandle(&hStylerSoup);

	return err;

}

pascal OSErr _WEAppendStyler(WESoupHandle hSoup, const WERunInfoPriv *info, SInt32 offset)
{
	// if info describes an embedded styler, append a new styler descriptor,
	// complete with the associated styler data, to the specified soup.

	WESoupHandle hStylerSoup = nil;
	OSErr err;

	err = _WESoupStyler(&hStylerSoup, info, offset);
	if (err != noErr)
		goto cleanup;

	// append the styler soup to the soup handle
	err = _WEAppendSoup(hSoup, hStylerSoup);

cleanup:
	_WEForgetHandle(&hStylerSoup);

	return err;

}


#endif  // WASTE_STYLERS